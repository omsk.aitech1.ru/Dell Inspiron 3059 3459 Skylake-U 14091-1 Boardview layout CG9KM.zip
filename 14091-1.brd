# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_TXP2: length 61.3
  TOP w0.102: GPU1.AD30 88.59,110.41 88.59,112.15 87.91,112.84 83.64,112.84 76.75,119.72 74.92,119.72 74.77,119.88 74.34,119.88 v3(74.2,120.02) ; v3(61.63,147.57) 61.88,147.83 62.07,147.83 C12344.1
  BOTTOM w0.102: 59.56,138.23 59.56,127.33 67.23,119.66 73.57,119.66 73.92,120.02 v3(74.2,120.02) ; 59.56,138.23 59.56,146.12 61.32,147.88 61.5,147.88 61.63,147.75 v3(61.63,147.57) ; 59.56,138.23 v2(59.88,138.23)
PEG_TXP3: length 63.6
  TOP w0.102: GPU1.AC29 88.37,109.6 88.5,109.73 88.5,109.93 88.37,110.06 88.03,110.06 87.86,110.28 87.86,110.51 88,110.88 88.07,111.15 88.07,111.67 87.6,112.14 83.46,112.14 77.24,118.36 76.11,118.36 v3(75.73,118.75) ; C12336.1 60.61,149.67 60.61,149.35 v3(60.87,149.1)
  BOTTOM w0.102: 72.65,118.52 75.5,118.52 v3(75.73,118.75) ; 72.65,118.52 67.5,118.52 58.94,127.08 58.94,134.14 58.08,134.99 58.08,145.53 60.45,147.89 60.76,148.21 60.76,149 v3(60.87,149.1) ; 72.65,118.52 v2(72.65,118.85)
PHASE1_R: length 18.5
  TOP w0.254: PR45.2 117.64,98.3 v3(117.51,98.42) ; PG4.1 v3(118.91,86.11)
  L3 w0.254: v3(118.91,86.11) 117.7,86.11 117.44,86.36 117.44,97.09 116.75,97.79 116.75,98.9 116.9,99.06 117.38,99.06 117.51,98.93 v3(117.51,98.42)
  BOTTOM w0.254: v3(118.91,86.11) v2(118.02,86.11)
PIRQA#: length 11.6
  TOP w0.102: R80080.2 99.21,143.84 99.21,144.77 99.6,145.16 99.6,148.34 98.7,149.23 v1(98.31,149.23) 97.94,149.61 95.82,149.61 94.61,150.81 CPU1.BB11
PLTRST#_PCH: length 31.1
  TOP w0.102: v4(88.27,149.63) 88.6,149.96 CPU1.AN10
  BOTTOM w0.102: R80052.1 v2(104.63,129.15) 103.41,130.37 103.41,133.41 91.28,145.54 88.96,145.54 88.17,146.33 88.17,149.53 v4(88.27,149.63)
PLTRST*_EC: length 3.3
  TOP w0.102: U4101.6 98.73,56.66 99.17,57.1 v1(99.35,57.1) 99.4,57.15 R79697.1
PLTRST*_SIO: length 5.9
  TOP w0.102: U109.46 127.38,57.77 127.36,57.79 v1(127.25,57.79) 127.11,57.79 127.11,57.78 127.08,57.78 126.35,57.05 126.32,57.05 125.99,56.72 125.99,56.7 125.88,56.58 C180.1 R251.1 R256.1
PLTRST_CR: length 129.7
  TOP w0.102: v4(177.83,147.07) 177.83,150.03 171.4,156.46 164.12,156.46 v4(163.67,156.02)
  BOTTOM w0.102: v4(163.67,156.02) 163.53,155.88 v2(163.53,153.72) 163.53,151.12 161.06,148.64 161.06,144.9 160.31,144.15 160.31,123.46 156.41,119.56 145.61,119.56 144.86,118.81 144.86,87.93 145.78,87.02 145.78,71.65 145.8,71.63 145.8,62.91 146.09,62.61 RN2.4 ; v4(177.83,147.07) 177.71,146.94 U14.1
PLTRST_LAN_N: length 139.6
  TOP w0.102: v3(34.83,15.46) U16.19
  L3 w0.127: v3(142.93,58.67) 143.63,57.98 143.63,52.89 142.94,52.2 141.86,52.2 140.24,50.58 140.24,47.72 138.78,46.27 137.35,46.27 133.88,42.8 128.05,42.8 v3(126.14,40.89)
  L4 w0.127: v3(126.14,40.89) 126.65,40.39 126.65,39.75 123.35,36.45 122.86,36.45 122.48,36.07 118.53,36.07 116.79,34.33 114.76,34.33 105.29,24.85 87.1,24.85 86.3,24.05 69.92,24.05 69.12,24.85 63.49,24.85 57.26,18.62 45.3,18.62 44.52,19.39 43.94,19.39 42.96,18.41 38.01,18.41 35.05,15.46 v3(34.83,15.46)
  BOTTOM w0.102: v3(142.93,58.67) 143.64,59.39 v2(143.64,59.84) 143.64,59.99 143.81,60.16 143.81,61.48 144.28,61.95 RN2.1
PLTRST_N: length 438.6
  TOP w0.102: R79697.2 101.89,57.15 102.9,56.13 v3(102.9,54.23) ; v3(165.01,130.81) 163.86,129.67 158.4,129.67 v4(157.89,129.16) ; R256.2 123.46,55.69 122.64,56.52 120.42,56.52 118.27,54.37 118.27,52.66 116.33,50.72 109.71,50.72 v3(109.38,51.05)
  L3 w0.127: v3(165.01,130.81) 166.11,131.91 166.11,199.3 164.61,200.8 160.17,200.8 153.2,207.77 101.3,207.77 100.87,207.34 94.06,207.34 93.63,207.77 84.55,207.77 81.91,210.42 81.91,224.72 79.93,226.69 58.87,226.69 58.23,226.06 50.72,226.06 50.33,226.45 31.41,226.45 v3(30.39,225.43) ; v3(102.9,54.23) 103.67,54.23 104.3,53.59 106.04,53.59 LPC1.3 108.58,51.05 v3(109.38,51.05) ; v4(157.89,129.16) 153.07,124.33 124.9,124.33 123.22,126.01 106.92,126.01 v3(105.87,124.97)
  BOTTOM w0.102: v3(109.38,51.05) 107.98,52.45 107.98,56.91 111.49,60.41 111.49,60.74 111.89,61.14 112.49,61.14 113.42,62.07 113.42,62.51 118.76,67.84 120.49,67.84 121.75,69.11 121.75,69.28 v2(124.49,72.02) 125.73,73.25 137.37,73.25 138.41,74.3 138.41,74.38 139.33,75.29 139.33,119.93 141.22,121.82 155.33,121.82 157.89,124.38 v4(157.89,129.16) ; R80052.2 106.78,127.74 C12350.1 105.89,126.85 R80051.1 105.89,124.98 v3(105.87,124.97) ; v3(30.39,225.43) 30.2,225.43 R9930.1
PLTRST_SL_N: length 125.3
  TOP w0.102: D7.1 D7.2 87.38,81.95 88.16,81.17 89.33,81.17 v3(89.95,81.79) ; R1160.2 98.44,106.21 R1159.1 99.66,107.44 101.25,107.44 v3(101.26,107.45) 101.62,107.45 102.52,108.35 102.52,109.03 D34.3
  L4 w0.127: v3(145.07,71.86) 144.44,71.23 137.82,71.23 137.61,71.03 128.77,71.03 125.95,68.21 104.21,68.21 100.49,71.93 100.49,75.31 95.54,80.26 91.47,80.26 v3(89.95,81.79)
  BOTTOM w0.102: RN2.3 145.44,71.48 v3(145.07,71.86) ; v3(89.95,81.79) 90.41,81.33 95.61,81.33 96.2,81.92 96.2,85.01 v2(95.89,85.32) 96.5,85.32 97.06,85.88 97.06,86.77 97.16,86.88 97.16,87.11 102.09,92.04 102.09,106.62 v3(101.26,107.45)
PM_CLKRUN#_EC: length 188.2
  TOP w0.102: v3(104.62,50.74) 104.56,50.8 104.49,50.8 103.41,51.88 103.41,56.13 101.86,57.68 98.92,57.68 98.29,57.06 U4101.7
  L3 w0.127: v4(157.01,130.94) 155.13,129.06 146.78,129.06 146.46,128.74 131.38,128.74 131.04,129.08 114.99,129.08 111.03,133.04 111.03,135.76 v3(107.86,138.94)
  BOTTOM w0.102: v3(107.86,138.94) 107.35,139.45 R80212.1 ; v3(104.62,50.74) 106.08,52.2 106.08,55.51 111.13,60.56 111.13,60.88 111.74,61.49 112.34,61.49 113.06,62.22 113.06,62.65 121.25,70.84 v2(122.08,70.84) 124.85,73.61 137.22,73.61 138.06,74.44 138.06,74.52 138.97,75.44 138.97,120.07 141.07,122.17 155.19,122.17 157.01,123.99 v4(157.01,130.94)
PM_DPRSLPVR: length 6.3
  TOP w0.102: PR7.1 135.48,103.82 v3(134.65,103) 133.39,101.73 U9.39
  BOTTOM w0.102: PR15.2 134.65,104.2 v2(134.65,103.84) v3(134.65,103)
PM_PCH_PWROK: length 50.6
  TOP w0.089: CPU1.BA20 93.86,155.65 94.53,154.99 95.31,154.99
  TOP w0.102: 95.31,154.99 99.9,154.99 100.78,155.86 RN9504.3 102.2,156.29 102.24,156.33 104.17,156.33 112.4,148.11 112.4,131.67 111.62,130.89 111.62,127.06 109.65,125.09 v3(109.65,124.41) 109.65,122.76 R80045.2
  BOTTOM w0.102: v2(110.47,124.41) v3(109.65,124.41)
PM_PWRBTN_N: length 430.2
  TOP w0.089: 96.96,151.68 96.72,151.92 96.15,151.92 95.09,152.97 94.05,152.97 93.91,153.11 CPU1.BA15
  TOP w0.102: 96.96,151.68 96.98,151.66 101.79,151.66 102.03,151.9 103.33,151.9 103.92,151.32 103.92,144.81 106.74,141.99 107.42,141.99 108.31,141.1 108.31,134.95 v3(107.86,134.49) ; v3(119.54,46.61) 119.54,46.98 R333.1 120.68,47.64 121.17,47.14 121.69,47.14 122.16,46.67 122.16,46.52 122.53,46.15 124.72,46.15 125.18,46.61 R334.2 ; R9926.2 v3(18.83,225.93)
  L3 w0.127: v3(18.83,225.93) 20.35,227.46 117.38,227.46 118.14,226.69 118.14,211.58 121.19,208.53 154.63,208.53 156.41,206.76 160.05,206.76 v3(160.18,206.88)
  L4 w0.127: v3(107.86,134.49) 108.36,134.49 110.38,132.47 110.74,132.47 111.7,132.47 128.33,115.85 134.37,115.85 136.71,115.85 140,119.14 140.74,119.14 v3(141.13,118.75)
  BOTTOM w0.102: v3(160.18,206.88) v2(160.18,202.18) 160.18,196.47 160.89,195.76 160.89,184.05 160.94,184 160.94,151.22 158.77,149.05 158.77,145.31 158.4,144.94 158.4,124.25 155.62,121.46 142.27,121.46 141.13,120.32 v3(141.13,118.75) 140.04,117.65 140.04,74.21 139.41,73.58 139.26,73.58 138.07,72.39 136.76,72.39 136.61,72.54 132.16,72.54 122.72,63.09 122.72,55.53 121.78,54.59 121.78,48.84 v3(119.54,46.61)
PM_RSMRST_PWRGD_XDP: length 20.8
  TOP w0.102: XDP1.39 29.33,216.1 28.37,217.07 27.8,217.07 27.21,217.66 27.21,217.71 26.48,218.44 19.43,218.44 18.07,219.81 18.07,223.96 R9903.2 R9904.2 16.09,223.63 v1(16.09,223.27)
PM_SLP_S3#_R: length 4
  TOP w0.102: SCA1.34 70.51,72.4 v3(70.52,72.39)
  BOTTOM w0.102: R79789.2 72.11,72.39 v2(71.53,72.39) v3(70.52,72.39)
PORTC_SPK_L: length 31.6
  TOP w0.203: v3(162.34,80.52) 162.39,80.46 U6.43 ; C12332.1 v3(159.01,58.29)
  L3 w0.203: v3(159.01,58.29) 159.65,58.93 161.15,58.93 161.83,59.61 161.83,63.75 166.25,68.17 166.25,72.1 165.21,73.15 165.21,79.48 164.17,80.52 v3(162.34,80.52)
  BOTTOM w0.203: v3(159.01,58.29) v2(158.2,58.29)
PORTC_SPK_L_1: length 2.8
  TOP w0.203: C12332.2 157.34,58.43 157.34,59.26 v1(157.18,59.41) 156.83,59.41 156.12,58.7 R384.1
PORTC_SPK_R: length 33.7
  TOP w0.203: U6.44 161.99,80.1 v3(161.58,80.52) ; C12331.1 v3(159.77,58.29)
  L3 w0.203: v3(159.77,58.29) 161.34,58.29 162.47,59.42 162.47,63.5 166.83,67.87 166.83,72.35 165.79,73.39 165.79,79.76 164.42,81.13 162.11,81.13 161.73,80.75 161.73,80.67 v3(161.58,80.52)
  BOTTOM w0.203: v3(159.77,58.29) v2(160.59,58.29)
PORTC_SPK_R_1: length 2.5
  TOP w0.203: R383.1 161.86,59.28 v1(161.45,59.28) 161.45,59.26 161.4,59.21 161.4,58.41 C12331.2
PQ4206_D: length 3.7
  TOP w0.152: PQ4206.D 89.7,37.08 v1(89.44,36.83) 88.93,36.32 88.93,35.18
PQ4406_2: length 3.6
  BOTTOM w0.152: PR4462.2 v2(25.69,62.74) PQ5008.2
PQ4406_3: length 3.7
  BOTTOM w0.152: PQ5008.3 25.04,63.23 24.67,62.87 v2(24.67,61.72) PR4455.2
PQ4406_5: length 3.8
  BOTTOM w0.152: PR8522.2 24.73,68.71 PC4426.1 v2(25.81,67.69) 25.81,67.31 25.69,67.18 PQ5008.5
PQ4406_6: length 5.9
  BOTTOM w0.152: PQ5008.6 26.34,67.45 26.45,67.56 26.45,69.02 PR4450.1 v2(26.96,70.48) 26.07,70.48 PC4426.2
PQ4409_C: length 16.2
  TOP w0.152: v3(34.07,52.07) 34.64,52.64 PQ4409.C
  BOTTOM w0.152: v3(34.07,52.07) 33.77,52.07 v2(33.36,52.48) 31.97,53.87 28,53.87 27.49,54.38 26.72,54.38 25.86,55.24 25.86,56.52 26.32,56.98 26.32,58.42 26,58.74 PR4451.1 PR4462.1
PQ4409_E: length 6.2
  TOP w0.152: PR8523.2 35.59,55.56 v1(35.59,55.18) 36.29,54.48 PR8524.1 36.29,50.77 PQ4409.E
PRE: length 6.3
  TOP w0.102: U118.16 132.55,38.92 132.54,38.93 132.54,39.42 132.62,39.5 v3(132.62,39.88)
  BOTTOM w0.102: R2088.2 131.45,41.57 v2(131.45,40.85) 131.65,40.85 v3(132.62,39.88) 132.49,39.75 R2090.1
PROC_SELECT#: length 12.2
  TOP w0.089: 70.26,181.87 71.19,180.93 72.61,180.93 CPU1.C64
  TOP w0.102: 70.26,181.87 69.54,182.59 69.54,185.31 68.23,186.61 66.15,186.61 v1(65.69,187.07) 65.5,186.88 R603.1
PROCHOT#_CPU: length 12
  TOP w0.089: CPU1.C65 72.75,181.55 72.31,181.11 71.29,181.11 69.73,182.67 69.73,182.78
  TOP w0.102: 69.73,182.78 69.73,185.81 R403.2 68.94,187.67 68.94,188.54 v3(68.66,188.82)
  BOTTOM w0.102: v2(68.66,187.96) v3(68.66,188.82)
PRW_VGA_CORE_RBIAS: length 5.6
  TOP w0.203: 133.59,105.1 133.59,104.9 133.18,104.5 132.76,104.5 132.2,103.94 131.66,103.94 131.29,103.57 131.28,103.57 131.15,103.43 131.15,103.43 131.08,103.36 U9.3
  TOP w0.254: 133.59,105.1 133.59,105.63 v1(133.62,105.67) 133.59,105.7 133.59,106.16 PR9.1
PS_0: length 13.6
  TOP w0.102: GPU1.AC19 88.53,102.13 89.14,102.13 89.39,101.88 89.39,101.74 89.69,101.45 90.65,101.45 91.26,100.84 92.63,100.84 93,100.47 93,100.2 93.38,99.82 93.38,99.56 95.08,97.85 v1(96.14,97.85) 96.55,97.85 C1847.1 R80084.1 R80083.1
PS_1: length 13.9
  TOP w0.102: R943.1 R948.1 C1849.2 96.78,95.31 v1(96.21,95.89) 96.21,96.06 93.84,98.42 93.31,98.42 93,98.74 93,98.87 92.74,99.13 91.04,99.13 90.97,99.07 90.46,99.07 90.2,99.33 90.2,100.66 89.85,101.02 89.78,101.02 GPU1.AD19
PS_2: length 15.3
  TOP w0.102: R1900.1 R1899.1 C1850.1 96.7,93.41 v1(96.2,92.91) 95.66,93.45 95.66,95.4 93.47,97.6 92.93,97.6 92.62,97.92 92.62,98.05 92.24,98.42 90.97,98.42 90.71,98.68 90.05,98.68 89.47,99.26 89.47,99.6 89.8,99.93 GPU1.AE17
PS_3: length 11.8
  TOP w0.102: R935.2 99.47,99.25 R940.1 98.01,99.25 C1848.1 96.93,99.57 v1(96.2,99.57) 94.9,99.57 93.38,101.09 93.38,101.32 93.1,101.6 92.49,101.6 91.66,102.43 90.65,102.43 90.07,103 GPU1.AE20
PSI#: length 7.9
  TOP w0.102: v3(134.65,106.05) 134.2,105.59 134.2,104.93 133.48,104.22 132.95,104.22 132.39,103.66 131.85,103.66 131.48,103.29 U9.2 ; v3(134.65,106.05) PR3.1 ; v3(134.65,106.05) 134.65,106.63 134.4,106.88 v1(134.27,106.88)
  BOTTOM w0.102: PR3.1 v3(134.65,106.05)
PSID_D: length 4.9
  BOTTOM w0.102: Q47.D 55.21,35.18 L15.2 v2(53.7,33.91) 52.87,33.91 52.74,34.04 R1852.1
PSID_D_1: length 3.9
  BOTTOM w0.102: R1852.2 51.69,35.75 Q45.B 51.44,34.07 R1853.1 v2(51.4,33.01)
PSID_G: length 5.5
  BOTTOM w0.102: Q47.G 54.04,38.45 v2(54.01,38.48) 53.63,38.86 R1849.2 Q45.C
PSYS: length 3.7
  BOTTOM w0.203: 21.93,203.84 22.61,203.15 PU4601.50
  BOTTOM w0.254: 21.93,203.84 21.09,203.84 v2(21.01,203.91) 20.11,203.91 PR4612.2
PW_CLEAR: length 74.8
  TOP w0.102: PSWD1.2 126.53,113.28 v1(127.54,112.27) 128.49,111.32 R151.1 ; v4(81.27,148.28) 80.95,148.28 CPU1.U7
  L4 w0.127: v4(81.27,148.28) 81.89,147.66 81.89,146.65 79.57,144.34 79.57,133.92 87.18,126.32 88.22,126.32 88.59,125.95 111.42,125.95 123.6,113.77 PSWD1.2
PWM_SW_EN: length 44.5
  TOP w0.102: Q9614.2 50.07,56.01 50.33,56.26 50.33,56.77 50.71,57.15 52.1,57.15 52.23,57.02 52.23,56.13 52.1,56.01 ; v1(68.36,83.82) 67.91,83.38 R79205.1 67.08,82.68 63.83,79.43 62.85,79.43 60.12,76.7 SCA1.54 60.12,74.82 59.98,74.68 59.98,74.04 61.58,72.44 61.58,69.55 56.68,64.64 56.68,57.91 55.86,57.1 55.86,56.2 55.47,55.8 55.1,55.8 54.84,55.55 52.56,55.55 52.1,56.01 ; Q9614.5 52.1,56.01
PWR_0D95V_VGA_EN: length 3.9
  TOP w0.102: PR8514.2 PC8409.1 v1(110.59,101.85) 110.59,102.17 109.86,102.9 PU8401.5
PWR_0D95V_VGA_FB: length 6.8
  TOP w0.254: PU8401.6 112.96,101.88 112.56,101.47 PR8405.1 PC8401.2 PR8403.2 PR8401.1 115.6,101.73 v1(116.37,102.49)
PWR_0D95V_VGA_FB_R1: length 17.1
  TOP w0.254: PR8403.1 PC8401.1 113.57,99.31 112.88,98.63 102.7,98.63 101.25,100.08 v1(101.25,100.46) 101.58,100.79 PG8401.2
PWR_0D95V_VGA_FB_R2: length 3.4
  TOP w0.254: PC8402.1 111.54,99.69 v3(111.79,99.44) 112.17,99.44 112.56,99.82 PR8405.2
  BOTTOM w0.254: v2(110.9,99.44) v3(111.79,99.44)
PWR_0D95V_VGA_LX: length 0.9
  BOTTOM w0.508: v3(108.76,105.24) 108.75,105.23 v2(108.75,104.39)
PWR_0D95V_VGA_PG: length 4.9
  TOP w0.102: PR8513.1 PR8404.2 108.06,101.97 v1(108.06,102.62) 108.06,102.82 109.13,103.89 PU8401.4
PWR_0D95V_VGA_PVIN: length 1.6
  TOP w0.508: PR8402.1 116.62,104.39 v1(116.87,104.14)
PWR_0D95V_VGA_SVIN: length 3.6
  TOP w0.305: PR8402.2 PU8401.8
  TOP w0.508: PR8402.2 PC8408.1 v1(114.52,102.36)
PWR_1D0V_BOOT: length 3.2
  TOP w0.508: PR5210.1 24.77,147.6 v3(25.18,147.19)
  BOTTOM w0.305: PU5201.10 25.2,147.22 v3(25.18,147.19)
  BOTTOM w0.508: v3(25.18,147.19) 25.18,147.09 25.81,146.46 v2(25.81,146.43)
PWR_1D0V_BOOT_R: length 4.7
  TOP w0.508: PR5210.2 24.77,151.18 25.33,151.74 v1(25.99,151.74) 26.63,151.74 PC5206.2
PWR_1D0V_CS: length 6.5
  BOTTOM w0.254: PU5201.2 21.21,148.6 20.12,147.52 20.12,146 v2(20.2,145.92) 21.43,145.92 22.25,145.11 PR5219.1
PWR_1D0V_EN: length 6.1
  TOP w0.102: PR5218.2 22.82,149.85 PC5207.1 PR5217.2 21.71,150.09 v1(20.58,150.09) 20.58,149.48 v3(20.96,149.11)
  BOTTOM w0.102: v3(20.96,149.11) 20.97,149.1 PU5201.3
PWR_1D0V_FB: length 7.4
  TOP w0.254: v3(20.99,152.4) 21.5,152.91 PR5207.1 PR5208.2 PC5203.2
  BOTTOM w0.254: v3(20.99,152.4) 20.3,151.71 v2(20.3,150.93) 20.3,150.52 21.22,149.6 PU5201.4
PWR_1D0V_FB_R: length 39.7
  TOP w0.254: PR5208.1 PC5203.1 22.85,155.09 23.48,155.09 v1(23.73,154.84) 23.73,154 v3(23.66,153.92) ; PG5202.2 51.21,156.08 51.85,156.72 v3(52.87,156.72)
  L4 w0.254: v3(52.87,156.72) 51.21,158.37 26.2,158.37 23.66,155.83 v3(23.66,153.92)
PWR_1D0V_LGATE: length 12.6
  L4 w0.762: v5(31.46,155.96) 28.45,155.96 27.8,155.3 27.8,153.14 v5(25.56,150.9)
  BOTTOM w0.305: PU5201.6 25.2,150.55 v5(25.56,150.9)
  BOTTOM w0.762: PU5203.4 v5(31.46,155.96) v2(30.44,155.96)
PWR_1D0V_PG: length 5.3
  TOP w0.102: PR5212.2 PR8510.1 23.27,146.56 v3(23.66,146.94)
  BOTTOM w0.102: PU5201.1 22.11,146.63 v2(22.21,146.53) 23.25,146.53 v3(23.66,146.94)
PWR_1D0V_PHASE: length 17.6
  TOP w0.508: PC5206.1 26.5,149.4 v5(26.32,149.22)
  L4 w0.762: v5(26.32,149.22) 26.9,149.22 29.37,146.76 29.37,146.71 30.28,145.8 38.9,145.8 v5(39.78,144.91)
  BOTTOM w0.305: PU5201.8 26.2,149.1 v5(26.32,149.22)
  vias: v2(40.72,145.77) v2(41.66,155.47) v5(38.01,149.35) v5(38.97,149.35) v5(39.91,149.35) v5(39.91,147.75) v5(39.91,146.79) v5(40.29,156.01) v5(40.29,155.04) v5(40.27,154.13) v5(41.33,152.88) v5(41.33,151.92) v5(41.31,151)
PWR_1D0V_RF: length 3.9
  TOP w0.254: v3(20.99,151.51) 21.37,151.89 PR5202.1
  BOTTOM w0.254: v3(20.99,151.51) 21.24,151.76 v2(22.11,151.76) PU5201.5
PWR_1D0V_SNB: length 2.7
  BOTTOM w0.508: PC5205.1 33.09,149.87 v2(33.43,150.22) 34.27,150.22 PR5214.2
PWR_1D0V_UGATE: length 19.2
  L4 w0.762: v5(26.32,147.83) 26.32,147.63 29.55,144.4 38.26,144.4 39.15,143.51 v5(39.78,143.51)
  BOTTOM w0.305: PU5201.9 25.81,148.6 26.32,148.08 v5(26.32,147.83)
  BOTTOM w0.508: v5(26.32,147.83) v2(27.21,147.83)
  BOTTOM w0.762: PU5202.4 v5(39.78,143.51)
PWR_1D8V: length 1.3
  TOP w0.254: PG5302.1 103.92,73.79
  TOP w0.508: PG5301.1 107.35,76.89
  vias: v1(105.37,75.29)
PWR_1D8V_BOOT: length 3.6
  TOP w0.203: PU5301.10 118.41,73.47 117.99,73.05
  TOP w0.508: 117.99,73.05 117.43,72.49 v1(117.43,71.93) 116.87,71.37 PR5301.1
PWR_1D8V_BOOT_A: length 3.5
  TOP w0.508: PR5301.2 116.37,68.96 v1(115.78,68.38) 115.1,69.06 PC5301.1
PWR_1D8V_EN: length 5.7
  TOP w0.203: PU5301.13 119.94,72.85 120.64,72.16
  TOP w0.254: 120.64,72.16 120.93,71.87 120.93,71.67 121.32,71.27 121.36,71.27 C12368.1 121.51,70.74 PR8516.2 121.51,68.61 v1(121.5,68.6)
PWR_1D8V_FB: length 5.1
  TOP w0.203: 119.54,72.69 PU5301.12
  TOP w0.254: 119.54,72.69 120.13,72.11 v1(120.13,71.78) 120.42,71.49 120.42,71.46 120.56,71.32 PC5304.2 PR5305.2 PR5302.1
PWR_1D8V_FB_1: length 21.4
  TOP w0.254: v3(120.56,69.06) PC5304.1 PR5305.1 ; PG5302.2 v3(103.92,71.75)
  L3 w0.254: v3(103.92,71.75) 105.06,71.75 105.19,71.88 117.74,71.88 v3(120.56,69.06)
  BOTTOM w0.254: v3(103.92,71.75) v2(103.92,72.57)
PWR_1D8V_LX: length 5.4
  TOP w0.508: PR5303.1 113.55,70.41 113.57,70.43 v1(113.57,70.61) 113.57,70.71 114.23,71.37 PC5301.2 115.35,71.63 115.35,73.03
PWR_1D8V_PG: length 4.7
  TOP w0.102: PR8515.1 121.95,78.24 v1(121.9,78.19) 121.3,78.19 PR5304.2 119.94,77.55 PU5301.4
PWR_1D8V_SNB: length 3.4
  TOP w0.508: PR5303.2 110.88,69.01 110.88,70.41 v1(110.62,70.66) 109.56,70.66 PC5302.1
PWR_1D8V_VBYP: length 4.6
  TOP w0.203: 120.99,76.39 PU5301.3
  TOP w0.254: PR5306.2 122.97,78.36 122.29,77.69 122.28,77.69 v3(121.33,76.73) 120.99,76.39
  BOTTOM w0.254: v2(122.21,76.71) 121.36,76.71 v3(121.33,76.73)
PWR_1D8V_VCC: length 3.5
  TOP w0.203: v1(118.81,71.86) 118.81,72.37 119.14,72.7 PU5301.11
  TOP w0.508: v1(118.81,71.86) 118.5,71.86 117.86,71.23 117.86,71.16 PC5308.1
PWR_1D8V_VOUT: length 33.2
  TOP w0.203: 118.74,77.66 PU5301.7
  TOP w0.254: PG5301.2 107.35,79.02 v3(107.48,79.15) ; 118.74,77.66 118.74,77.69 119.54,78.49 PC5312.2 119.3,78.98 PR5313.2 118.7,78.41 v3(118.47,78.18)
  BOTTOM w0.254: v3(107.48,79.15) 107.48,72.14 108.11,71.5 v2(111.82,71.5) 117.89,71.5 120.43,74.04 120.43,77.98 120.05,78.36 118.65,78.36 v3(118.47,78.18)
PWR_1D8V_VOUT_1: length 3.2
  TOP w0.254: PR5312.2 117.51,79.76 v1(117.64,79.88) 118.69,79.88 PR5313.1 118.84,80.01 PC5312.1
PWR_1D35V_VGA_EN: length 7.4
  TOP w0.102: PU8501.8 98.71,70.36 99.75,69.32 100.85,69.32 101.43,68.73 v1(102.01,68.73) 103.16,68.73 103.5,68.39 PR8505.2 PC12187.1
PWR_1D35V_VGA_FB_M: length 15.2
  TOP w0.254: PC12189.2 PR8504.2 PR8503.1 88.88,76.72 88.88,77.38 v1(88.97,77.47) 89.06,77.47 89.09,77.44 89.38,77.44 89.95,76.88 89.95,75.56 91.47,74.04 91.47,69.47 91.85,69.09 PU8501.2
PWR_1D35V_VGA_FB_M1: length 4.2
  TOP w0.254: PR8504.1 86.9,77.76 86.53,78.13 v1(86.42,78.13) 85.89,77.6 PC12189.1 PR8502.1
PWR_1D35V_VGA_PG: length 11.2
  TOP w0.102: PU8501.7 98.92,69.09 99.04,68.96 100.54,68.96 101.33,68.17 103.21,68.17 104.28,67.11 v1(104.77,67.11) 104.86,67.11 105.82,68.07 PC12185.1 PR8518.2 PR8501.2
PWR_3D3V_BOOT2: length 2.9
  TOP w0.203: PU4501.7 153.09,24.56 v1(153.75,25.22)
  TOP w0.508: PR4501.1 153.75,26.05 v1(153.75,25.22)
PWR_3D3V_BOOT2_1: length 4.2
  TOP w0.508: PR4501.2 152.62,27.09 v3(152.31,27.41) 151.65,28.07 PC4508.1
  BOTTOM w0.508: v2(152.31,28.32) v3(152.31,27.41)
PWR_3D3V_ENTRIP2: length 4.6
  TOP w0.203: PU4501.4 155.75,22.63 v3(155.86,22.73)
  BOTTOM w0.254: PR4535.1 PC4512.1 155.42,23.18 v3(155.86,22.73) 155.99,22.86 v2(155.99,23.62)
PWR_3D3V_FB: length 42.5
  TOP w0.254: v3(156.75,25.91) PR4504.1 156.51,25.08 155.93,24.5 PC4502.1
  L3 w0.254: v3(156.75,25.91) 156.75,21.87 156.4,21.51 156.4,21.5 156.08,21.18 156.07,21.18 154.21,19.33 154.21,18.46 146.93,11.18 142.91,11.18 139.61,7.87 132.62,7.87 131.2,9.3 v3(131.2,10.29)
  BOTTOM w0.254: v3(131.2,10.29) 131.2,11.23 131.43,11.46 v2(131.61,11.46) 131.81,11.46 132.06,11.2 PG4501.2
PWR_3D3V_FB2: length 5.3
  TOP w0.203: 155,23.27 154.76,23.03 PU4501.5
  TOP w0.254: v1(158.88,24.54) 158.54,24.19 PR4503.1 PR4504.2 156.24,23.69 155.81,23.69 PC4502.2 155.39,23.27 155,23.27
PWR_3D3V_LDO3: length 4.3
  TOP w0.203: PU4501.15 150.77,21.42 150.45,21.11
  TOP w0.254: PG4506.1 149.56,19.13 v1(149.82,19.38) 150.45,20.02 150.45,21.11
PWR_3D3V_LGATE2: length 18.1
  TOP w0.203: v5(151.16,23.75) 151.19,23.78 PU4501.10
  L3 w0.762: v5(136.69,21.72) 137.32,21.72 138.08,22.48 138.08,23.49 138.84,24.26 149.39,24.26 149.89,23.75 v5(151.16,23.75)
  BOTTOM w0.508: v5(151.16,23.75) 151.06,23.75 150.86,23.95 v2(150.25,23.95)
PWR_3D3V_PHASE2: length 33.2
  TOP w0.203: 152.05,24.77 152.29,24.53 PU4501.9
  TOP w0.508: PC4508.2 151.04,26.04 v5(151.04,25.4) 151.42,25.4 152.05,24.77
  L3 w0.762: v5(151.04,25.4) 148.5,27.94 136.56,27.94 133.26,24.64 133.26,20.78 130.84,18.37 v5(130.84,17.27)
  BOTTOM w0.508: v5(151.04,25.4) v2(150.41,26.03)
  vias: v2(136.2,15.95) v5(131.61,16.38) v5(132.62,17.27) v5(133.26,16.38) v5(134.27,17.27) v5(134.78,16.38) v5(135.8,17.27)
PWR_3D3V_SNB: length 3.5
  BOTTOM w0.508: PC12184.1 PR5498.2 138.62,16.97 v2(139.58,16)
PWR_3D3V_UGATE2: length 36.1
  TOP w0.203: PU4501.8 v5(152.69,25.4)
  L3 w0.762: v5(152.69,25.4) 152.43,25.65 152.43,25.98 149.07,29.34 135.98,29.34 131.86,25.22 131.86,21.46 129.45,19.05 129.45,17.53 v5(129.19,17.27)
  BOTTOM w0.508: v5(152.69,25.4) 152.71,25.4 153.04,25.73 153.5,25.73 v2(153.55,25.68)
PWR_5V3D3V_ENLDO: length 3.2
  TOP w0.203: 149.99,23.19 150.56,22.63 PU4501.12
  TOP w0.254: PR4511.2 149.56,23.19 v1(149.59,23.22) 149.61,23.19 149.99,23.19
PWR_5V3D3V_TON: length 3.5
  TOP w0.203: PU4501.3 156.55,22.23
  TOP w0.254: PR4515.1 156.76,22.31 156.62,22.17 v1(156.62,22.15) 156.55,22.23
PWR_5V3V_PGOOD: length 5.4
  TOP w0.102: PR4509.2 154.66,26.72 155.66,25.72 v1(155.66,25.5) 155.09,24.93 155.09,24.5 154.36,23.78 PU4501.6
PWR_5V3V_SECFB: length 5.4
  TOP w0.203: PU4501.13 v3(150.02,22.23)
  TOP w0.254: v3(150.02,22.23) 148.23,22.23 PR4508.2
  BOTTOM w0.254: v3(150.02,22.23) 149.03,22.23 v2(149,22.2) 148.37,21.56 PR4599.1
PWR_5V_BOOT1: length 3.1
  TOP w0.203: 153.32,19.68 153.09,19.92 PU4501.19
  TOP w0.508: 153.32,19.68 153.6,19.41 v1(153.6,19.28) 153.6,19.15 153.64,19.11 PR4513.1
PWR_5V_BOOT1_1: length 2.9
  TOP w0.508: PR4513.2 152.75,16.75 v1(152.48,16.48) 152.46,16.51 PC4514.2
PWR_5V_BYP1: length 29.5
  TOP w0.203: 153.7,20.07 153.49,20.28 PU4501.20
  TOP w0.254: PC4528.1 155.44,19.37 154.9,19.91 153.86,19.91 153.7,20.07 ; PC4528.1 155.74,18.61 PC4503.1 155.85,18.34 v1(154.62,18.34) 154.59,18.36 154.59,18.92 v3(154.85,19.18) ; PC4528.1 PR4518.1 ; PG4532.2 v3(145.88,4.06)
  L3 w0.254: v3(154.85,19.18) 154.85,18.34 151.16,14.66 151.16,8 150.91,7.75 146.97,7.75 145.88,6.65 v3(145.88,4.06)
PWR_5V_ENTRIP1: length 4.5
  TOP w0.203: v3(155.86,21.72) 155.75,21.82 PU4501.2
  BOTTOM w0.254: PR4506.1 PC4513.1 155.42,22.16 v3(155.86,21.72) 156.01,21.56 v2(156.01,20.9)
PWR_5V_FB1: length 5.8
  TOP w0.203: 155.35,20.83 154.76,21.42 PU4501.1
  TOP w0.254: PR4519.1 157.77,21.11 v1(157.67,21.21) 157.08,21.21 156.75,20.88 PR4518.2 PC4528.2 155.74,20.45 155.35,20.83
PWR_5V_LDO: length 5
  TOP w0.203: PU4501.14 150.34,21.82 149.93,21.41
  TOP w0.508: 149.93,21.41 149.59,21.07 v1(149.59,20.93) 148.52,20.93 PC4505.1 148.09,21.08 147.29,21.88 PR4508.1
PWR_5V_LGATE1: length 10.2
  TOP w0.203: v5(151.16,20.7) 151.19,20.67 PU4501.16
  L3 w0.762: v5(142.92,21.59) 143.81,20.7 v5(151.16,20.7)
  BOTTOM w0.508: v5(151.16,20.7) v2(151.16,21.59)
PWR_5V_PHASE1: length 9.8
  TOP w0.203: PU4501.17 152.29,19.81 152.17,19.69
  TOP w0.508: PC4514.1 v5(151.04,19.05) 151.52,19.05 152.17,19.69
  L3 w0.762: v5(146.34,17.27) 149.26,17.27 v5(151.04,19.05)
  BOTTOM w0.508: v5(151.04,19.05) v2(150.41,18.42)
  vias: v2(142.96,16.31) v5(139.86,17.27) v5(140.5,16.38) v5(140.88,17.27) v5(141.51,16.38) v5(141.89,17.27) v5(145.45,16.76)
PWR_5V_SNB: length 3.7
  TOP w0.508: PC4504.1 138.34,18.31 137.75,18.9 v1(137.29,18.9) 137.09,18.69 137.09,17.65 PR4435.2
PWR_5V_UGATE1: length 13.4
  TOP w0.203: PU4501.18 v5(152.69,19.05)
  L3 w0.762: v5(144.43,17.27) 144.43,16.26 144.81,15.88 149.84,15.88 152.69,18.73 v5(152.69,19.05)
  BOTTOM w0.508: v2(152.69,19.94) v5(152.69,19.05)
PWR_CHG_ACDET: length 7.4
  TOP w0.254: PC4401.1 PR4409.1 45.5,41.97 45.82,41.66 PR4424.2 44.08,41.15 v1(44.05,41.12) 43.98,41.2 v3(43.98,42.16)
  BOTTOM w0.254: PU4404.6 43.32,42.82 v3(43.98,42.16)
PWR_CHG_ACN: length 21.7
  TOP w0.254: v3(48.77,46.83) 47.91,46.83 PC4408.1 ; PG4402.2 v3(61.09,43.94)
  BOTTOM w0.254: v3(61.09,43.94) 60.86,43.71 60.37,43.71 59.93,44.15 ; v2(60.23,44.45) 59.93,44.15 ; 59.93,44.15 58.23,45.85 57.36,45.85 56.25,46.96 48.9,46.96 v3(48.77,46.83) 48.48,46.55 46.96,46.55 PC4413.2 44.98,46.21 PU4404.1
PWR_CHG_ACP: length 21.7
  TOP w0.254: PG4401.2 61.96,42.34 v3(61.12,43.18) ; PC4410.1 48.28,46.04 v3(48.8,46.04)
  BOTTOM w0.254: v2(58.28,44.73) 58.54,45 ; 58.54,45 58.07,45.47 57.2,45.47 56.09,46.58 49.34,46.58 v3(48.8,46.04) 46.32,46.04 PC4413.1 45.25,45.85 45.11,45.71 PU4404.2 ; 58.54,45 60.21,43.33 60.97,43.33 v3(61.12,43.18)
PWR_CHG_AD_OFF: length 27.3
  TOP w0.102: U4101.19 95.32,60.52 v3(95.16,60.35) ; PQ4206.G PR4210.1 92.11,41.27 v3(91.98,41.4)
  BOTTOM w0.102: R80231.1 95.09,60.41 v3(95.16,60.35) 95.16,60.33 95.49,59.99 95.49,59.13 94.85,58.5 94.85,57.71 95.66,56.9 95.66,53.34 94.01,51.69 94.01,50.93 91.98,48.9 v2(91.98,45.21) v3(91.98,41.4)
PWR_CHG_AD_OFF_R: length 4.7
  TOP w0.152: PR4210.2 v1(92.11,37.21) 92.11,36.83 92.25,36.69 PQ4204.B
PWR_CHG_BT_LR:
  vias: v1(36.2,63.35)
PWR_CHG_BTST: length 4.4
  TOP w0.508: v1(41.13,46.86) 41.13,47.06 v3(40.6,47.59)
  BOTTOM w0.305: PU4404.17 41.82,47.52 41.59,47.75 41.06,47.75 40.9,47.59 v3(40.6,47.59) 40.6,47.96 41.24,48.6 PR4425.1
PWR_CHG_BTST_1: length 6.1
  BOTTOM w0.508: v2(37.63,50.09) 37.63,49.91 38.7,48.84 PD4401.K 40.28,48.77 PR4425.2 40.36,48.96 40.57,49.17 40.57,49.27 40.8,49.5 40.9,49.5 40.93,49.53 42.04,49.53 PC4415.1
PWR_CHG_CMPIN: length 16.3
  TOP w0.254: PR4408.1 46.58,42.99 47.28,43.69 v3(47.28,44.32) 47.4,44.2 PR4411.2 PR4428.1
  BOTTOM w0.254: PU4404.4 44.6,44.71 45.17,44.15 46.9,44.15 47.07,44.32 v3(47.28,44.32) ; PR4420.2 48.23,44.32 v3(47.28,44.32) ; v3(47.28,44.32) 47.28,43.69 46.77,43.18 46.77,41.66 v2(47.18,41.25) 46.01,40.08 44.22,40.08 PR4405.2
PWR_CHG_CMPIN_R: length 9.2
  TOP w0.254: PQ4401.6 57.04,42.56 56.78,42.82 56.78,43.29 55.92,44.15 v1(55.2,44.15) 55.2,44.2 54.95,44.45 52.23,44.45 51.21,45.47 50.03,45.47 PR4428.2
PWR_CHG_CMPIN_RR: length 8.6
  TOP w0.254: PQ4401.3 54.52,41.26 54.24,41.54 54.24,43.66 53.95,43.94 52.02,43.94 51.28,44.68 v1(51.06,44.68) 51.04,44.65 50.24,44.65 PR4411.1
PWR_CHG_HIDRV: length 16.9
  L3 w0.762: v5(42.32,48.08) 42.07,48.34 42.07,49.02 42.58,49.53 44.26,49.53 45.65,50.92 45.65,54.23 44.48,55.4 v5(44.48,58.53)
  BOTTOM w0.305: PU4404.18 v5(42.32,48.08)
  BOTTOM w0.406: v5(44.48,58.53) 44.48,58.51 44.19,58.21 PU4401.4
  BOTTOM w0.508: v5(44.48,58.53) v2(44.48,59.49)
PWR_CHG_ILIM: length 8.3
  TOP w0.254: PQ4402.D 38.07,43.18 PR4407.2 38.58,42.1 39.17,41.5 v1(39.33,41.5) 39.66,41.83 39.66,42.7 v3(39.94,42.98) 39.59,43.32 PR4416.1
  BOTTOM w0.254: PU4404.10 40.37,43.41 v3(39.94,42.98)
PWR_CHG_IOUT: length 5.8
  TOP w0.254: v3(42.83,42.16) 43.59,42.93 PC4412.1
  BOTTOM w0.254: PU4404.7 42.82,42.17 v3(42.83,42.16) 42.96,42.04 PR4431.1 PR4405.1 45.03,41.21 45.22,41.02 v2(45.22,41)
PWR_CHG_LODRV: length 11.8
  TOP w0.508: PC4409.1 39.12,47.24 v5(39.45,46.91)
  L3 w0.762: v5(39.45,46.91) 39.45,47.07 37.5,49.02 v5(37.5,52.96)
  BOTTOM w0.305: PU4404.15 39.88,46.21 39.53,46.56 39.53,46.84 v5(39.45,46.91)
  BOTTOM w0.406: PU4402.4 37.79,53.25 v5(37.5,52.96)
  BOTTOM w0.508: v5(37.5,52.96) v2(37.5,51.99)
PWR_CHG_NC: length 2.9
  BOTTOM w0.254: PU4404.11 40.13,44.21 v2(39.15,43.23) 38.69,43.69 PR4422.1
PWR_CHG_PHASE: length 20.4
  L3 w0.762: v5(43.34,48.08) 44.78,48.08 47.05,50.35 47.05,54.84 45.88,56.01 45.88,59.11 45.06,59.93 43.9,59.93 43.09,59.11 v5(43.09,58.67)
  BOTTOM w0.305: PU4404.19 42.82,47.57 v5(43.34,48.08)
  BOTTOM w0.508: PC4415.2 43.98,48.72 v5(43.34,48.08)
  vias: v2(38.64,60.43) v5(38.01,58.67) v5(39.02,58.67) v5(40.04,58.67) v5(41.05,58.67) v5(42.07,58.67)
PWR_CHG_SRN: length 2.6
  BOTTOM w0.254: PR4423.1 38.9,44.7 v2(39.15,44.45) 39.15,44.48 39.39,44.71 PU4404.12
PWR_CHG_SRN_1: length 27.7
  TOP w0.254: PG4403.2 v3(37.63,66.67)
  BOTTOM w0.254: PR4423.2 36.42,44.7 PC4411.1 35.4,44.64 PC4405.2 34.65,45.26 34.65,45.99 34.04,46.6 34.04,49.84 35.85,51.64 35.85,65.05 36.38,65.59 ; v3(37.63,66.67) 37.63,66.22 37.37,65.97 36.76,65.97 36.38,65.59 ; 36.38,65.59 v2(36.15,65.81)
PWR_CHG_SRP: length 3.4
  BOTTOM w0.254: PR4406.1 38.45,45.72 38.5,45.67 v2(38.51,45.67) 38.51,45.66 38.98,45.19 39.62,45.19 39.65,45.21 PU4404.13
PWR_CHG_SRP_1: length 24.8
  TOP w0.254: PG4404.2 v3(37.63,64.9)
  BOTTOM w0.254: 36.23,63.45 36.23,64.9 36.92,65.58 37.37,65.58 37.63,65.33 v3(37.63,64.9) ; 36.23,63.45 36.23,51.49 34.42,49.68 34.42,46.76 35.09,46.1 PC4405.1 35.67,46.1 36.05,45.72 PR4406.2 ; 36.23,63.45 v2(36.56,63.45)
PWR_CHG_VCC: length 8.8
  TOP w0.762: v3(46.9,48.51) 45.3,48.51 PC4418.1
  BOTTOM w0.305: 44.09,47.18 43.92,47.01 PU4404.20
  BOTTOM w0.508: 44.09,47.18 45.19,48.29 v2(45.19,48.51) 46.77,48.51
  BOTTOM w0.762: PR4403.2 45.93,49.48 v3(46.9,48.51) 46.77,48.51
PWR_DCBATOUT_1D0V:
  vias: v2(29.14,144.02) v5(30.23,148.08) v5(30.23,147.07) v5(31.15,148.08) v5(31.15,147.07)
PWR_DCBATOUT_1D8V:
  vias: v1(125.03,70.51)
PWR_DCBATOUT_3D3V:
  vias: v2(126.75,22.91) v5(129.45,22.99) v5(130.46,22.99)
PWR_DCBATOUT_5V:
  vias: v2(148.32,26.72) v5(145.07,22.99) v5(146.08,22.99)
PWR_DCBATOUT_VDDQ: length 7.9
  BOTTOM w0.254: PR5101.1 79,215.61 79,217.93 v2(79.38,218.31) 79.59,218.52 82.02,218.52 83.04,219.53 PR5121.2
  vias: v2(88.76,221.46) v5(84.46,221.77) v5(84.46,220.85) v5(85.38,221.77) v5(85.38,220.85)
PWR_LED_YELLOW_C: length 16.3
  TOP w0.254: v3(24.42,19.87) 24.74,20.19 26.07,20.19 26.63,20.75 PWRCN1.9 30.82,20.75 v1(31.53,21.46) 31.97,21.91 R1761.1
  BOTTOM w0.254: Q1212.D 24.32,14.64 v2(24.32,15.27) 24.67,15.62 R1751.2 23.91,17.53 23.91,19.36 v3(24.42,19.87)
PWR_LED_YELLOW_C2: length 3.2
  BOTTOM w0.254: R1751.1 26.2,15.44 v2(26.3,15.34) 26.7,15.34 27.36,16 R724.2
PWR_V1P8A_EN: length 5.3
  TOP w0.102: PR5257.2 89.63,120.27 PR5245.1 PC5228.1 87.65,120.33 v1(87.36,120.62) 87.36,121.53 87.14,121.74 PU5302.8
PWR_V1P8A_FB: length 5.3
  TOP w0.254: PC5226.2 PR1689.2 PR5242.1 94.97,122.75 v1(94.09,123.62) 94.01,123.7 PU5302.2
PWR_V1P8A_PG: length 5.3
  TOP w0.102: PR5246.2 84.41,124.97 84.74,125.3 PC5229.1 ; PR5246.2 85.03,124.65 v1(85.38,124.31) 85.99,123.7 PU5302.7 ; PR5246.2 R1689.2
PWR_VCC_CSN_SA: length 65.9
  TOP w0.254: v3(41.69,168.53) PR4610.2 41.44,167.96 41.44,164.47 41.82,164.08 PG5002.1
  L4 w0.254: v3(18.42,199.69) 18.45,199.67 18.52,199.67 18.65,199.54 18.67,199.54 19.36,198.85 19.36,194.45 17.23,192.32 17.23,180.36 18.09,179.49 18.09,177.03 25.3,169.82 39.15,169.82 40.45,168.53 v3(41.69,168.53)
  BOTTOM w0.203: PU4601.45 22.1,201.15
  BOTTOM w0.254: 22.1,201.15 22,201.24 20.64,201.24 20.46,201.42 19.34,201.42 PC4607.1 19.27,199.96 PC4626.2 18.47,199.64 v3(18.42,199.69) ; v2(40.96,168.88) 41.31,168.53 v3(41.69,168.53)
PWR_VCCGT_BSTA: length 5
  BOTTOM w0.203: 29.24,204.98 28.85,204.59 PU4601.14
  BOTTOM w0.508: PR4601.2 31.45,207.65 30.28,206.47 v2(30.28,205.92) 30.19,205.92 29.24,204.98
PWR_VCCGT_BSTA_R: length 3.7
  BOTTOM w0.508: PC4601.1 34.17,206.38 34.58,206.78 v2(34.58,207.42) 34.35,207.65 PR4601.1
PWR_VCCGT_BSTB: length 3.4
  BOTTOM w0.203: PU4601.22 29.48,200.75 29.75,200.48 v2(30.77,200.48)
  BOTTOM w0.508: PR4667.1 31.71,200.48 v2(30.77,200.48)
PWR_VCCGT_BSTB_R: length 2.6
  BOTTOM w0.508: PR4667.2 PC4634.1 33.54,201.88 34.04,202.39 v2(34.04,202.62)
PWR_VCCGT_COMP: length 6.1
  BOTTOM w0.203: PU4601.4 24.74,205.34
  BOTTOM w0.254: PC4631.2 21.88,207.96 PC4615.1 21.86,207.59 22.7,207.59 23.18,207.11 23.2,207.11 v2(23.43,206.88) 23.66,206.65 23.66,206.43 24.74,205.34
PWR_VCCGT_COMP_R: length 2.8
  BOTTOM w0.254: v2(20.1,211.05) 20.1,210.47 20.12,210.44 20.12,210.29 20.78,209.64 20.84,209.64 PR4602.1 PC4631.1
PWR_VCCGT_CSCOMP: length 47.7
  TOP w0.254: v3(54.77,218.19) 54.83,218.12 PR4651.2
  L4 w0.254: v3(54.77,218.19) 54.14,218.82 39.02,218.82 33.94,213.74 31.49,213.74 30.89,213.14 30.89,211.87 29.59,210.57 22.51,210.57 v3(22,211.07)
  BOTTOM w0.203: PU4601.6 25.54,206.13 25.36,206.32 25.36,206.56
  BOTTOM w0.254: v3(54.77,218.19) v2(53.96,218.19) ; 25.36,206.56 23.76,208.15 PR4630.2 23.74,208.22 22.85,209.11 PC4639.1 PC4630.1 22.85,211 PR4633.1 22.07,211.01 v3(22,211.07)
PWR_VCCGT_CSNA: length 44.9
  TOP w0.254: v3(57.06,210.95) PG4805.1
  L4 w0.254: v3(57.06,210.95) 56.83,211.17 56.83,218.82 55.44,220.22 38.23,220.22 34.29,216.28 31.5,216.28 29.05,213.84 29.05,212.28 v3(28.88,212.11)
  BOTTOM w0.254: v2(57.31,210.11) 57.06,210.36 v3(57.06,210.95) ; PR4656.1 28.74,211.26 28.74,211.96 v3(28.88,212.11)
PWR_VCCGT_CSNB: length 63
  TOP w0.254: v3(57.06,199.77) PG4822.1
  L4 w0.254: v3(57.06,199.77) 56.83,199.55 56.83,199.14 57.21,198.75 57.6,198.75 57.93,199.09 57.93,218.68 55.63,220.98 47.91,220.98 47.28,221.62 36.64,221.62 32.88,217.85 31.61,217.85 27.62,213.87 26.96,213.87 26.64,213.55 26.64,213.04 v3(26.83,212.85)
  BOTTOM w0.254: v2(57.26,200.56) 57.06,200.35 v3(57.06,199.77) ; PR4657.1 27.16,210.83 27.16,212.52 v3(26.83,212.85)
PWR_VCCGT_CSPA: length 6.1
  BOTTOM w0.203: 27.57,206.55 27.14,206.13 PU4601.10
  BOTTOM w0.254: 27.57,206.55 27.57,206.81 v2(28.56,207.8) 28.93,208.17 PC4632.1 29.12,208.98 PR4653.1
PWR_VCCGT_CSPB: length 6.9
  BOTTOM w0.203: PU4601.9 26.74,204.91 26.81,204.98 26.81,206.28 26.93,206.39 26.93,207.74 PR4652.2
  BOTTOM w0.254: v2(24.9,209.85) 25.83,209.85 PR4658.1 26,209.68 PC4612.2 26,208.66 PR4652.2
PWR_VCCGT_CSREF: length 11.2
  TOP w0.254: PC4604.1 24.54,205.59 25.46,206.5 v1(25.48,206.5) 25.54,206.55 v3(26.37,206.55)
  L4 w0.254: v3(26.37,206.55) 27.58,207.77 v3(27.72,207.77)
  BOTTOM w0.203: PU4601.8 26.34,206.53 v3(26.37,206.55)
  BOTTOM w0.254: PC4632.2 PC4612.1 26.96,208.85 PR4657.2 ; PC4632.2 28.04,208.52 27.72,208.2 v3(27.72,207.77) ; PC4632.2 28.1,208.85 PR4656.2
PWR_VCCGT_CSSUM: length 17
  BOTTOM w0.203: 25.18,207.45 25.86,206.78 25.86,206.28 25.94,206.2 PU4601.7
  BOTTOM w0.254: PR4636.1 30.39,212.34 v2(29.56,213.17) 29.34,213.39 25.85,213.39 25,212.54 PR4642.1 24.3,211.01 PR4637.2 23.74,210.9 PC4630.2 PC4639.2 23.74,209.04 24.28,208.5 24.28,208.35 25.18,207.45
PWR_VCCGT_DIFFOUT: length 7.9
  BOTTOM w0.203: PU4601.2 23.94,204.84 23.16,205.63 23.02,205.63
  BOTTOM w0.254: PR4624.1 19.85,208.93 19.85,207.84 PR4628.1 PR4622.1 20.43,206.76 v2(20.81,206.38) 20.94,206.25 22.4,206.25 23.02,205.63
PWR_VCCGT_DIFFOUT_R: length 2.2
  BOTTOM w0.254: PC4614.2 18.02,208.62 v2(18.02,208.23) 18.48,207.77 PR4628.2
PWR_VCCGT_FB: length 9.2
  BOTTOM w0.203: PU4601.3 24.34,205.02 24.04,205.33
  BOTTOM w0.254: PC4614.1 PR4624.2 20.33,209.33 20.33,209.26 PR4602.2 20.86,207.84 PC4615.2 20.8,207.68 21.65,206.83 v2(22.05,206.83) 22.53,206.83 24.04,205.33
PWR_VCCGT_ILIM: length 4.7
  BOTTOM w0.203: PU4601.5 25.14,204.81
  BOTTOM w0.254: PR4630.1 23.39,207.62 23.52,207.62 24.57,206.57 24.57,206.43 v2(24.75,206.25) 25.14,205.85 25.14,204.81
PWR_VCCGT_ILIM_NTC: length 40.8
  TOP w0.254: v3(55.66,218.19) 55.72,218.12 PR4651.1
  L4 w0.254: v3(23.66,212.85) 24.95,211.56 29.86,211.56 30.39,212.08 30.39,213.36 31.28,214.25 33.73,214.25 38.81,219.33 54.52,219.33 v3(55.66,218.19)
  BOTTOM w0.254: PR4633.2 PR4637.1 23.86,212.65 v3(23.66,212.85) ; v3(55.66,218.19) v2(56.47,218.19)
PWR_VCCGT_IOUT: length 5.3
  BOTTOM w0.203: PU4601.1 23.26,204.46 22.49,205.23
  BOTTOM w0.254: 22.49,205.23 22.26,205.46 v2(22.26,205.56) 22.23,205.56 22.18,205.61 PR4626.2 PC4637.2
PWR_VCCGT_LGA: length 26.8
  TOP w0.508: PR4654.1 31.78,204.47 v5(32.16,204.09)
  TOP w0.762: PU4803.4 43.09,206.12 v5(43.47,205.74)
  L4 w0.762: 43.09,207.77 v5(43.09,211.61) ; 43.09,207.77 39.48,207.77 36.56,204.85 33.69,204.85 32.93,204.09 v5(32.16,204.09) ; 43.09,207.77 43.09,206.5 43.47,206.12 v5(43.47,205.74)
  BOTTOM w0.203: PU4601.17 29.36,202.75 29.81,203.2 30.39,203.2
  BOTTOM w0.508: v5(32.16,204.09) 31.28,203.2 v2(30.51,203.2) 30.39,203.2
  BOTTOM w0.762: v5(43.09,211.61) PU4802.4
PWR_VCCGT_LGB: length 26.5
  TOP w0.508: v5(32.16,202.95) 31.91,202.95 31.4,203.45 PR4650.1
  TOP w0.762: PU4807.4 v5(43.09,199.16)
  L4 w0.762: v5(42.71,204.98) 42.71,204.47 43.09,204.09 43.09,202.18 ; 43.09,202.18 v5(43.09,199.16) ; 43.09,202.18 34.07,202.18 33.31,202.95 v5(32.16,202.95)
  BOTTOM w0.203: 30.77,202.44 30.37,202.04 29.58,202.04 29.49,201.95 PU4601.19
  BOTTOM w0.508: 30.77,202.44 31.53,202.44 32.04,202.95 v5(32.16,202.95) 32.37,202.95 v2(32.98,203.56)
  BOTTOM w0.762: PU4805.4 43.09,203.96 43.09,204.6 v5(42.71,204.98)
PWR_VCCGT_SNB1: length 2.9
  BOTTOM w0.508: PR4813.2 v2(43.21,212.98) 42.77,213.42 PC4809.1
PWR_VCCGT_SNB2: length 2.6
  BOTTOM w0.508: PC4810.1 43.28,197.93 v2(43.85,197.36) 44.79,197.36 PR4814.2
PWR_VCCGT_SWA: length 30.4
  TOP w0.254: 52.03,210.95 PG4804.2
  L4 w0.762: v5(32.04,205.23) 40.29,213.49 43.98,213.49 46.26,215.77 v5(50.33,215.77)
  BOTTOM w0.203: 30,203.85 29.29,203.15 PU4601.16
  BOTTOM w0.381: 30,203.85 30.68,203.85 31.08,204.25 v2(31.2,204.25) 31.2,204.39 v5(32.04,205.23)
  BOTTOM w0.508: PC4601.2 31.66,205.61 v5(32.04,205.23)
  vias: v2(52.08,215.72) v2(53.27,206.93) v5(51.04,214.4) v5(51.04,213.49) v5(51.16,208.43) v5(51.16,207.52) v5(51.95,214.4) v5(51.95,213.49) v5(52.08,208.43) v5(52.08,207.52) v5(52.87,214.4) v5(52.87,213.49)
PWR_VCCGT_SWB: length 27.9
  TOP w0.254: PL4802.1 PG4819.2
  L4 w0.762: v5(49.69,198.5) 49.69,199.08 48.87,199.9 47.66,199.9 45.52,197.76 35.82,197.76 32.06,201.52 v5(30.89,201.52)
  BOTTOM w0.203: PU4601.20 29.56,201.55 29.71,201.7 30.72,201.7 v5(30.89,201.52)
  BOTTOM w0.508: v5(30.89,201.52) 31.91,201.52 PC4634.2
  vias: v2(52.94,193.55) v2(53.42,204.27) v5(50.91,203.2) v5(50.91,202.29) v5(51.04,197.23) v5(51.04,196.32) v5(51.82,203.2) v5(51.82,202.29) v5(51.95,197.23) v5(51.95,196.32) v5(52.74,203.2) v5(52.74,202.29)
PWR_VCCGT_SWNA: length 44.9
  TOP w0.254: v3(56.23,210.95) PG4804.1
  L4 w0.254: v3(29.64,212.09) 29.43,212.3 29.43,213.68 31.66,215.9 34.45,215.9 38.39,219.84 55.28,219.84 56.45,218.66 56.45,211.17 v3(56.23,210.95)
  BOTTOM w0.254: v3(56.23,210.95) v2(55.42,210.95) ; v3(29.64,212.09) 29.12,211.57 PR4653.2 29.56,210.63 PR4636.2
PWR_VCCGT_SWNB: length 65.6
  TOP w0.254: v3(56.23,199.77) PG4819.1
  L4 w0.254: v3(26.07,212.85) 26.26,213.04 26.26,213.71 26.8,214.25 27.47,214.25 31.45,218.23 32.72,218.23 36.48,222 47.44,222 48.07,221.36 55.79,221.36 58.31,218.84 58.31,198.93 57.75,198.37 57.06,198.37 56.45,198.98 56.45,199.55 v3(56.23,199.77)
  BOTTOM w0.254: v3(26.07,212.85) 26.07,212.17 PR4642.2 25.94,211.12 PR4658.2 ; v2(55.42,199.77) v3(56.23,199.77)
PWR_VCCGT_TSENSE: length 10.9
  TOP w0.254: PC4635.1 25.43,204.85 27.08,206.5 v3(28.1,206.5)
  BOTTOM w0.203: PU4601.11 27.54,205.94 v3(28.1,206.5)
  BOTTOM w0.254: v3(28.1,206.5) 29.4,207.8 v2(29.95,207.8) 30.3,207.8 31.53,209.02 PR4647.1
PWR_VCCGT_TSENSE_NTC: length 27.2
  TOP w0.254: v3(51.47,217.3) PR4649.2
  L4 w0.254: v3(51.47,217.3) 51.47,217.93 51.09,218.31 39.58,218.31 v3(33.1,211.84)
  BOTTOM w0.254: v2(51.47,218.14) v3(51.47,217.3) ; v3(33.1,211.84) 33.1,211.23 32.61,210.73 PR4648.2 31.78,210.63 PR4647.2
PWR_VCCGT_UGA: length 29.8
  TOP w0.762: PU4801.4 v5(50.07,217.17)
  L4 w0.762: v5(30.89,205.23) 30.89,206.06 39.71,214.88 43.34,214.88 45.63,217.17 v5(50.07,217.17)
  BOTTOM w0.203: 29.94,204.41 29.5,203.96 29.5,203.84 29.21,203.55 PU4601.15
  BOTTOM w0.381: v5(30.89,205.23) 30.77,205.23 29.94,204.41
  BOTTOM w0.508: v5(50.07,217.17) 49.31,217.17 v2(49.18,217.3)
PWR_VCCGT_UGB: length 24.8
  TOP w0.508: v1(30.72,200.53) 30.54,200.53 v5(29.95,201.12)
  TOP w0.762: PU4804.4 48.68,198.12 v3(48.29,198.5)
  L4 w0.762: v3(48.29,198.5) 46.16,196.37 35.24,196.37 31.08,200.53 30.28,200.53 29.95,200.86 v5(29.95,201.12)
  BOTTOM w0.203: v5(29.95,201.12) 29.92,201.15 PU4601.21
PWR_VCCGT_VSN: length 5.7
  TOP w0.254: PR4617.2 PC4603.2 22,207.47 21.48,206.95 v1(21.48,206.2) 21.48,205.17 v3(21.65,205)
  BOTTOM w0.203: v3(21.65,205) 21.8,205 22.86,203.95 PU4601.52
PWR_VCCGT_VSN_G: length 5.1
  TOP w0.254: PC4609.1 21,207.85 21.62,208.47 PC4603.1 PR4617.1 PG4604.1 23.07,209.32 23.99,209.32 v1(24.42,209.75)
PWR_VCCGT_VSP: length 8
  TOP w0.254: v3(20.89,204.97) 20.2,204.97 v1(19.57,205.61) 19.44,205.74 19.44,206.84 PC4609.2 19.92,207.71 PG4601.1
  BOTTOM w0.203: v3(20.89,204.97) 21.55,204.32 22,204.32 22.28,204.04 22.28,203.95 22.68,203.55 PU4601.51
PWR_VCCSA_BST: length 4.3
  TOP w0.305: 25.79,163.47 PU5003.1
  TOP w0.508: PR5005.2 22.98,164.35 23.49,163.84 v1(24.14,163.84) 24.51,163.84 24.52,163.86 25.07,163.86 25.08,163.84 25.42,163.84 25.79,163.47
PWR_VCCSA_BST_RC: length 3
  TOP w0.508: PR5005.1 23.95,164.9 v1(25.43,164.9) 26.78,164.9 PC5020.1
PWR_VCCSA_COMP: length 7
  TOP w0.254: PC4606.2 22.06,203.55 PC4605.2 21.69,203.17 21.64,203.23 v1(20.12,203.23) 20.12,202.79 20.99,201.92 v3(20.99,201.8)
  BOTTOM w0.203: 22.13,202.18 22.37,201.95 PU4601.47
  BOTTOM w0.254: v3(20.99,201.8) 21.52,202.34 21.98,202.34 22.13,202.18
PWR_VCCSA_COMP_1: length 2.9
  TOP w0.254: PC4605.1 22.11,204.49 PR4605.2 22.7,205.12 v1(23.46,205.88)
PWR_VCCSA_CSP: length 6.5
  BOTTOM w0.203: 21.37,200.66 21.46,200.75 PU4601.44
  BOTTOM w0.254: 21.37,200.66 v2(21.17,200.66) PC4607.2 20.16,200.6 PC4626.1 PR4608.2 20.16,197.27 PR4627.1
PWR_VCCSA_CSP_R: length 51.6
  TOP w0.254: v3(39.15,168.28) 39.4,168.53 PR4610.1
  L4 w0.254: v3(39.15,168.28) 38.49,168.94 24.93,168.94 17.2,176.67 17.2,179.12 16.34,179.99 16.34,196.82 v3(18.45,198.93)
  BOTTOM w0.254: v2(38.34,168.25) 38.36,168.28 v3(39.15,168.28) ; v3(18.45,198.93) 18.75,198.63 PR4608.1
PWR_VCCSA_DRVH: length 17.2
  TOP w0.305: v5(27.61,163.69) PU5003.8
  TOP w0.406: PU5001.4 35.83,169.07 v1(36.12,169.36) 36.36,169.36 36.95,168.77 v5(36.95,167.09)
  L4 w0.762: v5(27.61,163.69) 27.61,164.68 28.79,165.86 35.59,165.86 36.82,167.09 v5(36.95,167.09)
PWR_VCCSA_DRVL: length 6.8
  TOP w0.305: v5(27.61,160.67) PU5003.5
  TOP w0.406: v5(31.44,160.4) 31.74,160.7 PU5002.4
  L4 w0.762: v5(27.61,160.67) 27.88,160.4 v5(31.44,160.4)
  BOTTOM w0.508: v2(27.62,159.78) 27.62,160.66 v5(27.61,160.67)
PWR_VCCSA_ILIM: length 5
  TOP w0.254: PC4628.1 22.68,202.58 PR4613.2 22.04,202.61 21.75,202.31 v3(21.75,201.8) 21.75,201.47 v1(21.27,200.99)
  BOTTOM w0.203: PU4601.46 22.28,201.55 22.03,201.8 v3(21.75,201.8)
PWR_VCCSA_IOUT: length 4.4
  TOP w0.254: v3(21.87,200.2) 21.7,200.03 v1(21.7,199.29) 22.12,199.29 22.15,199.32 22.27,199.32 PC4602.2 PR4614.1
  BOTTOM w0.203: PU4601.43 22.23,200.35 22.08,200.2 v3(21.87,200.2)
PWR_VCCSA_PH: length 16.1
  TOP w0.254: PG5001.2 PL5001.1
  TOP w0.305: PU5003.7 28.88,162.43 v1(28.89,162.43)
  TOP w0.508: PC5020.2 28.61,164.59 v5(28.61,163.7) 28.61,163.32 28.89,163.04 v1(28.89,162.43)
  L4 w0.762: v5(38.39,166.62) 38.39,166.55 36.04,164.21 29.12,164.21 v5(28.61,163.7)
PWR_VCCSA_PWM: length 47
  TOP w0.254: v3(24.8,163.19) 24.8,163.17 25.54,162.43 PU5003.2 ; v3(21.93,198.37) 22.36,198.81 PR4620.2
  L3 w0.254: v3(21.93,198.37) 22.16,198.14 22.16,194.54 23.77,192.93 23.77,188.77 23.18,188.18 21.84,188.18 18.58,184.91 18.58,167.64 21.94,164.27 23.42,164.27 24.5,163.19 v3(24.8,163.19)
  BOTTOM w0.203: v3(21.93,198.37) 22.7,199.15 PU4601.40
  BOTTOM w0.254: v3(24.8,163.19) v2(24.8,164.01)
PWR_VCCSA_SWN: length 55.8
  TOP w0.254: v3(40.8,167.64) 41.05,167.39 41.05,164.47 40.67,164.08 PG5001.1
  L4 w0.254: v3(18.45,198.17) 18.47,198.15 18.55,198.15 18.98,197.71 18.98,194.61 16.85,192.48 16.85,180.2 17.71,179.34 17.71,176.88 25.14,169.44 39,169.44 v3(40.8,167.64)
  BOTTOM w0.254: v3(40.8,167.64) v2(40.8,166.83) ; v3(18.45,198.17) 18.58,198.04 PR4627.2
PWR_VCCSA_VSN: length 11.5
  TOP w0.254: v3(20.1,202.06) 20.35,201.8 v1(20.35,198.88) 20.35,196.91 PC4638.2 PR4603.2
  BOTTOM w0.203: 21.18,202.76 21.24,202.82 22,202.82 22.47,202.35 PU4601.48
  BOTTOM w0.254: 21.18,202.76 20.8,202.76 v3(20.1,202.06)
PWR_VCCSA_VSN_G: length 5.2
  TOP w0.254: PG4602.1 21.37,192.09 PC4620.1 21.38,192.15 22.64,193.41 v1(22.64,193.8) PR4603.1 PC4638.1
PWR_VCCSA_VSP_: length 12.4
  TOP w0.254: PR4669.2 PR4606.1 20.61,195.83 19.62,196.82 v1(19.62,197.13) 19.62,201.78 v3(19.34,202.06)
  BOTTOM w0.203: 20.56,203.28 22.01,203.28 22.54,202.75 PU4601.49
  BOTTOM w0.254: 20.56,203.28 v3(19.34,202.06)
PWR_VCCSA_VSP_G: length 4.7
  TOP w0.254: PG4603.1 20.35,192.09 PC4620.2 20.42,192.22 21.37,193.17 v1(21.5,193.17) 20.86,193.8 PC4633.1 20.61,193.87 PR4606.2
PWR_VCCSA_VSP_RC: length 2.1
  TOP w0.254: PR4669.1 19.65,194.69 PC4633.2 19.65,192.98 v1(19.46,192.79)
PWR_VCORE_ALERT#: length 3.9
  BOTTOM w0.102: PU4601.37 24.34,198.36 23.44,197.46 v2(23.07,197.46) 23.07,196.82 22.64,196.39 PR4660.2
PWR_VCORE_BST: length 5.6
  BOTTOM w0.203: PU4601.26 28.99,199.01 28.99,197.99 29.24,197.74
  BOTTOM w0.508: 29.24,197.74 29.4,197.59 29.88,197.59 30.21,197.26 31.12,197.26 PR4646.1 31.53,197.18 v2(32.24,197.89)
PWR_VCORE_BST_R: length 2.5
  BOTTOM w0.508: PR4646.2 33.05,197.36 v2(33.59,197.89) 33.59,198.53 PC4617.2
PWR_VCORE_COMP: length 5.9
  BOTTOM w0.203: PU4601.30 27.14,198.06 27.08,198 27.08,196.84 27.18,196.74 27.45,196.48 27.85,196.48 28.02,196.65 v2(28.4,196.65)
  BOTTOM w0.254: v2(28.4,196.65) 28.46,196.65 29.46,195.64 PC4618.1 PC4619.1
PWR_VCORE_COMP_RC: length 3
  BOTTOM w0.254: PR4631.1 29.92,192.98 30.36,193.42 v2(30.36,193.47) 30.51,193.62 PC4619.2
PWR_VCORE_CSN: length 35.9
  TOP w0.254: PG4702.1 42.64,180.21 42.39,180.47 42.39,185.01 42.01,185.39 PR4632.1 41.09,186.31 39.97,187.43 39.25,187.43 ; v1(39.25,187.71) 39.25,187.43 ; 39.25,187.43 37.15,187.43 35.47,189.1 28.74,189.1 27.21,190.63 27.21,190.98 v3(27.34,191.11) 27.97,191.74 PC4608.2 PC4613.2
  L4 w0.254: v3(27.34,191.11) 26.6,191.11 26.32,191.39 26.32,196.19 v3(25.81,196.7)
  BOTTOM w0.203: PU4601.32 26.34,198.25
  BOTTOM w0.254: v3(25.81,196.7) 26.34,197.22 26.34,198.25
PWR_VCORE_CSP: length 9
  TOP w0.254: v3(25.76,197.49) 25.78,197.49 26.35,196.92 26.35,195.27 v1(26.23,195.15) 26.23,194.27 PR4623.1 27.66,192.85 PC4608.1 PC4613.1 PR4625.1
  BOTTOM w0.203: PU4601.33 25.94,197.66 v3(25.76,197.49)
PWR_VCORE_CSP_NTC: length 16.4
  TOP w0.254: 37.22,189.87 38.64,189.87 41.63,186.88 42.32,186.88 PR4632.2 ; 37.22,189.87 30.64,189.87 v1(29.88,190.63) PR4625.2 ; 37.22,189.87 v1(37.22,189.59)
PWR_VCORE_DRON: length 47
  TOP w0.254: v3(24.8,162.18) 25.05,161.93 PU5003.3
  L3 w0.254: v3(21.62,197.61) 21.62,194.31 23.26,192.67 23.26,189.03 22.95,188.71 21.62,188.71 18.07,185.17 18.07,167.39 21.69,163.77 23.21,163.77 v3(24.8,162.18)
  BOTTOM w0.203: PU4601.39 22.9,198.64 22.9,198.63 21.88,197.61 v3(21.62,197.61)
  BOTTOM w0.254: v2(24.8,161.37) v3(24.8,162.18)
PWR_VCORE_EN: length 5.6
  BOTTOM w0.102: PU4601.41 22.41,199.55 21.92,199.06 v2(21.42,199.06) 21.09,198.73 21.09,196.13 PR4666.1
PWR_VCORE_ILIM: length 4.5
  BOTTOM w0.203: 26.74,198.3 PU4601.31
  BOTTOM w0.254: PR4629.1 PC4625.1 27.45,195.64 v2(26.73,196.37) 26.73,198.29 26.74,198.3
PWR_VCORE_IOUT: length 5.2
  BOTTOM w0.203: 25.54,198.02 PU4601.34
  BOTTOM w0.254: 25.54,198.02 25.23,197.71 25.23,196.01 v2(25.59,195.66) 25.69,195.55 PR4621.1 26.65,194.75 PC4611.2
PWR_VCORE_LG: length 30.2
  TOP w0.381: v5(30.64,199.26) 29.94,199.26 PR4655.1
  TOP w0.762: PU4702.4 27.85,179.96 v5(27.85,179.58)
  L4 w0.762: v5(27.85,179.58) 27.85,185.04 v5(28.35,185.55) 28.23,185.67 28.23,196.53 28.4,196.7 28.4,198.81 28.99,199.39 30.51,199.39 v5(30.64,199.26)
  BOTTOM w0.203: v5(30.64,199.26) 30.64,199.34 30.08,199.9 29.8,199.9 29.35,200.35 PU4601.23
  BOTTOM w0.762: PU4703.4 28.48,185.42 v5(28.35,185.55) 29.01,186.21 v2(29.29,186.21)
PWR_VCORE_SCLK: length 4.3
  BOTTOM w0.102: PU4601.38 23.94,198.38 23.6,198.04 22.94,198.04 22.44,197.54 22.44,197.41 v2(21.85,196.83) 21.62,196.6 PR4662.2
PWR_VCORE_SDIO: length 3.5
  BOTTOM w0.102: PR4668.2 23.66,196.32 v2(23.88,196.55) 23.88,197.58 24.37,198.07 24.43,198.07 24.74,198.37 PU4601.36
PWR_VCORE_SNB: length 2.9
  TOP w0.508: PC4702.1 26.64,186.94 v1(26.7,186.94) PR4707.2
PWR_VCORE_SW: length 31.7
  TOP w0.254: PG4701.2 PL4701.1
  L4 w0.762: v5(30.51,197.99) 31.66,196.85 31.66,183.39 35.59,179.45 35.59,175.64 v5(35.72,175.51)
  BOTTOM w0.203: PU4601.24 29.27,199.95 30.06,199.16 30.06,199.02 30.51,198.56 v5(30.51,197.99)
  BOTTOM w0.508: v5(30.51,197.99) 31.02,197.99 31.63,198.6 PC4617.1
  vias: v2(36.86,181.2) v2(37.65,175.69) v5(36.56,184.56) v5(36.56,183.64) v5(36.56,182.73) v5(36.56,177.8) v5(36.56,176.89) v5(37.47,184.56) v5(37.47,183.64) v5(37.47,182.73) v5(37.47,177.8) v5(37.47,176.89) v5(38.39,184.56) v5(38.39,183.64) v5(38.39,182.73) v5(38.39,177.8) v5(38.39,176.89)
PWR_VCORE_SWN: length 25.5
  TOP w0.254: 32.6,188.72 28.58,188.72 26.83,190.47 26.83,190.89 26.8,190.91 26.8,191.87 PR4623.2 ; 32.6,188.72 v1(32.6,188.42) ; 32.6,188.72 35.31,188.72 36.99,187.05 39.81,187.05 42.01,184.85 42.01,180.4 41.82,180.21 PG4701.1
PWR_VCORE_TSENSE: length 6
  BOTTOM w0.203: PU4601.27 28.34,198.26 28.61,197.99 28.61,197.48 28.74,197.35
  BOTTOM w0.254: PR4640.1 PC4636.1 31.53,195.71 30.56,196.67 v2(29.78,196.67) 29.41,196.67 28.74,197.35
PWR_VCORE_TSENSE_NTC: length 12.2
  TOP w0.254: PR4644.1 v3(32.93,186.31)
  L4 w0.254: v3(32.93,186.31) 33.36,186.74 33.36,193.37 v3(32.93,193.8)
  BOTTOM w0.254: PR4645.2 31.97,193.31 32.47,193.8 v3(32.93,193.8) 32.93,194.37 PR4640.2 ; v2(33.74,186.39) 33,186.39 v3(32.93,186.31)
PWR_VCORE_UG: length 34.5
  TOP w0.762: PU4701.4 v5(34.07,178.81)
  L4 w0.762: v5(29.62,198.37) 29.62,196.85 30.26,196.22 30.26,182.63 v5(34.07,178.81) 34.07,175.19 35.27,173.99 v5(35.85,173.99)
  BOTTOM w0.203: PU4601.25 29.17,199.55 29.62,199.09 v5(29.62,198.37)
  BOTTOM w0.762: PU4704.4 34.07,172.92 34.5,172.49 v2(35.8,172.49) 35.8,172.57 35.85,172.62 v5(35.85,173.99)
