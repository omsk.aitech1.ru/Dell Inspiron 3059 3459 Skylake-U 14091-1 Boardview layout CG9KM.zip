# Allegro board 14091-1.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C402-TO0D2H28
  custom 0.152x0.152 smd: 1(0,0.457) 2(0,-0.457)
C402H20
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
C402H22
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
C603H35
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H36
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H40
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C805H50
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H54
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H58
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C1206H71
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
C1206H75
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
C1808H87
  rect 2.286x1.27 smd: 1(0,2.032) 2(0,-2.032)
CI1410M1HRL-NH
  rect 0.61x1.549 smd: 1(-4.5,3.325) 2(-3.5,3.325) 3(-2.5,3.325) 4(-1.5,3.325) 5(-0.5,3.325) 6(0.5,3.325) 7(1.5,3.325) 8(2.5,3.325) 9(3.5,3.325) 10(4.5,3.325)
  rect 0.61x1.194 smd: 11(-5.6,0) 12(5.6,0)
CI2505P1H00-LF-U
  round 1.422 hole 1.016: 1(-5,0) 2(-2.5,0) 3(0,0) 4(2.5,0) 5(5,0)
CON2C
  custom 0.171x0.171 smd: 1(0,0.533) 2(0,-0.533)
CON2C-U
  custom 0.171x0.171 smd: 1(0,0.533) 2(0,-0.533)
CT3528H79
  rect 2.286x2.286 smd: 1(0,1.905) 2(0,-1.905)
CT7343H75
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
CT7343H83
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
D1608-035030AKH28
  rect 0.559x0.991 smd: A(0,0.691) K(0,-0.691)
D4724AKH44
  rect 2.007x1.549 smd: A(0,2.221) K(0,-2.221)
DFN8F3-G2517H32
  rect 0.406x0.94 smd: 1(0.975,1.538) 2(0.325,1.538) 3(-0.325,1.538) 4(-0.975,1.538) 5(-0.975,-1.538)
  rect 0.025x0.025 smd: 6(-0.325,-1.538) 8(0.975,-1.538)
  custom 0.235x0.235 smd: 7(0.325,-1.538)
  rect 2.489x1.676 smd: 9(0,0)
DFN10G3-G265175H32
  rect 0.305x0.914 smd: 1(1,1.549) 2(0.5,1.549) 3(0,1.549) 4(-0.5,1.549) 5(-1,1.549) 6(-1,-1.549) 7(-0.5,-1.549) 8(0,-1.549) 9(0.5,-1.549) 10(1,-1.549)
  rect 2.642x1.753 smd: 11(0,0)
DFN10G2510H26
  rect 0.305x0.787 smd: 1(1,0.494) 5(-1,0.494) 6(-1,-0.494) 10(1,-0.494)
  rect 0.254x0.787 smd: 2(0.521,0.494) 4(-0.521,0.494) 7(-0.521,-0.494) 9(0.521,-0.494)
  rect 0.025x0.025 smd: 3(0,0.494)
  rect 0.406x1.753 smd: 8(0,-0.494)
DO214AAAK-1121H97
  rect 2.311x2.032 smd: A(0,2.322) K(0,-2.322)
ECAP-100D6D3H237
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
ECAP-100D6D3H355
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
ECAP-100D6D3H375
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
FUSE-1608H22
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GEN8D5X8R5X4D5-8-F-A
  round 0.254 hole 5.004x4.521 unplated: (0,0)
  round 0.864 hole 0.508: 1(3.136,1.664) 2(1.918,2.882) 3(-1.918,2.882) 4(-3.136,1.664) 5(-3.136,-1.664) 6(-1.918,-2.882) 7(1.918,-2.882) 8(3.136,-1.664)
GEN315R138-8-F-A-1
  round 0.254 hole 3.505 unplated: (0,0)
  round 0.864 hole 0.508: 1(2.667,1.54) 2(1.54,2.667) 3(-1.54,2.667) 4(-2.667,1.54) 5(-2.667,-1.54) 6(-1.54,-2.667) 7(1.54,-2.667) 8(2.667,-1.54)
GEN315R138-8-F-A-2-S
  round 0.254 hole 3.505 unplated: (0,0)
  round 0.864 hole 0.508: 1(2.667,1.54) 2(1.54,2.667) 3(-1.54,2.667) 4(-2.667,1.54) 5(-2.667,-1.54) 6(-1.54,-2.667) 7(1.54,-2.667) 8(2.667,-1.54)
GEN315R178-8-F-A-1
  round 0.254 hole 4.521 unplated: (0,0)
  round 0.864 hole 0.508: 1(2.882,1.664) 2(1.664,2.882) 3(-1.664,2.882) 4(-2.882,1.664) 5(-2.882,-1.664) 6(-1.664,-2.882) 7(1.664,-2.882) 8(2.882,-1.664)
HF1804H
  round 1.651 hole 1.016: 1(-3.81,0) 2(-1.27,0) 3(1.27,0) 4(3.81,0)
HL5507F
  round 0.254 hole 1.016 unplated: (5,0)
  round 1.321 hole 0.914: 1(-6,-1) 2(-6,1) 3(-4,-1) 4(-4,1) 5(-2,-1) 6(-2,1) 7(0,-1) 8(0,1) 9(2,-1) 10(2,1) 11(4,-1) 12(4,1) 13(6,-1) 14(6,1)
HOLE237R158
  round 6.02 hole 4.013: 1(0,0)
JAC331-0140A8B-9H
  oval 1.321x2.235 hole 0.61x1.524: 1(-4.95,2.1) 4(5,2.1) P(3.25,-3.15) Q(-3.9,-2.1)
  oval 2.235x1.422 hole 1.524x0.711: 5(0,3.17)
L402H22
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L402H24
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
L2520-D620H48
  rect 2.261x1.245 smd: 1(0,1.018) 2(0,-1.018)
L7066-1830-UH119
  rect 3.505x2.921 smd: 1(0,2.78) 2(0,-2.78)
L8080-6020H158
  rect 6.502x3.15 smd: 1(0,2.944) 2(0,-2.944)
L20125H42
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
L112100-2030H158
  rect 3.505x3.15 smd: 1(0,4.769) 2(0,-4.769)
L115100-2H158
  rect 3.759x3.251 smd: 1(0,5.022) 2(0,-5.022)
L115100-2030H158
  rect 3.251x2.896 smd: 1(0,4.944) 2(0,-4.944)
L125100-4P-1H24
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-1H28
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-1H36
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-1H37
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-4H24
  rect 0.762x0.432 smd: 1(-0.625,0.341) 2(0.625,0.341) 3(0.625,-0.341) 4(-0.625,-0.341)
L125100-4P-4H28
  rect 0.762x0.432 smd: 1(-0.625,0.341) 2(0.625,0.341) 3(0.625,-0.341) 4(-0.625,-0.341)
L686647-127318H119
  rect 3.683x2.413 smd: 1(0,2.986) 2(0,-2.986)
LED1608AKH30
  custom 0.216x0.216 smd: A(0,0.762) K(0,-0.762)
LFDFN8G2-G1309H40
  rect 0.305x0.483 smd: 1(0.75,0.911) 2(0.25,0.911) 3(-0.25,0.911) 4(-0.75,0.911) 5(-0.75,-0.911) 6(-0.25,-0.911) 7(0.25,-0.911) 8(0.75,-0.911)
  rect 1.295x0.889 smd: 9(0,0)
LFQFN52J6-G4D8-1H40
  rect 0.203x0.533 smd: 1(2.4,2.911) 13(-2.4,2.911) 27(-2.4,-2.911) 39(2.4,-2.911)
  rect 0.203x0.584 smd: 2(2,2.911) 3(1.6,2.911) 4(1.2,2.911) 5(0.8,2.911) 6(0.4,2.911) 7(0,2.911) 8(-0.4,2.911) 9(-0.8,2.911) 10(-1.2,2.911) 11(-1.6,2.911) 12(-2,2.911) 28(-2,-2.911) 29(-1.6,-2.911) 30(-1.2,-2.911) 31(-0.8,-2.911) 32(-0.4,-2.911) 33(0,-2.911) 34(0.4,-2.911) 35(0.8,-2.911) 36(1.2,-2.911) 37(1.6,-2.911) 38(2,-2.911)
  rect 0.533x0.203 smd: 14(-2.911,2.4) 26(-2.911,-2.4) 40(2.911,-2.4) 52(2.911,2.4)
  rect 0.584x0.203 smd: 15(-2.911,2) 16(-2.911,1.6) 17(-2.911,1.2) 18(-2.911,0.8) 19(-2.911,0.4) 20(-2.911,0) 21(-2.911,-0.4) 22(-2.911,-0.8) 23(-2.911,-1.2) 24(-2.911,-1.6) 25(-2.911,-2) 41(2.911,-2) 42(2.911,-1.6) 43(2.911,-1.2) 44(2.911,-0.8) 45(2.911,-0.4) 46(2.911,0) 47(2.911,0.4) 48(2.911,0.8) 49(2.911,1.2) 50(2.911,1.6) 51(2.911,2)
  rect 4.801x4.801 smd: 53(0,0)
LGA16G3-1H40
  rect 0.305x0.559 smd: 1(1,1.221) 2(0.5,1.221) 3(0,1.221) 4(-0.5,1.221) 5(-1,1.221) 9(-1,-1.221) 10(-0.5,-1.221) 11(0,-1.221) 12(0.5,-1.221) 13(1,-1.221)
  rect 0.559x0.305 smd: 6(-1.221,0.5) 7(-1.221,0) 8(-1.221,-0.5) 14(1.221,-0.5) 15(1.221,0) 16(1.221,0.5)
LQFP64H63
  rect 0.203x1.524 smd: 1(3,4.242) 2(2.6,4.242) 3(2.2,4.242) 4(1.8,4.242) 5(1.4,4.242) 6(0.999,4.242) 7(0.599,4.242) 8(0.199,4.242) 9(-0.199,4.242) 10(-0.599,4.242) 11(-0.999,4.242) 12(-1.4,4.242) 13(-1.8,4.242) 14(-2.2,4.242) 15(-2.6,4.242) 16(-3,4.242) 33(-3,-4.242) 34(-2.6,-4.242) 35(-2.2,-4.242) 36(-1.8,-4.242) 37(-1.4,-4.242) 38(-0.999,-4.242) 39(-0.599,-4.242) 40(-0.199,-4.242) 41(0.199,-4.242) 42(0.599,-4.242) 43(0.999,-4.242) 44(1.4,-4.242) 45(1.8,-4.242) 46(2.2,-4.242) 47(2.6,-4.242) 48(3,-4.242)
  rect 1.524x0.203 smd: 17(-4.242,3) 18(-4.242,2.6) 19(-4.242,2.2) 20(-4.242,1.8) 21(-4.242,1.4) 22(-4.242,0.999) 23(-4.242,0.599) 24(-4.242,0.199) 25(-4.242,-0.199) 26(-4.242,-0.599) 27(-4.242,-0.999) 28(-4.242,-1.4) 29(-4.242,-1.8) 30(-4.242,-2.2) 31(-4.242,-2.6) 32(-4.242,-3) 49(4.242,-3) 50(4.242,-2.6) 51(4.242,-2.2) 52(4.242,-1.8) 53(4.242,-1.4) 54(4.242,-0.999) 55(4.242,-0.599) 56(4.242,-0.199) 57(4.242,0.199) 58(4.242,0.599) 59(4.242,0.999) 60(4.242,1.4) 61(4.242,1.8) 62(4.242,2.2) 63(4.242,2.6) 64(4.242,3)
LQFP128H63
  rect 0.203x1.524 smd: 1(6.2,7.747) 2(5.8,7.747) 3(5.4,7.747) 4(5,7.747) 5(4.6,7.747) 6(4.2,7.747) 7(3.8,7.747) 8(3.4,7.747) 9(3,7.747) 10(2.6,7.747) 11(2.2,7.747) 12(1.8,7.747) 13(1.4,7.747) 14(0.999,7.747) 15(0.599,7.747) 16(0.199,7.747) 17(-0.199,7.747) 18(-0.599,7.747) 19(-0.999,7.747) 20(-1.4,7.747) 21(-1.8,7.747) 22(-2.2,7.747) 23(-2.6,7.747) 24(-3,7.747) 25(-3.4,7.747) 26(-3.8,7.747) 27(-4.2,7.747) 28(-4.6,7.747) 29(-5,7.747) 30(-5.4,7.747) 31(-5.8,7.747) 32(-6.2,7.747) 65(-6.2,-7.747) 66(-5.8,-7.747) 67(-5.4,-7.747) 68(-5,-7.747) 69(-4.6,-7.747) 70(-4.2,-7.747) 71(-3.8,-7.747) 72(-3.4,-7.747) 73(-3,-7.747) 74(-2.6,-7.747) 75(-2.2,-7.747) 76(-1.8,-7.747) 77(-1.4,-7.747) 78(-0.999,-7.747) 79(-0.599,-7.747) 80(-0.199,-7.747) 81(0.199,-7.747) 82(0.599,-7.747) 83(0.999,-7.747) 84(1.4,-7.747) 85(1.8,-7.747) 86(2.2,-7.747) 87(2.6,-7.747) 88(3,-7.747) 89(3.4,-7.747) 90(3.8,-7.747) 91(4.2,-7.747) 92(4.6,-7.747) 93(5,-7.747) 94(5.4,-7.747) 95(5.8,-7.747) 96(6.2,-7.747)
  rect 1.524x0.203 smd: 33(-7.747,6.2) 34(-7.747,5.8) 35(-7.747,5.4) 36(-7.747,5) 37(-7.747,4.6) 38(-7.747,4.2) 39(-7.747,3.8) 40(-7.747,3.4) 41(-7.747,3) 42(-7.747,2.6) 43(-7.747,2.2) 44(-7.747,1.8) 45(-7.747,1.4) 46(-7.747,0.999) 47(-7.747,0.599) 48(-7.747,0.199) 49(-7.747,-0.199) 50(-7.747,-0.599) 51(-7.747,-0.999) 52(-7.747,-1.4) 53(-7.747,-1.8) 54(-7.747,-2.2) 55(-7.747,-2.6) 56(-7.747,-3) 57(-7.747,-3.4) 58(-7.747,-3.8) 59(-7.747,-4.2) 60(-7.747,-4.6) 61(-7.747,-5) 62(-7.747,-5.4) 63(-7.747,-5.8) 64(-7.747,-6.2) 97(7.747,-6.2) 98(7.747,-5.8) 99(7.747,-5.4) 100(7.747,-5) 101(7.747,-4.6) 102(7.747,-4.2) 103(7.747,-3.8) 104(7.747,-3.4) 105(7.747,-3) 106(7.747,-2.6) 107(7.747,-2.2) 108(7.747,-1.8) 109(7.747,-1.4) 110(7.747,-0.999) 111(7.747,-0.599) 112(7.747,-0.199) 113(7.747,0.199) 114(7.747,0.599) 115(7.747,0.999) 116(7.747,1.4) 117(7.747,1.8) 118(7.747,2.2) 119(7.747,2.6) 120(7.747,3) 121(7.747,3.4) 122(7.747,3.8) 123(7.747,4.2) 124(7.747,4.6) 125(7.747,5) 126(7.747,5.4) 127(7.747,5.8) 128(7.747,6.2)
LVDFH-02004-TP00
  rect 0.305x1.295 smd: 1(-4.75,-1.95) 2(-4.25,-1.95) 3(-3.75,-1.95) 4(-3.25,-1.95) 5(-2.75,-1.95) 6(-2.25,-1.95) 7(-1.75,-1.95) 8(-1.25,-1.95) 9(-0.75,-1.95) 10(-0.25,-1.95) 11(0.25,-1.95) 12(0.75,-1.95) 13(1.25,-1.95) 14(1.75,-1.95) 15(2.25,-1.95) 16(2.75,-1.95) 17(3.25,-1.95) 18(3.75,-1.95) 19(4.25,-1.95) 20(4.75,-1.95)
  rect 1.194x2.692 smd: 21(-7.15,0) 22(7.15,0)
  rect 2.261x1.346 smd: 23(3.9,1.975) 24(0,1.975) 25(-3.9,1.975)
MSOP10H44
  rect 0.305x1.524 smd: 1(-0.999,-2.07) 2(-0.5,-2.07) 3(0,-2.07) 4(0.5,-2.07) 5(0.999,-2.07) 6(0.999,2.07) 7(0.5,2.07) 8(0,2.07) 9(-0.5,2.07) 10(-0.999,2.07)
NTC-402H22-U
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
NTC-402H24-U
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
OSC-3225-4P-3H36
  rect 1.397x0.914 smd: 1(-1.171,-0.825) 2(1.171,-0.825) 3(1.171,0.825) 4(-1.171,0.825)
OSC-3225-4P-4H30
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
OSC-3225-4P-4H36
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
POLYSW-2114H30
  rect 1.6x0.965 smd: 1(0,0.94) 2(0,-0.94)
PPAK-5PH45
  rect 0.762x1.524 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81)
  rect 5.283x5.08 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.635,2.032) 7(-0.635,2.032) 8(-1.905,2.032)
PPAK-8P-2H45
  rect 0.406x1.168 smd: 1(-0.975,-2.351) 2(-0.325,-2.351) 3(0.325,-2.351) 4(0.975,-2.351)
  rect 3.404x2.769 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(1.029,0.902) 7(0.013,0.902) 8(-0.991,0.902)
PPAK-8P-3232H36
  rect 0.406x0.914 smd: 1(-0.975,-2.396) 2(-0.325,-2.396) 3(0.325,-2.396) 4(0.975,-2.396)
  rect 3.353x2.692 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.65,0.838) 7(0,0.838) 8(-0.65,0.838)
PPAK-8P-5262H40
  rect 0.762x1.448 smd: 1(-1.905,-3.684) 2(-0.635,-3.684) 3(0.635,-3.684) 4(1.905,-3.684)
  rect 5.512x5.309 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.635,2.146) 7(-0.635,2.146) 8(-1.905,2.146)
QFN16-G1D8-UH32
  rect 0.305x0.914 smd: 1(0.75,1.551) 2(0.25,1.551) 3(-0.25,1.551) 4(-0.75,1.551) 9(-0.75,-1.551) 10(-0.25,-1.551) 11(0.25,-1.551) 12(0.75,-1.551)
  rect 0.914x0.305 smd: 5(-1.551,0.75) 6(-1.551,0.25) 7(-1.551,-0.25) 8(-1.551,-0.75) 13(1.551,-0.75) 14(1.551,-0.25) 15(1.551,0.25) 16(1.551,0.75)
  rect 1.778x1.778 smd: 17(0,0)
QFN16J3H24
  rect 0.254x1.422 smd: 1(0.525,1.297) 2(-0.175,1.297) 8(-0.525,-1.297) 9(0.175,-1.297)
  rect 1.092x0.203 smd: 3(-1.462,0.8) 4(-1.462,0.4) 5(-1.462,0) 6(-1.462,-0.4) 7(-1.462,-0.8) 10(1.462,-0.8) 11(1.462,-0.4) 12(1.462,0) 13(1.462,0.4) 14(1.462,0.8)
  rect 0.203x0.66 smd: 15(0.165,0) 16(-0.435,0)
QFN20-G1D75H32
  rect 0.203x0.914 smd: 1(0.8,1.551) 2(0.4,1.551) 3(0,1.551) 4(-0.4,1.551) 5(-0.8,1.551) 11(-0.8,-1.551) 12(-0.4,-1.551) 13(0,-1.551) 14(0.4,-1.551) 15(0.8,-1.551)
  rect 0.914x0.203 smd: 6(-1.551,0.8) 7(-1.551,0.4) 8(-1.551,0) 9(-1.551,-0.4) 10(-1.551,-0.8) 16(1.551,-0.8) 17(1.551,-0.4) 18(1.551,0) 19(1.551,0.4) 20(1.551,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN20-G2D1H32
  rect 0.305x1.092 smd: 1(0.999,1.956) 5(-0.999,1.956) 11(-0.999,-1.956) 15(0.999,-1.956)
  rect 0.305x1.143 smd: 2(0.5,1.93) 3(0,1.93) 4(-0.5,1.93) 12(-0.5,-1.93) 13(0,-1.93) 14(0.5,-1.93)
  rect 1.092x0.305 smd: 6(-1.956,0.999) 10(-1.956,-0.999) 16(1.956,-0.999) 20(1.956,0.999)
  rect 1.143x0.305 smd: 7(-1.93,0.5) 8(-1.93,0) 9(-1.93,-0.5) 17(1.93,-0.5) 18(1.93,0) 19(1.93,0.5)
  rect 2.108x2.108 smd: 21(0,0)
QFN20G3D5-G2D15H40
  rect 0.305x0.914 smd: 1(1,1.801) 5(-1,1.801) 11(-1,-1.801) 15(1,-1.801)
  rect 0.305x0.965 smd: 2(0.5,1.775) 3(0,1.775) 4(-0.5,1.775) 12(-0.5,-1.775) 13(0,-1.775) 14(0.5,-1.775)
  rect 0.914x0.305 smd: 6(-1.801,1) 10(-1.801,-1) 16(1.801,-1) 20(1.801,1)
  rect 0.965x0.305 smd: 7(-1.775,0.5) 8(-1.775,0) 9(-1.775,-0.5) 17(1.775,-0.5) 18(1.775,0) 19(1.775,0.5)
  rect 2.159x2.159 smd: 21(0,0)
QFN32-G3D55H40
  rect 0.305x0.838 smd: 1(1.75,2.591) 8(-1.75,2.591) 17(-1.75,-2.591) 24(1.75,-2.591)
  rect 0.305x0.94 smd: 2(1.25,2.54) 3(0.751,2.54) 4(0.25,2.54) 5(-0.25,2.54) 6(-0.751,2.54) 7(-1.25,2.54) 18(-1.25,-2.54) 19(-0.751,-2.54) 20(-0.25,-2.54) 21(0.25,-2.54) 22(0.751,-2.54) 23(1.25,-2.54)
  rect 0.838x0.305 smd: 9(-2.591,1.75) 16(-2.591,-1.75) 25(2.591,-1.75) 32(2.591,1.75)
  rect 0.94x0.305 smd: 10(-2.54,1.25) 11(-2.54,0.751) 12(-2.54,0.25) 13(-2.54,-0.25) 14(-2.54,-0.751) 15(-2.54,-1.25) 26(2.54,-1.25) 27(2.54,-0.751) 28(2.54,-0.25) 29(2.54,0.25) 30(2.54,0.751) 31(2.54,1.25)
  rect 3.531x3.531 smd: 33(0,0)
QFN32J4-G2D85H36
  rect 0.203x0.864 smd: 1(1.4,2.085) 2(1,2.085) 3(0.6,2.085) 4(0.2,2.085) 5(-0.2,2.085) 6(-0.6,2.085) 7(-1,2.085) 8(-1.4,2.085) 17(-1.4,-2.085) 18(-1,-2.085) 19(-0.6,-2.085) 20(-0.2,-2.085) 21(0.2,-2.085) 22(0.6,-2.085) 23(1,-2.085) 24(1.4,-2.085)
  rect 0.864x0.203 smd: 9(-2.085,1.4) 10(-2.085,1) 11(-2.085,0.6) 12(-2.085,0.2) 13(-2.085,-0.2) 14(-2.085,-0.6) 15(-2.085,-1) 16(-2.085,-1.4) 25(2.085,-1.4) 26(2.085,-1) 27(2.085,-0.6) 28(2.085,-0.2) 29(2.085,0.2) 30(2.085,0.6) 31(2.085,1) 32(2.085,1.4)
  rect 2.845x2.845 smd: 33(0,0)
QFN40-G3D5H32
  rect 0.203x0.914 smd: 1(1.8,2.553) 10(-1.8,2.553) 21(-1.8,-2.553) 30(1.8,-2.553)
  rect 0.203x0.965 smd: 2(1.4,2.527) 3(1,2.527) 4(0.6,2.527) 5(0.2,2.527) 6(-0.2,2.527) 7(-0.6,2.527) 8(-1,2.527) 9(-1.4,2.527) 22(-1.4,-2.527) 23(-1,-2.527) 24(-0.6,-2.527) 25(-0.2,-2.527) 26(0.2,-2.527) 27(0.6,-2.527) 28(1,-2.527) 29(1.4,-2.527)
  rect 0.914x0.203 smd: 11(-2.553,1.8) 20(-2.553,-1.8) 31(2.553,-1.8) 40(2.553,1.8)
  rect 0.965x0.203 smd: 12(-2.527,1.4) 13(-2.527,1) 14(-2.527,0.6) 15(-2.527,0.2) 16(-2.527,-0.2) 17(-2.527,-0.6) 18(-2.527,-1) 19(-2.527,-1.4) 32(2.527,-1.4) 33(2.527,-1) 34(2.527,-0.6) 35(2.527,-0.2) 36(2.527,0.2) 37(2.527,0.6) 38(2.527,1) 39(2.527,1.4)
  rect 3.505x3.505 smd: 41(0,0)
QFN40J5-G3D65H32
  rect 0.203x0.94 smd: 1(1.8,2.538) 10(-1.8,2.538) 21(-1.8,-2.538) 30(1.8,-2.538)
  rect 0.203x0.965 smd: 2(1.4,2.526) 3(1,2.526) 4(0.6,2.526) 5(0.2,2.526) 6(-0.2,2.526) 7(-0.6,2.526) 8(-1,2.526) 9(-1.4,2.526) 22(-1.4,-2.526) 23(-1,-2.526) 24(-0.6,-2.526) 25(-0.2,-2.526) 26(0.2,-2.526) 27(0.6,-2.526) 28(1,-2.526) 29(1.4,-2.526)
  rect 0.94x0.203 smd: 11(-2.538,1.8) 20(-2.538,-1.8) 31(2.538,-1.8) 40(2.538,1.8)
  rect 0.965x0.203 smd: 12(-2.526,1.4) 13(-2.526,1) 14(-2.526,0.6) 15(-2.526,0.2) 16(-2.526,-0.2) 17(-2.526,-0.6) 18(-2.526,-1) 19(-2.526,-1.4) 32(2.526,-1.4) 33(2.526,-1) 34(2.526,-0.6) 35(2.526,-0.2) 36(2.526,0.2) 37(2.526,0.6) 38(2.526,1) 39(2.526,1.4)
  rect 3.658x3.658 smd: 41(0,0)
QFN48J6-G465H40
  rect 0.203x0.965 smd: 1(2.2,3.025) 2(1.8,3.025) 3(1.4,3.025) 4(1,3.025) 5(0.6,3.025) 6(0.2,3.025) 7(-0.2,3.025) 8(-0.6,3.025) 9(-1,3.025) 10(-1.4,3.025) 11(-1.8,3.025) 12(-2.2,3.025) 25(-2.2,-3.025) 26(-1.8,-3.025) 27(-1.4,-3.025) 28(-1,-3.025) 29(-0.6,-3.025) 30(-0.2,-3.025) 31(0.2,-3.025) 32(0.6,-3.025) 33(1,-3.025) 34(1.4,-3.025) 35(1.8,-3.025) 36(2.2,-3.025)
  rect 0.965x0.203 smd: 13(-3.025,2.2) 14(-3.025,1.8) 15(-3.025,1.4) 16(-3.025,1) 17(-3.025,0.6) 18(-3.025,0.2) 19(-3.025,-0.2) 20(-3.025,-0.6) 21(-3.025,-1) 22(-3.025,-1.4) 23(-3.025,-1.8) 24(-3.025,-2.2) 37(3.025,-2.2) 38(3.025,-1.8) 39(3.025,-1.4) 40(3.025,-1) 41(3.025,-0.6) 42(3.025,-0.2) 43(3.025,0.2) 44(3.025,0.6) 45(3.025,1) 46(3.025,1.4) 47(3.025,1.8) 48(3.025,2.2)
  rect 4.648x4.648 smd: 49(0,0)
QSH-030-01-FDAK
  round 0.254 hole 1.016 unplated: (-10.066,2.67) (10.066,2.67)
  rect 0.305x2.515 smd: 1(-7.25,-2.99) 2(-7.25,2.99) 3(-6.75,-2.99) 4(-6.75,2.99) 5(-6.25,-2.99) 6(-6.25,2.99) 7(-5.751,-2.99) 8(-5.751,2.99) 9(-5.25,-2.99) 10(-5.25,2.99) 11(-4.75,-2.99) 12(-4.75,2.99) 13(-4.249,-2.99) 14(-4.249,2.99) 15(-3.75,-2.99) 16(-3.75,2.99) 17(-3.25,-2.99) 18(-3.25,2.99) 19(-2.75,-2.99) 20(-2.75,2.99) 21(-2.25,-2.99) 22(-2.25,2.99) 23(-1.75,-2.99) 24(-1.75,2.99) 25(-1.25,-2.99) 26(-1.25,2.99) 27(-0.751,-2.99) 28(-0.751,2.99) 29(-0.25,-2.99) 30(-0.25,2.99) 31(0.25,-2.99) 32(0.25,2.99) 33(0.751,-2.99) 34(0.751,2.99) 35(1.25,-2.99) 36(1.25,2.99) 37(1.75,-2.99) 38(1.75,2.99) 39(2.25,-2.99) 40(2.25,2.99) 41(2.75,-2.99) 42(2.75,2.99) 43(3.25,-2.99) 44(3.25,2.99) 45(3.75,-2.99) 46(3.75,2.99) 47(4.249,-2.99) 48(4.249,2.99) 49(4.75,-2.99) 50(4.75,2.99) 51(5.25,-2.99) 52(5.25,2.99) 53(5.751,-2.99) 54(5.751,2.99) 55(6.25,-2.99) 56(6.25,2.99) 57(6.75,-2.99) 58(6.75,2.99) 59(7.25,-2.99) 60(7.25,2.99)
  rect 2.54x0.432 smd: 61(-8.065,0) 64(8.065,0)
  rect 4.699x0.432 smd: 62(-3.175,0) 63(3.175,0)
R402H14
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H15
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H16
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R603H22
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
R603H24
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
R805H24
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
R1206H26
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
R1206H28
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
R3720H40
  rect 4.013x1.041 smd: 1(0,0.867) 2(0,-0.867)
SC70-5H44
  rect 0.406x1.219 smd: 1(0.65,0.826) 2(0,0.826) 3(-0.65,0.826) 4(-0.65,-0.826) 5(0.65,-0.826)
SE3116H241
  rect 1.626x3.099 smd: 1(0,2.654) 2(0,-2.654)
SE361414H241
  rect 1.372x3.607 smd: 1(0,2.499) 2(0,-2.499)
SE361416H237
  rect 1.422x3.556 smd: 1(0,2.574) 2(0,-2.574)
SKT-HDMI22-150077
  rect 0.305x2.007 smd: 1(4.21,3.37) 2(3.71,3.37) 3(3.21,3.37) 4(2.71,3.37) 5(2.21,3.37) 6(1.71,3.37) 7(1.21,3.37) 8(0.71,3.37) 9(0.21,3.37) 10(-0.29,3.37) 11(-0.79,3.37) 12(-1.29,3.37) 13(-1.79,3.37) 14(-2.29,3.37) 15(-2.79,3.37) 16(-3.29,3.37) 17(-3.79,3.37) 18(-4.29,3.37) 19(-4.79,3.37)
  oval 4.928x1.524 hole 4.216x0.813: 20(0,-2.53)
  oval 1.524x4.674 hole 0.813x3.962: 21(-7.25,0) 22(7.25,0)
SKT-SOIC8-092117H235
  rect 0.508x1.702 smd: 1(1.905,4.1) 2(0.635,4.1) 3(-0.635,4.1) 4(-1.905,4.1) 5(-1.905,-4.1) 6(-0.635,-4.1) 7(0.635,-4.1) 8(1.905,-4.1)
SKT-USB6-135063
  round 1.346 hole 0.94: 1(3.5,-2.71) 2(1,-2.71) 3(-1,-2.71) 4(-3.5,-2.71)
  round 2.718 hole 2.311: 5(6.57,0) 6(-6.57,0)
SKT-USB11-138165-1
  round 1.067 hole 0.711: 1(3.5,3.5) 2(1,3.5) 3(-1,3.5) 4(-3.5,3.5) 5(-4,2) 6(-2,2) 7(0,2) 8(2,2) 9(4,2)
  oval 1.422x3.023 hole 0.711x2.311: 10(-6.4,0) 11(6.4,0)
SLP2510P8-1H22
  rect 0.305x0.762 smd: 1(-1,-0.5) 5(1,-0.5) 6(1,0.5) 10(-1,0.5)
  rect 0.203x0.762 smd: 2(-0.5,-0.5) 4(0.5,-0.5) 7(0.5,0.5) 9(-0.5,0.5)
  rect 0.406x0.762 smd: 3(0,-0.5) 8(0,0.5)
SMD49-6914-0403H56
  rect 1.168x0.559 smd: 1(-3.38,-0.427) 2(3.38,-0.427) 3(3.38,0.427) 4(-3.38,0.427)
SMD-OSC8H52
  rect 1.803x1.6 smd: 1(-1.469,-1.4) 2(1.469,-1.4) 3(1.469,1.4) 4(-1.469,1.4)
SOD323AKH38
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD323AKH40
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD323AKH42
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD523AKH28
  rect 0.559x1.016 smd: A(0,0.762) K(0,-0.762)
SOD882-10D6-1H20
  custom 0.114x0.114 smd: 1(0,0.445) 2(0,-0.445)
SOIC8-1H86
  rect 0.635x1.651 smd: 1(-1.905,-3.493) 2(-0.635,-3.493) 3(0.635,-3.493) 4(1.905,-3.493) 5(1.905,3.493) 6(0.635,3.493) 7(-0.635,3.493) 8(-1.905,3.493)
SOIC8-G3530H63
  rect 0.635x1.651 smd: 1(-1.905,-2.555) 2(-0.635,-2.555) 3(0.635,-2.555) 4(1.905,-2.555) 5(1.905,2.555) 6(0.635,2.555) 7(-0.635,2.555) 8(-1.905,2.555)
  rect 3.505x2.997 smd: 9(0,0)
SOIC8H69
  rect 0.635x1.651 smd: 1(-1.905,-2.54) 2(-0.635,-2.54) 3(0.635,-2.54) 4(1.905,-2.54) 5(1.905,2.54) 6(0.635,2.54) 7(-0.635,2.54) 8(-1.905,2.54)
SON14J3020-G2610H32
  rect 0.025x0.025 smd: 1(1.2,1.105) 6(-0.8,1.105) 9(-0.8,-1.105) 14(1.2,-1.105)
  custom 0.151x0.151 smd: 2(0.8,1.105) 7(-1.2,1.105) 8(-1.2,-1.105) 13(0.8,-1.105)
  rect 0.203x0.813 smd: 3(0.4,1.105) 4(0,1.105) 5(-0.4,1.105) 10(-0.4,-1.105) 11(0,-1.105) 12(0.4,-1.105)
  rect 2.591x0.889 smd: 15(0,0)
SOT23-2D4-312H44
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D4-312H46
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D4-312H48
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23CBE2D4H44
  custom 0.191x0.191 smd: B(-0.984,-0.953) C(0,0.953) E(0.984,-0.953)
SOT23DGS2D4H44
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D4H48
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D8H50
  custom 0.254x0.254 smd: D(0,1.118) G(-1.016,-1.118) S(1.016,-1.118)
SOT323CBE2D2H44
  custom 0.152x0.152 smd: B(-0.65,-0.902) C(0,0.902) E(0.65,-0.902)
SOT-6-1H50
  rect 0.584x1.219 smd: 1(-0.95,-1.194) 2(0,-1.194) 3(0.95,-1.194) 4(0.95,1.194) 5(0,1.194) 6(-0.95,1.194)
SOT-6H58
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-23-9H44
  custom 0.178x0.178 smd: 1(-0.95,-0.999) 2(0.95,-0.999) 3(0,0.999)
SOT-89-4541-3PH63
  rect 0.991x1.499 smd: 1(-1.5,0) 3(1.5,0)
  custom 0.502x0.502 smd: 2(0,0)
SOT-223H71
  rect 1.27x2.032 smd: 1(-2.286,0) 3(2.286,0)
  custom 0.889x0.889 smd: 2(0,0)
SOT-363H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
STF256R109H99
  round 6.502 hole 2.769: 1(0,0)
TPAD28
  round 0.711 smd: 1(0,0)
TQFP128H63
  rect 0.305x1.778 smd: 1(9.249,7.62) 2(8.75,7.62) 3(8.25,7.62) 4(7.75,7.62) 5(7.25,7.62) 6(6.75,7.62) 7(6.25,7.62) 8(5.751,7.62) 9(5.25,7.62) 10(4.75,7.62) 11(4.249,7.62) 12(3.75,7.62) 13(3.25,7.62) 14(2.75,7.62) 15(2.25,7.62) 16(1.75,7.62) 17(1.25,7.62) 18(0.751,7.62) 19(0.25,7.62) 20(-0.25,7.62) 21(-0.751,7.62) 22(-1.25,7.62) 23(-1.75,7.62) 24(-2.25,7.62) 25(-2.75,7.62) 26(-3.25,7.62) 27(-3.75,7.62) 28(-4.249,7.62) 29(-4.75,7.62) 30(-5.25,7.62) 31(-5.751,7.62) 32(-6.25,7.62) 33(-6.75,7.62) 34(-7.25,7.62) 35(-7.75,7.62) 36(-8.25,7.62) 37(-8.75,7.62) 38(-9.249,7.62) 65(-9.249,-7.62) 66(-8.75,-7.62) 67(-8.25,-7.62) 68(-7.75,-7.62) 69(-7.25,-7.62) 70(-6.75,-7.62) 71(-6.25,-7.62) 72(-5.751,-7.62) 73(-5.25,-7.62) 74(-4.75,-7.62) 75(-4.249,-7.62) 76(-3.75,-7.62) 77(-3.25,-7.62) 78(-2.75,-7.62) 79(-2.25,-7.62) 80(-1.75,-7.62) 81(-1.25,-7.62) 82(-0.751,-7.62) 83(-0.25,-7.62) 84(0.25,-7.62) 85(0.751,-7.62) 86(1.25,-7.62) 87(1.75,-7.62) 88(2.25,-7.62) 89(2.75,-7.62) 90(3.25,-7.62) 91(3.75,-7.62) 92(4.249,-7.62) 93(4.75,-7.62) 94(5.25,-7.62) 95(5.751,-7.62) 96(6.25,-7.62) 97(6.75,-7.62) 98(7.25,-7.62) 99(7.75,-7.62) 100(8.25,-7.62) 101(8.75,-7.62) 102(9.249,-7.62)
  rect 1.778x0.305 smd: 39(-10.617,6.25) 40(-10.617,5.751) 41(-10.617,5.25) 42(-10.617,4.75) 43(-10.617,4.249) 44(-10.617,3.75) 45(-10.617,3.25) 46(-10.617,2.75) 47(-10.617,2.25) 48(-10.617,1.75) 49(-10.617,1.25) 50(-10.617,0.751) 51(-10.617,0.25) 52(-10.617,-0.25) 53(-10.617,-0.751) 54(-10.617,-1.25) 55(-10.617,-1.75) 56(-10.617,-2.25) 57(-10.617,-2.75) 58(-10.617,-3.25) 59(-10.617,-3.75) 60(-10.617,-4.249) 61(-10.617,-4.75) 62(-10.617,-5.25) 63(-10.617,-5.751) 64(-10.617,-6.25) 103(10.617,-6.25) 104(10.617,-5.751) 105(10.617,-5.25) 106(10.617,-4.75) 107(10.617,-4.249) 108(10.617,-3.75) 109(10.617,-3.25) 110(10.617,-2.75) 111(10.617,-2.25) 112(10.617,-1.75) 113(10.617,-1.25) 114(10.617,-0.751) 115(10.617,-0.25) 116(10.617,0.25) 117(10.617,0.751) 118(10.617,1.25) 119(10.617,1.75) 120(10.617,2.25) 121(10.617,2.75) 122(10.617,3.25) 123(10.617,3.75) 124(10.617,4.249) 125(10.617,4.75) 126(10.617,5.25) 127(10.617,5.751) 128(10.617,6.25)
TVS5436-1121H105
  rect 2.337x2.007 smd: 1(0,2.299) 2(0,-2.299)
unnamed#2
  round 1.016 smd: (0,0)
XFORM12A127097H91
  rect 0.635x1.524 smd: 1(-4.445,-4.699) 2(-3.175,-4.699) 3(-1.905,-4.699) 4(1.905,-4.699) 5(3.175,-4.699) 6(4.445,-4.699) 7(4.445,4.699) 8(3.175,4.699) 9(1.905,4.699) 10(-1.905,4.699) 11(-3.175,4.699) 12(-4.445,4.699)

## Nets
1V_CPU_XDP_AB: R9905.2 XDP1.43
1V_CPU_XDP_CD: R9924.2 XDP1.44
1V_DCPDSW: C2103.1 CPU1.AL1
1V_EDRAM: CPU1.AB62 CPU1.P62 CPU1.V62 R702.2 R80012.1
1V_EOPIO: CPU1.AE62 CPU1.AG62 R80014.1 R80128.2
1V_S3: C750.1 R707.2 R708.2 U706.6 U706.7 U706.8
1V_SIP_S5: CPU1.AB17 CPU1.Y18 R1136.2
1V_VCC19P2: CPU1.A14 R1131.2
1V_VCC24TBT: C2116.1 CPU1.A10 R1122.2
1V_VCCAMPHYPLL: C1181.1 CPU1.K15 CPU1.L15 R1102.2
1V_VCCAPLL: CPU1.V15 R1120.2
1V_VCCAPLLEBB: C1173.1 CPU1.N18 R1101.2
1V_VCCDTS: CPU1.T1 R1130.2
1V_VCCF24NS: C2115.1 CPU1.L19 R1125.2 R80063.2
1V_VCCF100: C2113.1 CPU1.K19 R1114.2
1V_VCCF100OC: C2114.1 CPU1.N20 R1132.2
1V_VCCF135: CPU1.L21 R1121.2
1V_VCCFHV: CPU1.AK20 R1133.2
1V_VCCFUSEPRG: CPU1.G20 R703.2
1V_VCCGT: C1136.1 C1137.1 C1138.1 C1139.1 C1140.1 C1141.1 C1142.1 C1143.1 C1144.1 C1145.1 C12383.1 CPU1.A48 CPU1.A53 CPU1.A58 CPU1.A62 CPU1.A66 CPU1.AA63 CPU1.AA64 CPU1.AA66 CPU1.AA67 CPU1.AA69 CPU1.AA70 CPU1.AA71 CPU1.AC64 CPU1.AC65 CPU1.AC66 CPU1.AC67 CPU1.AC68 CPU1.AC69 CPU1.AC70 CPU1.AC71 CPU1.J43 CPU1.J45 CPU1.J46 CPU1.J48 CPU1.J50 CPU1.J52 CPU1.J53 CPU1.J55 CPU1.J56 CPU1.J58 CPU1.J60 CPU1.K48 CPU1.K50 CPU1.K52 CPU1.K53 CPU1.K55 CPU1.K56 CPU1.K58 CPU1.K60 CPU1.L62 CPU1.L63 CPU1.L64 CPU1.L65 CPU1.L66 CPU1.L67 CPU1.L68 CPU1.L69 CPU1.L70 CPU1.L71 CPU1.M62 CPU1.N63 CPU1.N64 CPU1.N66 CPU1.N67 CPU1.N69 CPU1.N70 CPU1.N71 CPU1.R63 CPU1.R64 CPU1.R65 CPU1.R66 CPU1.R67 CPU1.R68 CPU1.R69 CPU1.R70 CPU1.R71 CPU1.T62 CPU1.U65 CPU1.U68 CPU1.U71 CPU1.W63 CPU1.W64 CPU1.W65 CPU1.W66 CPU1.W67 CPU1.W68 CPU1.W69 CPU1.W70 CPU1.W71 CPU1.Y62 PC1126.1 PC1127.1 PC1128.1 PC1129.1 PC1130.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1139.1 PC12394.1 PC12395.1 PC12396.1 PC12397.1 PC12398.1 PC12399.1 PC12400.1 PC12401.1 PC12402.1 PC12403.1 PC12404.1 PC12405.1 PC12406.1 PC12407.1 PC12408.1 PC12409.1 PC12410.1 PC12411.1 PC12412.1 PC12413.1 PC12414.1 PC12415.1 PC12416.1 PC12417.1 PC12418.1 PC12419.1 PC12420.1 PC12421.1 PC12422.1 PC12423.1 PC12424.1 PC12425.1 PG4805.2 PG4822.2 PL4801.2 PL4802.2 PT4801.1 PT4802.1 R80016.1
1V_VCCGTUS: CPU1.AK42 CPU1.AK43 CPU1.AK45 CPU1.AK46 CPU1.AK48 CPU1.AK50 CPU1.AK52 CPU1.AK53 CPU1.AK55 CPU1.AK56 CPU1.AK58 CPU1.AK60 CPU1.AK70 CPU1.AL43 CPU1.AL46 CPU1.AL50 CPU1.AL53 CPU1.AL56 CPU1.AL60 CPU1.AM48 CPU1.AM50 CPU1.AM52 CPU1.AM53 CPU1.AM56 CPU1.AM58 CPU1.AU58 CPU1.AU63 CPU1.BB57 CPU1.BB66 R80129.2
1V_VCCIO: C1151.1 C1152.1 C1153.1 C1154.1 CPU1.AK28 CPU1.AK30 CPU1.AL30 CPU1.AL42 CPU1.AM28 CPU1.AM30 CPU1.AM42 PC1198.1 PC1199.1 R709.2 R801.1 R9906.1 R80020.1 R80024.2 R80200.1 U704.6 U704.7 U704.8
1V_VCCMPHYAON: C2104.1 CPU1.K17 CPU1.L1 R1134.2
1V_VCCMPHYGTAON: C1174.1 C1182.1 C12352.1 CPU1.N15 CPU1.N16 CPU1.N17 CPU1.P15 CPU1.P16 R1101.1 R1102.1 R1106.1 R80053.2
1V_VCCPRIM: C2101.1 CPU1.AB19 CPU1.AB20 CPU1.P18 R1112.2
1V_VCCPRIM_CORE: C2102.1 CPU1.AF18 CPU1.AF19 CPU1.V20 CPU1.V21 R80023.2 R80024.1 R80025.2
1V_VCCSA: C1148.1 C1149.1 C1150.1 C1184.1 C1185.1 C1186.1 C1187.1 CPU1.AK23 CPU1.AK25 CPU1.G23 CPU1.G25 CPU1.G27 CPU1.G28 CPU1.J22 CPU1.J23 CPU1.J27 CPU1.K23 CPU1.K25 CPU1.K27 CPU1.K28 CPU1.K30 PC1155.1 PC1156.1 PC1157.1 PC1158.1 PC1159.1 PC1160.1 PC1183.1 PC1188.1 PC1189.1 PC1190.1 PC1191.1 PC1192.1 PC1193.1 PC12426.1 PC12427.1 PC12428.1 PC12429.1 PC12430.1 PC12431.1 PC12432.1 PC12433.1 PG5002.2 PL5001.2 PT5001.1 R80022.1 R80025.1
1V_VCCSFR: C720.1 CPU1.K20 CPU1.K21 R708.1
1V_VCCSRAM: C1175.1 C1179.1 CPU1.AF20 CPU1.AF21 CPU1.T19 CPU1.T20 R1106.2
1V_VCCST: C716.1 CPU1.A18 PC4622.1 PR4609.1 PR4616.1 PR4618.1 PR4664.1 R419.1 R603.2 R707.1 R80027.1 R80028.1 R80029.1 R80043.1 R80158.1
1V_VCCSTG: C717.1 CPU1.A22 R401.1 R703.1 R709.1 R9918.2 R79997.2 R79998.2 R79999.2 R80000.2 R80001.2 R80002.2 R80005.2
1V_XDP_S5: C9902.1 C9904.1 R9901.2 R9905.1 R9924.1 R9932.1 R9934.1
3V3AUX: C12162.2 C12163.1 R79842.2 R79850.2 U14.27
3V_VA: C483.1 C485.1 C493.1 C495.2 L21.2 U6.23 U6.25
+19V_AMP_AVCC: C246.1 R380.2 U9625.12
+19V_AMP_PVCC: C232.1 C233.1 C247.1 C248.1 L6.2 R380.1 U9625.13 U9625.14 U9625.27 U9625.28
+VCCPRTC_3P3: C2120.1 C2121.2 CPU1.AK19 CPU1.BB14 R2106.2
AGND: C134.2 C140.2 C144.2 C145.1 C146.2 C147.1 C154.2 C155.2 C157.2 C159.2 C160.2 C246.2 C250.1 C267.2 C268.2 C450.2 C483.2 C485.2 C493.2 C495.1 C1491.2 C11358.2 C11359.2 C12266.1 C12333.2 C12375.1 C12386.2 LOUT1.5 LOUT1.P Q28.S Q9643.S R215.2 R216.2 R221.2 R268.2 R281.2 R300.2 R301.2 R379.1 R382.1 R385.2 R386.2 R387.1 R1193.2 R8516.2 R79824.2 R79825.2 R79987.1 R79988.2 U6.22 U6.28 U6.42 U9615.6 U9625.4 UHS1.5
AV12: R79841.1 R79843.2 U14.10
AV12_L: C12155.2 R79841.2
AVCC_EC: C12384.1 L9526.2 R79721.1 R79723.1 U4101.52
DV12S: C12157.1 C12158.2 R79843.1 U14.14
DV33_18: C12159.2 U14.18
GND: AFTP1.1 BAT2.9B BAT2.10B BT1.2 C1.2 C14.1 C20.2 C32.2 C33.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C48.2 C84.2 C87.2 C88.2 C104.2 C105.2 C106.2 C109.2 C110.2 C112.2 C121.1 C126.1 C127.2 C129.2 C131.2 C132.1 C163.2 C170.2 C180.2 C182.2 C185.2 C186.2 C187.2 C189.2 C190.2 C191.2 C194.2 C195.2 C197.2 C201.2 C202.2 C204.2 C207.1 C209.2 C213.2 C214.2 C216.2 C232.2 C233.2 C238.2 C245.2 C247.2 C248.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C261.2 C262.2 C271.2 C311.2 C312.1 C316.1 C329.1 C330.2 C419.2 C474.2 C478.2 C486.2 C489.2 C500.2 C501.2 C509.2 C514.2 C516.2 C529.2 C540.2 C557.2 C559.2 C570.2 C572.2 C574.2 C579.2 C580.2 C582.2 C583.2 C584.2 C585.2 C587.2 C591.2 C592.2 C593.2 C595.2 C597.2 C612.2 C616.2 C623.2 C627.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C742.2 C743.2 C744.2 C745.2 C747.2 C749.2 C750.2 C752.2 C753.2 C755.1 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C791.2 C792.2 C793.2 C794.2 C795.2 C796.2 C797.2 C798.2 C799.2 C800.2 C801.2 C802.2 C803.2 C804.2 C805.2 C806.2 C807.2 C808.2 C809.2 C810.2 C811.2 C812.2 C813.2 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 C820.2 C821.2 C822.2 C823.2 C824.2 C825.2 C826.2 C827.2 C828.2 C829.2 C830.2 C835.2 C839.2 C862.2 C863.2 C864.2 C865.1 C1039.2 C1040.2 C1041.2 C1042.2 C1043.2 C1044.2 C1045.2 C1046.2 C1047.2 C1048.2 C1049.2 C1050.2 C1051.2 C1052.2 C1053.2 C1054.2 C1055.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1143.2 C1144.2 C1145.2 C1148.2 C1149.2 C1150.2 C1151.2 C1152.2 C1153.2 C1154.2 C1173.2 C1174.2 C1175.2 C1179.2 C1181.2 C1182.2 C1184.2 C1185.2 C1186.2 C1187.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1219.2 C1220.2 C1221.2 C1222.2 C1223.2 C1224.2 C1225.2 C1226.2 C1227.2 C1228.2 C1229.2 C1230.2 C1231.2 C1232.2 C1233.2 C1234.2 C1235.2 C1236.2 C1237.2 C1238.2 C1239.2 C1240.2 C1241.2 C1245.2 C1246.2 C1247.2 C1301.2 C1302.2 C1303.2 C1305.2 C1306.2 C1308.2 C1309.2 C1310.2 C1311.2 C1312.2 C1313.2 C1314.2 C1315.2 C1316.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.2 C1322.2 C1323.2 C1324.2 C1325.2 C1326.2 C1615.2 C1616.2 C1617.2 C1698.2 C1699.2 C1700.2 C1701.2 C1742.2 C1743.2 C1744.2 C1745.2 C1753.1 C1756.2 C1760.2 C1764.1 C1769.2 C1770.2 C1771.2 C1773.2 C1774.2 C1796.2 C1797.2 C1798.2 C1799.2 C1800.2 C1801.2 C1802.2 C1803.2 C1804.2 C1806.2 C1807.2 C1829.2 C1830.2 C1831.2 C1832.2 C1833.2 C1834.2 C1835.2 C1836.2 C1837.2 C1846.2 C1847.2 C1848.2 C1849.1 C1850.2 C1851.2 C1852.2 C1853.2 C1854.2 C1855.1 C1856.2 C1857.2 C1858.2 C1859.2 C1860.2 C1861.2 C1864.1 C1867.2 C1868.2 C1869.2 C1925.2 C1926.2 C1927.2 C1928.2 C1929.2 C2101.2 C2102.2 C2103.2 C2104.2 C2105.2 C2106.2 C2107.2 C2108.2 C2109.2 C2110.2 C2111.2 C2112.2 C2113.2 C2114.2 C2115.2 C2116.2 C2117.2 C2118.2 C2119.2 C2120.2 C2121.1 C3131.2 C3366.2 C3367.2 C3452.2 C3453.2 C3454.2 C3459.2 C3460.2 C4101.1 C4254.1 C6701.2 C6702.2 C6703.2 C6710.2 C6711.2 C6716.1 C6717.2 C6718.2 C6724.1 C9504.2 C9516.2 C9518.2 C9520.2 C9522.2 C9901.2 C9902.2 C9903.2 C9904.2 C9905.2 C12126.2 C12131.2 C12151.2 C12152.2 C12155.1 C12156.1 C12157.2 C12158.1 C12159.1 C12160.1 C12161.1 C12162.1 C12163.2 C12169.2 C12170.2 C12171.2 C12172.2 C12174.2 C12183.1 C12184.1 C12185.2 C12186.2 C12187.2 C12188.2 C12189.2 C12190.2 C12191.2 C12194.2 C12195.2 C12196.2 C12197.2 C12199.2 C12200.2 C12201.2 C12202.2 C12203.2 C12204.2 C12205.2 C12206.2 C12207.2 C12216.2 C12217.2 C12218.2 C12219.2 C12244.2 C12245.2 C12246.2 C12249.2 C12250.2 C12251.1 C12261.2 C12262.2 C12264.2 C12265.2 C12333.1 C12334.2 C12335.2 C12350.2 C12351.2 C12352.2 C12353.2 C12354.2 C12355.2 C12356.2 C12357.2 C12358.2 C12361.2 C12362.2 C12363.2 C12364.2 C12365.2 C12368.2 C12369.2 C12370.2 C12376.2 C12377.2 C12378.2 C12379.2 C12380.2 C12381.2 C12382.2 C12383.2 C12384.2 C12386.1 CN3.4 CN3.5 CN3.6 CONVT1.10 CONVT1.11 CONVT1.12 CPU1.A5 CPU1.A67 CPU1.A70 CPU1.AA2 CPU1.AA4 CPU1.AA65 CPU1.AA68 CPU1.AB8 CPU1.AB15 CPU1.AB16 CPU1.AB18 CPU1.AB21 CPU1.AD8 CPU1.AD13 CPU1.AD16 CPU1.AD19 CPU1.AD20 CPU1.AD21 CPU1.AD62 CPU1.AE64 CPU1.AE65 CPU1.AE66 CPU1.AE67 CPU1.AE68 CPU1.AE69 CPU1.AF1 CPU1.AF2 CPU1.AF4 CPU1.AF10 CPU1.AF15 CPU1.AF17 CPU1.AF63 CPU1.AG16 CPU1.AG17 CPU1.AG18 CPU1.AG19 CPU1.AG20 CPU1.AG21 CPU1.AG71 CPU1.AH6 CPU1.AH13 CPU1.AH63 CPU1.AH64 CPU1.AH67 CPU1.AJ4 CPU1.AJ15 CPU1.AJ18 CPU1.AJ20 CPU1.AK8 CPU1.AK11 CPU1.AK16 CPU1.AK18 CPU1.AK21 CPU1.AK22 CPU1.AK27 CPU1.AK63 CPU1.AK68 CPU1.AK69 CPU1.AL2 CPU1.AL4 CPU1.AL28 CPU1.AL32 CPU1.AL35 CPU1.AL38 CPU1.AL45 CPU1.AL48 CPU1.AL52 CPU1.AL55 CPU1.AL58 CPU1.AL64 CPU1.AL65 CPU1.AL66 CPU1.AM8 CPU1.AM13 CPU1.AM21 CPU1.AM25 CPU1.AM27 CPU1.AM43 CPU1.AM45 CPU1.AM46 CPU1.AM55 CPU1.AM60 CPU1.AM61 CPU1.AM68 CPU1.AM71 CPU1.AN20 CPU1.AN23 CPU1.AN28 CPU1.AN30 CPU1.AN32 CPU1.AN33 CPU1.AN35 CPU1.AN37 CPU1.AN38 CPU1.AN40 CPU1.AN42 CPU1.AN43 CPU1.AN58 CPU1.AN63 CPU1.AP10 CPU1.AP18 CPU1.AP20 CPU1.AP23 CPU1.AP28 CPU1.AP32 CPU1.AP35 CPU1.AP38 CPU1.AP42 CPU1.AP58 CPU1.AP63 CPU1.AP68 CPU1.AP70 CPU1.AR5 CPU1.AR8 CPU1.AR11 CPU1.AR15 CPU1.AR16 CPU1.AR20 CPU1.AR23 CPU1.AR28 CPU1.AR35 CPU1.AR42 CPU1.AR43 CPU1.AR45 CPU1.AR46 CPU1.AR48 CPU1.AR50 CPU1.AR52 CPU1.AR53 CPU1.AR55 CPU1.AR58 CPU1.AR63 CPU1.AT2 CPU1.AT4 CPU1.AT20 CPU1.AT23 CPU1.AT28 CPU1.AT35 CPU1.AT42 CPU1.AT56 CPU1.AT58 CPU1.AT63 CPU1.AT68 CPU1.AT71 CPU1.AU10 CPU1.AU15 CPU1.AU20 CPU1.AU32 CPU1.AU38 CPU1.AV1 CPU1.AV68 CPU1.AV69 CPU1.AV70 CPU1.AV71 CPU1.AW6 CPU1.AW8 CPU1.AW10 CPU1.AW12 CPU1.AW14 CPU1.AW16 CPU1.AW18 CPU1.AW21 CPU1.AW23 CPU1.AW26 CPU1.AW28 CPU1.AW30 CPU1.AW32 CPU1.AW34 CPU1.AW36 CPU1.AW38 CPU1.AW41 CPU1.AW43 CPU1.AW45 CPU1.AW47 CPU1.AW49 CPU1.AW50 CPU1.AW51 CPU1.AW53 CPU1.AW55 CPU1.AW57 CPU1.AW60 CPU1.AW62 CPU1.AW64 CPU1.AW66 CPU1.AY66 CPU1.B10 CPU1.B14 CPU1.B18 CPU1.B22 CPU1.B30 CPU1.B34 CPU1.B39 CPU1.B44 CPU1.B48 CPU1.B53 CPU1.B58 CPU1.B62 CPU1.B66 CPU1.B71 CPU1.BA1 CPU1.BA2 CPU1.BA6 CPU1.BA10 CPU1.BA14 CPU1.BA18 CPU1.BA23 CPU1.BA28 CPU1.BA32 CPU1.BA36 CPU1.BA41 CPU1.BA45 CPU1.BA49 CPU1.BA53 CPU1.BA57 CPU1.BA62 CPU1.BA66 CPU1.BA71 CPU1.BB6 CPU1.BB18 CPU1.BB26 CPU1.BB30 CPU1.BB34 CPU1.BB38 CPU1.BB43 CPU1.BB55 CPU1.BB60 CPU1.BB64 CPU1.BB67 CPU1.BB70 CPU1.C1 CPU1.C5 CPU1.C25 CPU1.D6 CPU1.D10 CPU1.D11 CPU1.D14 CPU1.D18 CPU1.D22 CPU1.D25 CPU1.D26 CPU1.D30 CPU1.D34 CPU1.D39 CPU1.D44 CPU1.D45 CPU1.D47 CPU1.D48 CPU1.D53 CPU1.D58 CPU1.D62 CPU1.D66 CPU1.D69 CPU1.E6 CPU1.E11 CPU1.E15 CPU1.E18 CPU1.E21 CPU1.E46 CPU1.E50 CPU1.E53 CPU1.E56 CPU1.E65 CPU1.E71 CPU1.F1 CPU1.F2 CPU1.F4 CPU1.F8 CPU1.F13 CPU1.F22 CPU1.F23 CPU1.F27 CPU1.F28 CPU1.F32 CPU1.F33 CPU1.F35 CPU1.F37 CPU1.F38 CPU1.F40 CPU1.F42 CPU1.F68 CPU1.G5 CPU1.G6 CPU1.G10 CPU1.G22 CPU1.G43 CPU1.G45 CPU1.G48 CPU1.G52 CPU1.G55 CPU1.G58 CPU1.G60 CPU1.G63 CPU1.G66 CPU1.H15 CPU1.H18 CPU1.H71 CPU1.J8 CPU1.J11 CPU1.J13 CPU1.J25 CPU1.J28 CPU1.J32 CPU1.J35 CPU1.J38 CPU1.J42 CPU1.K16 CPU1.K18 CPU1.K22 CPU1.K61 CPU1.K63 CPU1.K64 CPU1.K65 CPU1.K66 CPU1.K67 CPU1.K68 CPU1.K70 CPU1.K71 CPU1.L2 CPU1.L4 CPU1.L8 CPU1.L11 CPU1.L16 CPU1.L17 CPU1.L18 CPU1.L20 CPU1.N6 CPU1.N10 CPU1.N13 CPU1.N19 CPU1.N21 CPU1.N65 CPU1.N68 CPU1.P17 CPU1.P19 CPU1.P20 CPU1.P21 CPU1.R6 CPU1.R13 CPU1.T2 CPU1.T4 CPU1.T15 CPU1.T17 CPU1.T18 CPU1.T21 CPU1.U10 CPU1.U63 CPU1.U64 CPU1.U66 CPU1.U67 CPU1.U69 CPU1.U70 CPU1.V16 CPU1.V17 CPU1.V18 CPU1.W6 CPU1.W9 CPU1.W13 CPU1.Y17 CPU1.Y19 CPU1.Y20 CPU1.Y21 D4.2 D16.A D19.1 D21.A D24.2 D5202.1 D5203.3 D5203.8 D5204.3 D5204.8 D5207.1 DB1.2 DCIN1.2 DCIN1.4 DCIN1.5 DCIN1.6 DCIN1.7 DCIN2.5 DCIN2.6 DCIN2.7 DCIN2.12 DCIN2.13 DCIN2.14 DIMM1.2 DIMM1.3 DIMM1.8 DIMM1.9 DIMM1.11 DIMM1.13 DIMM1.14 DIMM1.19 DIMM1.20 DIMM1.25 DIMM1.26 DIMM1.28 DIMM1.31 DIMM1.32 DIMM1.37 DIMM1.38 DIMM1.43 DIMM1.44 DIMM1.46 DIMM1.48 DIMM1.49 DIMM1.54 DIMM1.55 DIMM1.60 DIMM1.61 DIMM1.63 DIMM1.65 DIMM1.66 DIMM1.71 DIMM1.72 DIMM1.127 DIMM1.128 DIMM1.133 DIMM1.134 DIMM1.136 DIMM1.138 DIMM1.139 DIMM1.144 DIMM1.145 DIMM1.150 DIMM1.151 DIMM1.153 DIMM1.155 DIMM1.156 DIMM1.161 DIMM1.162 DIMM1.167 DIMM1.168 DIMM1.170 DIMM1.172 DIMM1.173 DIMM1.178 DIMM1.179 DIMM1.184 DIMM1.185 DIMM1.187 DIMM1.189 DIMM1.190 DIMM1.195 DIMM1.196 DIMM1.205 DIMM1.206 DIMM2.2 DIMM2.3 DIMM2.8 DIMM2.9 DIMM2.11 DIMM2.13 DIMM2.14 DIMM2.19 DIMM2.20 DIMM2.25 DIMM2.26 DIMM2.28 DIMM2.31 DIMM2.32 DIMM2.37 DIMM2.38 DIMM2.43 DIMM2.44 DIMM2.46 DIMM2.48 DIMM2.49 DIMM2.54 DIMM2.55 DIMM2.60 DIMM2.61 DIMM2.63 DIMM2.65 DIMM2.66 DIMM2.71 DIMM2.72 DIMM2.127 DIMM2.128 DIMM2.133 DIMM2.134 DIMM2.136 DIMM2.138 DIMM2.139 DIMM2.144 DIMM2.145 DIMM2.150 DIMM2.151 DIMM2.153 DIMM2.155 DIMM2.156 DIMM2.161 DIMM2.162 DIMM2.167 DIMM2.168 DIMM2.170 DIMM2.172 DIMM2.173 DIMM2.178 DIMM2.179 DIMM2.184 DIMM2.185 DIMM2.187 DIMM2.189 DIMM2.190 DIMM2.195 DIMM2.196 DIMM2.205 DIMM2.206 FANC3.1 GPU1.A3 GPU1.A30 GPU1.AA11 GPU1.AA13 GPU1.AA16 GPU1.AA27 GPU1.AB6 GPU1.AB10 GPU1.AB15 GPU1.AB24 GPU1.AB32 GPU1.AC9 GPU1.AC17 GPU1.AC24 GPU1.AC26 GPU1.AC27 GPU1.AD6 GPU1.AD8 GPU1.AD25 GPU1.AD32 GPU1.AE7 GPU1.AE14 GPU1.AE27 GPU1.AF32 GPU1.AG12 GPU1.AG27 GPU1.AH10 GPU1.AH28 GPU1.AH32 GPU1.B6 GPU1.B8 GPU1.B10 GPU1.B12 GPU1.B14 GPU1.B16 GPU1.B18 GPU1.B20 GPU1.B22 GPU1.B24 GPU1.B26 GPU1.C1 GPU1.C32 GPU1.E28 GPU1.F2 GPU1.F6 GPU1.F8 GPU1.F10 GPU1.F12 GPU1.F14 GPU1.F16 GPU1.F18 GPU1.F20 GPU1.F22 GPU1.F24 GPU1.F26 GPU1.G8 GPU1.G10 GPU1.G27 GPU1.G31 GPU1.H2 GPU1.H6 GPU1.H14 GPU1.H17 GPU1.H20 GPU1.J7 GPU1.J27 GPU1.J31 GPU1.K2 GPU1.K6 GPU1.K11 GPU1.K22 GPU1.K28 GPU1.K32 GPU1.L27 GPU1.M6 GPU1.M12 GPU1.M32 GPU1.N11 GPU1.N13 GPU1.N16 GPU1.N18 GPU1.N21 GPU1.N25 GPU1.N27 GPU1.P6 GPU1.P9 GPU1.P25 GPU1.P32 GPU1.R11 GPU1.R12 GPU1.R15 GPU1.R17 GPU1.R20 GPU1.R27 GPU1.T6 GPU1.T11 GPU1.T13 GPU1.T16 GPU1.T18 GPU1.T21 GPU1.T25 GPU1.T32 GPU1.U9 GPU1.U15 GPU1.U17 GPU1.U20 GPU1.U25 GPU1.U27 GPU1.V11 GPU1.V13 GPU1.V16 GPU1.V18 GPU1.V32 GPU1.W25 GPU1.W26 GPU1.W27 GPU1.Y10 GPU1.Y15 GPU1.Y17 GPU1.Y20 GPU1.Y25 GPU1.Y32 H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 H6.2 H6.3 H6.4 H6.5 H6.6 H6.7 H6.8 H7.1 H7.2 H7.3 H7.4 H7.5 H7.6 H7.7 H7.8 H9.1 H9.2 H9.3 H9.4 H9.5 H9.6 H9.7 H9.8 H10.1 H10.2 H10.3 H10.4 H10.5 H10.6 H10.7 H10.8 H11.1 H11.2 H11.3 H11.4 H11.5 H11.6 H11.7 H11.8 HDD1.1 HDD1.4 HDD1.7 HDD1.8 HDD1.9 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI2.2 HDMI2.5 HDMI2.8 HDMI2.17 HDMI2.20 HDMI2.21 HDMI2.22 HDMI3.3 HDMI3.9 HDMI3.12 HDMI3.15 HDMI3.18 HDMI3.20 HDMI3.21 HDMI3.22 HDMI3.23 HDMI3.24 HDMI3.25 HDMI4.3 HDMI4.12 HDMI4.15 HDMI4.18 HDMI4.20 HDMI4.21 HDMI4.22 HDMI4.23 HDMI4.24 HDMI4.25 HS6.1 LED2.K LPC1.12 LPC1.14 LVDS1.7 LVDS1.14 LVDS1.31 LVDS1.32 MEM1.A9 MEM1.B1 MEM1.B3 MEM1.B9 MEM1.D1 MEM1.D8 MEM1.E1 MEM1.E2 MEM1.E8 MEM1.F9 MEM1.G1 MEM1.G8 MEM1.G9 MEM1.J2 MEM1.J8 MEM1.M1 MEM1.M9 MEM1.P1 MEM1.P9 MEM1.T1 MEM1.T9 MEM2.A9 MEM2.B1 MEM2.B3 MEM2.B9 MEM2.D1 MEM2.D8 MEM2.E1 MEM2.E2 MEM2.E8 MEM2.F9 MEM2.G1 MEM2.G8 MEM2.G9 MEM2.J2 MEM2.J8 MEM2.M1 MEM2.M9 MEM2.P1 MEM2.P9 MEM2.T1 MEM2.T9 MEM3.A9 MEM3.B1 MEM3.B3 MEM3.B9 MEM3.D1 MEM3.D8 MEM3.E1 MEM3.E2 MEM3.E8 MEM3.F9 MEM3.G1 MEM3.G8 MEM3.G9 MEM3.J2 MEM3.J8 MEM3.M1 MEM3.M9 MEM3.P1 MEM3.P9 MEM3.T1 MEM3.T9 MEM4.A9 MEM4.B1 MEM4.B3 MEM4.B9 MEM4.D1 MEM4.D8 MEM4.E1 MEM4.E2 MEM4.E8 MEM4.F9 MEM4.G1 MEM4.G8 MEM4.G9 MEM4.J2 MEM4.J8 MEM4.M1 MEM4.M9 MEM4.P1 MEM4.P9 MEM4.T1 MEM4.T9 MEMCD1.3 MEMCD1.6 MEMCD1.12 MEMCD1.13 MEMCD1.14 MEMCD1.15 NGFF1.7 NGFF1.18 NGFF1.23 NGFF1.24 NGFF1.29 NGFF1.30 NGFF1.33 NGFF1.36 NGFF1.39 NGFF1.45 NGFF1.57 NGFF1.63 NGFF1.69 NGFF1.75 NGFF1.76 NGFF1.77 ODD1.1 ODD1.4 ODD1.7 ODD1.8 ODD1.9 OSC2.2 PC12.2 PC17.2 PC18.2 PC24.2 PC61.2 PC126.1 PC701.2 PC702.2 PC703.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1076.2 PC1126.2 PC1127.2 PC1128.2 PC1129.2 PC1130.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1139.2 PC1155.2 PC1156.2 PC1157.2 PC1158.2 PC1159.2 PC1160.2 PC1183.2 PC1188.2 PC1189.2 PC1190.2 PC1191.2 PC1192.2 PC1193.2 PC1198.2 PC1199.2 PC4301.2 PC4302.2 PC4303.2 PC4304.2 PC4305.2 PC4402.2 PC4404.2 PC4406.2 PC4407.2 PC4409.2 PC4414.2 PC4416.1 PC4417.2 PC4419.2 PC4501.2 PC4503.2 PC4504.2 PC4505.2 PC4506.2 PC4507.2 PC4509.2 PC4510.2 PC4511.2 PC4512.2 PC4513.2 PC4515.2 PC4516.2 PC4517.2 PC4518.2 PC4602.1 PC4604.2 PC4606.1 PC4611.1 PC4616.2 PC4618.2 PC4622.2 PC4625.2 PC4627.2 PC4628.2 PC4629.2 PC4635.2 PC4636.2 PC4637.1 PC4702.2 PC4725.2 PC4726.2 PC4727.2 PC4728.2 PC4801.2 PC4802.2 PC4803.2 PC4804.2 PC4805.2 PC4806.2 PC4807.2 PC4808.2 PC4809.2 PC4810.2 PC5002.2 PC5003.2 PC5004.2 PC5101.2 PC5102.2 PC5103.2 PC5104.2 PC5105.2 PC5106.2 PC5107.2 PC5109.2 PC5110.2 PC5113.2 PC5115.2 PC5199.2 PC5202.2 PC5204.2 PC5205.2 PC5207.2 PC5209.2 PC5223.1 PC5224.2 PC5225.1 PC5227.2 PC5228.2 PC5229.2 PC5299.2 PC5302.2 PC5303.2 PC5305.2 PC5306.2 PC5307.2 PC5308.2 PC5309.2 PC5310.2 PC5311.2 PC8402.2 PC8403.2 PC8404.2 PC8405.2 PC8406.2 PC8407.2 PC8408.2 PC8409.2 PC8501.2 PC8502.2 PC12172.2 PC12175.2 PC12177.2 PC12178.2 PC12179.2 PC12181.2 PC12184.2 PC12185.2 PC12186.2 PC12187.2 PC12188.2 PC12190.2 PC12191.2 PC12370.2 PC12371.2 PC12372.2 PC12373.2 PC12374.2 PC12375.2 PC12376.2 PC12377.2 PC12378.2 PC12379.2 PC12380.2 PC12381.2 PC12382.2 PC12383.2 PC12384.2 PC12385.2 PC12386.2 PC12387.2 PC12388.2 PC12389.2 PC12390.2 PC12391.2 PC12392.2 PC12393.2 PC12394.2 PC12395.2 PC12396.2 PC12397.2 PC12398.2 PC12399.2 PC12400.2 PC12401.2 PC12402.2 PC12403.2 PC12404.2 PC12405.2 PC12406.2 PC12407.2 PC12408.2 PC12409.2 PC12410.2 PC12411.2 PC12412.2 PC12413.2 PC12414.2 PC12415.2 PC12416.2 PC12417.2 PC12418.2 PC12419.2 PC12420.2 PC12421.2 PC12422.2 PC12423.2 PC12424.2 PC12425.2 PC12426.2 PC12427.2 PC12428.2 PC12429.2 PC12430.2 PC12431.2 PC12432.2 PC12433.2 PC12434.2 PC12435.2 PC12436.2 PC12437.2 PC12438.2 PC12439.2 PC12440.2 PC12441.2 PC12442.2 PL4301.2 PL4302.2 PL4303.2 PQ4204.E PQ4206.S PQ4402.S PQ4403.S PQ4404.1 PQ4404.4 PQ4405.S PQ4406.S PQ5007.1 PQ5007.4 PQ5008.1 PQ5008.4 PR2.2 PR3.2 PR7.2 PR26.2 PR29.1 PR31.2 PR33.2 PR40.2 PR4410.1 PR4417.2 PR4451.2 PR4503.2 PR4506.2 PR4515.2 PR4519.2 PR4535.2 PR4599.2 PR4605.1 PR4612.1 PR4613.1 PR4614.2 PR4620.1 PR4621.2 PR4622.2 PR4626.1 PR4629.2 PR4631.2 PR4644.2 PR4645.1 PR4648.1 PR4649.1 PR4650.2 PR4654.2 PR4655.2 PR5110.2 PR5202.2 PR5207.2 PR5219.2 PR5242.2 PR5298.2 PR5302.2 PR5478.2 PR5479.2 PR5490.2 PR8401.2 PR8503.2 PR8509.1 PR8522.1 PR8524.2 PR8527.1 PSWD1.1 PT1.2 PT2.2 PT3.2 PT4.2 PT4501.2 PT4502.2 PT4503.2 PT4504.2 PT4701.2 PT4703.2 PT4704.2 PT4801.2 PT4802.2 PT4803.2 PT4804.2 PT5001.2 PT5101.2 PT5102.2 PT5103.2 PT5201.2 PT5202.2 PT5203.2 PT8501.2 PU3.1 PU3.2 PU3.3 PU4402.1 PU4402.2 PU4402.3 PU4404.14 PU4404.21 PU4501.21 PU4502.1 PU4502.2 PU4502.3 PU4504.1 PU4504.2 PU4504.3 PU4601.53 PU4702.1 PU4702.2 PU4702.3 PU4703.1 PU4703.2 PU4703.3 PU4802.1 PU4802.2 PU4802.3 PU4803.1 PU4803.2 PU4803.3 PU4805.1 PU4805.2 PU4805.3 PU4807.1 PU4807.2 PU4807.3 PU5002.1 PU5002.2 PU5002.3 PU5003.6 PU5003.9 PU5102.1 PU5102.2 PU5102.3 PU5104.1 PU5104.3 PU5104.14 PU5104.21 PU5201.11 PU5203.1 PU5203.2 PU5203.3 PU5301.2 PU5301.5 PU5301.6 PU5301.14 PU5302.1 PU5409.1 PU5409.2 PU5409.3 PU8401.11 PU8501.1 PWRCN1.4 PWRCN1.11 PWRCN1.12 Q1.S Q2.E Q3.S Q5.S Q6.1 Q6.4 Q8.S Q10.E Q12.S Q22.E Q24.3 Q31.E Q36.1 Q36.4 Q45.E Q46.3 Q48.E Q57.3 Q65.1 Q65.4 Q68.S Q76.S Q100.E Q101.E Q102.E Q128.E Q1212.S Q1214.E Q1217.1 Q1217.4 Q1249.S Q6701.1 Q6701.4 Q6705.S Q9503.1 Q9503.4 Q9619.S Q9620.1 Q9620.4 Q9622.4 Q9626.S Q9627.1 Q9629.S Q9631.1 Q9631.4 Q9632.1 Q9632.4 Q9633.1 Q9633.4 Q9634.S Q9635.4 Q9636.S Q9637.4 Q9638.S Q9639.4 Q9641.S Q9648.S Q9650.1 Q9650.4 Q9651.S Q9652.S Q9653.4 Q9654.1 Q9654.4 R1.2 R19.2 R27.2 R30.2 R33.2 R37.1 R73.1 R132.2 R144.2 R202.1 R210.2 R215.1 R216.1 R293.2 R299.1 R300.1 R301.1 R303.2 R320.1 R321.2 R327.2 R339.2 R379.2 R388.2 R406.2 R412.1 R523.2 R533.2 R542.1 R601.2 R602.1 R604.2 R605.2 R606.1 R702.1 R722.2 R732.2 R870.1 R886.1 R899.1 R924.1 R940.2 R946.1 R948.2 R963.2 R1158.1 R1179.1 R1193.1 R1201.1 R1202.1 R1205.2 R1206.2 R1207.2 R1209.1 R1210.1 R1213.2 R1214.2 R1219.2 R1221.2 R1301.1 R1306.2 R1307.2 R1501.2 R1502.2 R1592.2 R1603.2 R1660.2 R1663.2 R1685.2 R1688.2 R1700.1 R1707.2 R1709.1 R1727.2 R1729.2 R1779.2 R1781.2 R1782.2 R1817.2 R1819.2 R1823.2 R1825.2 R1834.1 R1848.2 R1850.2 R1853.2 R1880.2 R1881.2 R1882.2 R1886.2 R1888.2 R1889.2 R1894.2 R1897.2 R1899.2 R1901.2 R1905.1 R1921.1 R1923.1 R2082.2 R2085.2 R2086.2 R2089.2 R2090.2 R5201.1 R5202.1 R5203.1 R5204.1 R5205.1 R5206.1 R5207.1 R5208.1 R8515.2 R9505.2 R9508.2 R9511.2 R9519.1 R9554.2 R9563.2 R9604.2 R9609.2 R9931.2 R79172.2 R79188.1 R79237.1 R79622.2 R79647.1 R79648.1 R79668.2 R79705.2 R79720.2 R79722.2 R79756.2 R79797.2 R79801.2 R79802.2 R79824.1 R79825.1 R79840.2 R79926.2 R79931.2 R79945.2 R79981.2 R79996.2 R80003.2 R80004.2 R80006.2 R80007.2 R80008.2 R80009.2 R80011.2 R80013.2 R80015.2 R80018.2 R80019.2 R80021.2 R80033.2 R80042.2 R80051.2 R80056.2 R80058.2 R80076.2 R80077.2 R80078.2 R80081.1 R80084.2 R80088.1 R80102.2 R80104.2 R80107.2 R80114.2 R80128.1 R80129.1 R80137.2 R80163.2 R80165.2 R80170.1 R80181.2 R80196.2 R80197.2 R80215.2 R80218.2 R80232.2 R80238.2 R80255.2 R80257.1 RJ1.13 RN9504.1(A) RN9504.2(A) RV1.1 SATAP1.2 SATAP1.4 SCA1.11 SCA1.38 SCA1.61 SCA1.85 SCA1.107 SPK1.5 SPK1.7 SPK1.8 SRCON1.4 SSUSB1.4 SSUSB1.7 SSUSB1.10 SSUSB1.11 SSUSB2.4 SSUSB2.7 SSUSB2.10 SSUSB2.11 TC1.2 TC5.2 TC8.2 TC23.2 TOUCH1.2 U3.3 U3.8 U5.3 U5.8 U6.49 U9.22 U9.27 U10.2 U11.2 U12.2 U14.33 U16.33 U28.3 U28.8 U29.3 U29.8 U49.4 U52.11 U52.15 U54.11 U54.15 U109.4 U109.35 U109.71 U118.8 U118.15 U118.35 U118.41 U120.20 U501.3 U704.5 U706.5 U4101.10 U4101.21 U4101.45 U4101.53 U5201.1 U5201.2 U5201.3 U5201.4 U5202.3 U5203.3 U6701.5 U6701.10 U6701.12 U6701.13 U6701.15 U6701.16 U6706.3 U6706.8 U9501.4 U9502.1 U9502.2 U9502.3 U9502.4 U9601.1 U9602.4 U9624.4 U9625.8 U9625.9 U9625.10 U9625.17 U9625.20 U9625.21 U9625.24 U9625.33 U9626.3 U9628.14 U9628.17 UHS1.MS1 UHS1.MS2 USB3.4 USB3.5 USB3.6 USB4.4 USB4.5 USB4.6 WEBCM1.6 WEBCM1.8 WEBCM1.9 WEBCM1.10 X4.2 X4.4 X9502.2 X9502.4 X9503.2 X9503.4 X9504.2 X9504.3 X9505.2 X9505.4 XDP1.2 XDP1.7 XDP1.8 XDP1.13 XDP1.14 XDP1.19 XDP1.20 XDP1.25 XDP1.26 XDP1.31 XDP1.32 XDP1.37 XDP1.38 XDP1.49 XDP1.50 XDP1.59
GND_AUD: C144.1 C145.2 U6.40
PVCC_3V3: C9504.1 C9516.1 C12170.1 C12191.1 C12197.1 L9502.1 L9505.2 R9503.2 R9507.1 R9521.2 R9525.2 R9528.2 R9544.1 R9545.2 R9548.2 R79205.2 R79236.2 R79798.1 R79799.1 R79800.1 R79868.1 R80173.2 RN9503.6(B) RN9503.7(B) RN9503.8(B) SCA1.49 SCA1.84 U9501.7 U9501.8 U9502.8
PVCC_3V3_SDRAM: C9518.1 C12184.2 C12194.1 C12244.1 L9503.2 SCA1.62 SCA1.106
V0.85A_VID0: CPU1.AN11 TP2101.1
V0.85A_VID1: CPU1.AN13 TP2102.1
VBAT1: BT1.1 R79979.1
VBAT1_R: D2.2 D3.A R79979.2 TP108.1
VBAT2: D3.K R79929.2
VBAT_SIO: C190.1 R79929.1 U109.66
VCC: C20.1 C1832.1 C1833.1 C12199.1 D5205.A F5.1 F7.1 LPC1.8 PC12190.1 PR11.1 PR44.2 PR5481.1 PU8501.6 R101.1 R118.1 R183.1 R185.1 R617.1 R1849.1 R5217.1 R6705.1 R9540.1 R9541.1 R79937.2 R80251.2 U1.1 U1.2 U1.5 U1.6 U52.13 U52.14
VCC3: C127.1 C131.1 C474.1 C478.1 C509.1 C516.1 C836.2 C1203.1 C1311.1 C1834.1 C1835.1 C3367.1 C12131.1 C12160.2 C12200.1 C12201.1 D1.K D19.2 DIMM1.199 DIMM2.199 F1.1 L21.1 L9503.1 LPC1.4 PR4615.1 Q77.S Q9627.5 R12.1 R24.1 R41.1 R71.1 R124.1 R134.1 R138.1 R143.1 R213.1 R249.2 R251.2 R255.2 R257.1 R264.2 R265.2 R286.2 R290.2 R296.2 R323.2 R324.1 R335.1 R342.1 R377.1 R391.2 R507.1 R517.1 R524.1 R530.2 R802.2 R803.2 R1183.2 R1302.1 R1593.1 R1594.1 R1596.1 R1598.1 R1610.2 R1611.2 R1615.1 R1617.2 R1659.1 R1661.1 R1662.1 R1684.1 R1687.1 R1699.1 R1716.2 R1757.1 R1846.1 R2006.1 R2007.1 R2012.1 R2021.1 R2032.1 R2040.2 R2041.2 R2087.1 R2088.1 R6701.1 R6703.1 R6704.1 R9532.1 R9533.1 R9543.1 R9557.1 R9927.1 R79171.1 R79174.2 R79755.1 R79759.1 R79760.1 R79761.1 R79762.1 R79763.1 R79764.1 R79810.1 R79838.1 R79842.1 R79866.1 R79921.2 R79922.2 R79935.2 R79946.2 R79947.2 R79991.1 R80067.2 R80080.1 R80091.2 R80092.2 R80147.2 R80148.2 R80154.2 R80177.1 R80178.1 R80179.1 R80180.1 R80194.1 R80195.1 R80219.2 RN1.5(B) RN1.6(B) RN1.7(B) RN1.8(B) U6.7 U6.11 U14.11 U52.8 U52.9 U118.11 U118.37 U119.3 U4101.4
VCC3_CAM: C1.1 C1770.1 C1771.1 F1.2 F3.2 R24.2 R1784.2 WEBCM1.3
VCC5_33_CT1: C1837.1 U52.12
VCC5_33_CT2: C1836.1 U52.10
VCC5_33_EN: C1831.1 R1878.1 U52.3 U52.5
