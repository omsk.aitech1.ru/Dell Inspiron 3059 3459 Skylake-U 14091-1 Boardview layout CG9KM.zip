# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQS_DN5: length 61.8
  TOP w0.089: CPU1.AY34 93.06,163.43 93.69,163.43 93.89,163.37 94.09,163.37 94.24,163.42 94.51,163.42 94.58,163.35 98.22,163.35 98.61,162.97 98.61,162.8 v4(98.38,162.58)
  TOP w0.102: v4(136.62,142.05) 136.64,142.05 137.04,142.45 137.04,142.72 137.29,142.98 138.3,142.98 138.43,142.85 DIMM1.152
  L3 w0.089: 104.55,158.74 104.45,158.74 99.95,163.24 98.82,163.24 98.64,163.06 98.64,162.83 v4(98.38,162.58)
  L3 w0.127: 104.55,158.74 105.63,158.74 108.05,156.32 108.57,156.32 111.52,153.37 111.52,152.97 111.42,152.87 111.42,152.69 111.69,152.42 111.87,152.42 111.97,152.52 112.37,152.52 112.8,152.09 112.8,151.69 112.69,151.59 112.69,151.41 112.96,151.14 113.14,151.14 113.25,151.24 113.65,151.24 114.07,150.82 114.07,150.42 113.97,150.31 113.97,150.13 114.24,149.86 114.42,149.86 114.52,149.97 114.92,149.97 115.35,149.54 115.35,149.14 115.25,149.04 115.25,148.86 115.52,148.59 115.69,148.59 115.8,148.69 116.2,148.69 116.63,148.27 116.63,147.87 116.54,147.78 116.54,147.6 116.8,147.33 116.98,147.33 117.08,147.42 117.48,147.42 118.83,146.06 121.89,143 122.25,142.64 134.88,142.64 135.5,142.03 135.5,141.98 135.77,141.71 136.28,141.71 v4(136.62,142.05)
  BOTTOM w0.102: v2(136.37,141.26) 136.62,141.52 v4(136.62,142.05)
M_A_DQS_DN6: length 59.3
  TOP w0.089: v4(96.38,161) 96.5,160.88 96.5,160.74 96.38,160.62 95.16,160.62 94.8,160.97 94.21,160.97 94.06,160.92 93.92,160.92 93.72,160.98 93.54,160.98 CPU1.BA30
  TOP w0.102: v4(134,137.44) 133.41,138.03 132.45,138.03 132.16,137.75 DIMM1.169
  L3 w0.089: 102.69,155.42 102.68,155.43 102.68,155.49 102.41,155.76 102.41,155.94 102.3,156.05 98.12,160.22 96.91,160.22 96.64,160.49 96.64,160.88 96.51,161 v4(96.38,161)
  L3 w0.127: v4(134,137.44) 134.07,137.37 134.07,137.14 133.45,136.53 130.41,136.53 130.12,136.81 130.12,137.86 130,137.99 129.61,137.99 129.49,137.86 129.49,136.62 129.2,136.34 127.82,136.34 126.64,137.52 120.59,137.52 102.69,155.42
  BOTTOM w0.102: v2(134.37,136.68) 134,137.05 v4(134,137.44)
M_A_DQS_DN7: length 62.9
  TOP w0.089: CPU1.AY26 93.06,158.45 93.69,158.45 93.89,158.39 94.09,158.39 94.24,158.44 94.48,158.44 95.12,157.8 95.69,157.8 96.04,157.44 96.54,157.44 96.65,157.33 97.34,157.33 97.82,156.85 97.86,156.85 v4(98.02,156.69)
  TOP w0.102: v4(137.07,132.97) 136.81,132.71 136.81,132.34 136.88,132.26 138.08,132.26 138.46,132.65 DIMM1.186
  L3 w0.127: v4(98.02,156.69) 98.19,156.52 98.19,155.72 99.46,154.45 99.46,151.81 104.14,147.13 105.41,147.13 120.78,131.76 136.49,131.76 136.82,132.1 136.82,132.73 137.06,132.97 v4(137.07,132.97)
  BOTTOM w0.102: v4(137.07,132.97) 137.07,132.72 v2(137.55,132.23)
M_A_DQS_DP0: length 71.7
  TOP w0.089: 88.62,186.71 88.62,186.69 88.6,186.68 88.6,185.98 88.56,185.93 88.56,185.67 88.55,185.66 88.55,185.24 88.6,185.09 88.6,184.89 88.54,184.69 88.54,184.34 88.25,183.97 CPU1.AM69
  TOP w0.102: DIMM1.12 138.46,187.25 138.21,187.51 137.68,187.51 136.89,186.72 136.89,186.54 v4(137.11,186.32) ; v4(87.85,190.46) 88.06,190.24 88.42,190.24 88.62,190.04 88.62,186.71
  L3 w0.127: v4(87.85,190.46) 88.03,190.64 88.03,193.83 92.31,198.11 120.51,198.11 130.55,188.06 135.83,188.06 136.94,186.95 136.94,186.49 v4(137.11,186.32)
  BOTTOM w0.102: v2(138.16,185.58) 137.85,185.58 v4(137.11,186.32)
M_A_DQS_DP1: length 66
  TOP w0.089: CPU1.AT70 90.67,184.34 90.72,184.39 90.72,184.73 90.77,184.92 90.77,185.06 90.74,185.2 90.73,185.23 90.72,185.25 90.72,185.63 90.71,185.64 91.47,186.4 91.47,187.17 91.33,187.3 91.12,187.3 v4(91.04,187.23)
  TOP w0.102: DIMM1.29 132.03,182.15 132.18,182.3 132.18,182.44 132.49,182.75 133.26,182.75 133.45,182.56 133.45,182.47 v4(133.33,182.35)
  L3 w0.127: v4(91.04,187.23) 91.22,187.23 91.35,187.1 91.35,186.77 91.47,186.64 91.73,186.64 91.85,186.77 91.85,188.04 92.09,188.28 92.09,189.15 92.26,189.32 92.9,189.32 93.38,188.84 96.71,188.84 99.77,191.9 106.08,191.9 106.92,192.74 107.2,192.74 107.31,192.62 107.31,192.04 107.59,191.76 108.17,191.76 108.47,192.05 108.47,193.29 108.59,193.42 108.96,193.42 109.09,193.29 109.09,192.02 109.37,191.73 109.98,191.73 110.27,192.02 110.27,193.37 110.4,193.5 110.78,193.5 110.9,193.37 110.9,192.1 111.26,191.74 120.85,191.74 129.45,183.14 133.52,183.14 133.64,183.03 133.64,182.66 v4(133.33,182.35)
  BOTTOM w0.102: v2(132.75,183.13) 132.75,182.93 v4(133.33,182.35)
M_A_DQS_DP2: length 56.5
  TOP w0.089: CPU1.AY64 93.06,181.28 93.69,181.28 93.89,181.34 94.09,181.34 94.24,181.29 94.56,181.29 94.71,181.44 95.53,181.44 96.64,182.55 96.64,184.13 98.13,185.61 98.61,185.61 98.62,185.62 98.63,185.62
  TOP w0.102: v4(101.45,186.79) 101.67,186.57 101.67,186.17 101.13,185.62 98.63,185.62 ; DIMM1.47 131.89,176.75 132.33,176.31 133.8,176.31 134.02,176.53 134.02,176.91 v4(134.15,177.04)
  L3 w0.127: v4(134.15,177.04) 134.12,177.04 134.02,177.14 134.02,177.93 133.7,178.24 129.17,178.24 120.14,187.27 106.92,187.27 106.26,187.93 104.86,187.93 104.4,187.48 104.16,187.48 103.7,187.93 102.12,187.93 101.64,187.45 101.64,186.97 v4(101.45,186.79)
  BOTTOM w0.102: v2(135.16,177.8) 134.91,177.8 v4(134.15,177.04)
M_A_DQS_DP3: length 55.8
  TOP w0.089: 95.56,178.49 95.54,178.48 95.54,178.46 95.41,178.32 94.21,178.32 94.06,178.27 93.92,178.27 93.72,178.34 93.54,178.34 CPU1.BA60
  TOP w0.102: v4(137.19,171.58) 137.19,171.91 137.32,172.03 138.27,172.03 138.65,171.65 DIMM1.64 ; 95.56,178.49 95.63,178.56 97.52,180.45 99,180.45 99.15,180.6 99.15,180.79 v4(98.93,181)
  L3 w0.127: v4(137.19,171.58) 137.08,171.69 137.08,172.18 136.73,172.54 132.27,172.54 131.94,172.86 128.97,172.86 118.55,183.27 103.65,183.27 102.88,182.5 101.73,182.5 101.01,181.78 99.28,181.78 98.93,181.43 v4(98.93,181)
  BOTTOM w0.102: v4(137.19,171.58) 137.19,171.45 v2(137.88,170.76)
M_A_DQS_DP4: length 56.7
  TOP w0.089: CPU1.AY38 93.06,166.55 93.69,166.55 93.89,166.61 94.09,166.61 94.24,166.57 95.03,166.57 95.19,166.41 96.13,166.41 v4(96.55,166.83)
  TOP w0.102: DIMM1.137 131.83,147.35 132.24,146.93 133.51,146.93 v4(134.14,147.57)
  L3 w0.089: v4(96.55,166.83) 96.55,166.61 97.03,166.14 97.19,165.97 100.97,165.97 103.52,163.43 104.25,162.7 104.25,162.64 104.27,162.63
  L3 w0.127: v4(134.14,147.57) 133.44,146.87 128.8,146.87 128.51,147.16 128.51,147.33 128.39,147.46 127.94,147.46 127.82,147.33 127.82,146.94 127.53,146.66 126.89,146.66 126.61,146.94 126.61,147.31 126.48,147.44 126.17,147.44 126.04,147.31 126.04,147.16 125.67,146.79 124.77,146.79 109.23,162.33 104.56,162.33 104.27,162.63
  BOTTOM w0.102: v4(134.14,147.57) 134.14,147.07 v2(134.45,146.76)
M_A_DQS_DP5: length 61.8
  TOP w0.089: v4(99.04,162.6) 98.91,162.6 98.8,162.71 98.8,163.04 98.3,163.54 94.64,163.54 94.59,163.6 94.21,163.6 94.06,163.55 93.92,163.55 93.72,163.61 93.54,163.61 CPU1.BA34
  TOP w0.102: v4(137.25,142.05) 137.25,142.63 137.38,142.76 138.21,142.76 138.34,142.63 138.34,142.38 138.46,142.25 DIMM1.154
  L3 w0.089: v4(99.04,162.6) 98.83,162.81 98.83,162.98 98.9,163.05 99.88,163.05 104.29,158.64 104.29,158.63 104.44,158.47 104.55,158.47
  L3 w0.127: 104.55,158.47 105.52,158.47 107.94,156.06 108.46,156.06 110.88,153.64 111.26,153.26 111.26,153.08 111.15,152.98 111.15,152.58 111.58,152.15 111.98,152.15 112.08,152.25 112.26,152.25 112.53,151.98 112.53,151.8 112.43,151.7 112.43,151.3 112.85,150.87 113.25,150.87 113.36,150.98 113.54,150.98 113.81,150.71 113.81,150.53 113.7,150.42 113.7,150.02 114.13,149.6 114.53,149.6 114.63,149.7 114.81,149.7 115.08,149.43 115.08,149.25 114.98,149.15 114.98,148.75 115.41,148.32 115.81,148.32 115.91,148.43 116.09,148.43 116.36,148.16 116.36,147.98 116.27,147.89 116.27,147.49 116.69,147.06 117.1,147.06 117.19,147.15 117.37,147.15 118.72,145.8 118.91,145.61 121.78,142.74 122.14,142.38 134.77,142.38 135.23,141.92 135.23,141.87 135.66,141.45 136.65,141.45 v4(137.25,142.05)
  BOTTOM w0.102: v2(137.65,141.25) 137.25,141.64 v4(137.25,142.05)
M_A_DQS_DP6: length 59.3
  TOP w0.089: CPU1.AY30 93.36,160.81 93.69,160.81 93.89,160.75 94.09,160.75 94.24,160.79 94.71,160.79 95.08,160.43 96.72,160.43 97.07,160.78 v4(97.07,161.03)
  TOP w0.102: DIMM1.171 131.87,137.15 132.54,137.82 133.22,137.82 133.37,137.67 v4(133.37,137.43)
  L3 w0.089: 102.88,155.6 102.87,155.62 102.81,155.62 102.72,155.71 102.6,155.83 102.6,156.02 98.2,160.42 96.98,160.42 96.83,160.57 96.83,160.93 96.93,161.03 v4(97.07,161.03)
  L3 w0.127: v4(133.37,137.43) 133.38,137.43 133.51,137.3 133.51,136.96 133.34,136.79 130.52,136.79 130.39,136.92 130.39,137.97 130.11,138.26 129.5,138.26 129.22,137.97 129.22,136.74 129.09,136.61 127.93,136.61 126.75,137.79 120.7,137.79 102.88,155.6
  BOTTOM w0.102: v2(133.11,136.64) 133.37,136.9 v4(133.37,137.43)
M_A_DQS_DP7: length 62.9
  TOP w0.089: v4(98.7,156.69) 98.85,156.69 98.97,156.81 98.97,156.98 98.85,157.1 97.84,157.1 97.42,157.52 96.73,157.52 96.64,157.62 96.12,157.62 95.76,157.97 95.19,157.97 94.55,158.62 94.21,158.62 94.06,158.57 93.92,158.57 93.72,158.63 93.54,158.63 CPU1.BA26
  TOP w0.102: v4(136.43,132.97) 136.59,132.81 136.59,132.25 136.79,132.05 DIMM1.188
  L3 w0.127: v4(98.7,156.69) 98.59,156.69 98.46,156.56 98.46,155.83 99.73,154.56 99.73,151.92 104.25,147.4 105.52,147.4 120.89,132.03 136.38,132.03 136.56,132.21 136.56,132.84 v4(136.43,132.97)
  BOTTOM w0.102: v2(136.18,132.18) 136.43,132.44 v4(136.43,132.97)
M_A_ODT0: length 64.2
  TOP w0.165: DIMM1.116 137.25,153.65 136.53,152.94 v4(136.53,152.38) ; v4(90.21,170.63) 90.26,170.63 90.55,170.34 CPU1.AT45
  L3 w0.089: 104.43,165.48 104.17,165.48 101.66,168 93.33,168 92.74,168.58 92.39,168.58 91.66,169.31 90.77,169.31 90.21,169.87 v4(90.21,170.63)
  L3 w0.216: 104.43,165.48 110.45,165.48 115.22,160.71 125.5,150.42 131.77,150.42 132.06,150.71 137.62,150.71 137.83,150.93 137.83,151.71 137.68,151.87 137.01,151.87 136.72,152.15 136.72,152.2 v4(136.53,152.38)
  BOTTOM w0.102: v4(136.53,152.38) 136.53,152.38 v2(136.53,151.49)
M_A_ODT1: length 65.4
  TOP w0.165: CPU1.AT43 90.85,168.99 90.85,168.9 v4(90.86,168.89) ; v4(137.9,152.34) 138.01,152.45 DIMM1.120
  L3 w0.089: 104.55,164.97 104.3,164.97 101.51,167.77 93.23,167.77 92.69,168.3 91.45,168.3 v4(90.86,168.89)
  L3 w0.216: 104.55,164.97 110.25,164.97 115.01,160.22 125.3,149.93 132.27,149.93 132.56,150.22 139.75,150.22 139.97,150.43 139.97,152.93 139.73,153.16 138.21,153.16 137.9,152.85 v4(137.9,152.34)
  BOTTOM w0.102: v2(137.93,151.49) 137.9,151.52 v4(137.9,152.34)
M_A_RAS#: length 57.2
  TOP w0.165: CPU1.AU50 91.54,173.29 v4(91.54,173.37) ; v4(137.94,155.4) 137.99,155.45 DIMM1.110
  L3 w0.089: v4(91.54,173.37) 95.65,173.37 97.37,171.65 102.39,171.65 103.92,170.12
  L3 w0.216: 103.92,170.12 112.56,170.12 118.9,163.78 127.13,155.55 127.7,155.55 127.7,155.55 132.14,155.55 132.52,155.93 137.45,155.93 137.94,155.44 v4(137.94,155.4)
  BOTTOM w0.102: v4(137.94,155.4) 137.69,155.15 v2(137.69,154.57)
M_A_WE#: length 59
  TOP w0.165: v4(90.92,170.63) 90.92,170.75 CPU1.AT46 ; v4(134.11,152.4) 134.7,152.99 134.7,153.75 133.64,154.81 132.37,154.81 132.1,154.55 DIMM1.113
  L3 w0.089: 104.3,167.51 102.1,169.72 94.79,169.72 93.5,171 91.29,171 v4(90.92,170.63)
  L3 w0.216: 104.3,167.51 111.66,167.51 116.42,162.76 126.77,152.4 130.95,152.4 131.44,152.9 133.62,152.9 v4(134.11,152.4)
  BOTTOM w0.165: v2(135.01,153.21) 134.93,153.21 v4(134.11,152.4)
M_B_A0: length 78.3
  TOP w0.089: CPU1.BA46 93.9,170.64 93.9,170.64 94.23,170.72 95.16,170.72 95.19,170.69 95.66,170.69 96.33,171.36 97.03,171.36 97.25,171.13 97.25,171.01 v4(97.06,170.81)
  TOP w0.165: DIMM2.98 154.58,159.07 153.32,159.07 153.2,158.94 153.2,158.37 153.07,158.24 152.05,158.24 151.93,158.37 151.93,158.6 152.26,158.94 152.26,158.94 152.39,159.07 v4(152.44,159.07)
  L4 w0.089: 103.16,167.77 102.9,167.77 100.97,169.7 98.18,169.7 v4(97.06,170.81)
  L4 w0.216: 103.16,167.77 113.84,167.77 127.81,153.79 129.33,153.79 129.41,153.88 130.76,153.88 131.15,153.49 135.98,153.49 136.05,153.56 145.05,153.56 145.55,154.05 149.19,154.05 151.12,155.99 151.12,156.87 151.25,157 151.81,157 151.93,156.87 151.93,156.56 152.22,156.28 152.63,156.28 152.91,156.56 152.91,156.97 152.9,156.98 152.9,158.93 152.77,159.06 152.45,159.06 v4(152.44,159.07)
  BOTTOM w0.102: v2(152.17,159.88) 152.44,159.61 v4(152.44,159.07)
M_B_A1: length 79.7
  TOP w0.089: CPU1.AY46 93.61,170.85 94.02,170.85 94.02,170.85 94.21,170.9 95.23,170.9 95.24,170.89 95.59,170.89 96.24,171.54 98.08,171.54 98.2,171.41 98.2,171.25 98.08,171.13 98.06,171.13 97.93,171 97.93,170.94 97.8,170.81 v4(97.7,170.81)
  TOP w0.165: v4(150.45,157.56) 150.51,157.56 150.63,157.68 150.63,157.71 150.91,157.98 151.52,157.98 151.65,158.11 151.65,158.49 151.52,158.61 150.84,158.61 150.82,158.64 150.03,158.64 149.76,158.91 149.76,159.56 149.64,159.68 148.45,159.68 148.34,159.56 148.34,158.93 148.17,158.77 147.84,158.77 147.68,158.93 147.68,159.19 147.51,159.35 DIMM2.97
  L4 w0.089: 102.9,168.28 101.3,169.88 98.64,169.88 v4(97.7,170.81)
  L4 w0.216: 102.9,168.28 114.03,168.28 128.02,154.29 131.24,154.29 131.72,153.81 133.98,153.81 134.23,154.05 144.47,154.05 144.98,154.56 149.21,154.56 150.81,156.16 150.81,156.51 150.42,156.9 150.15,156.9 150.02,157.03 150.02,157.28 150.29,157.56 v4(150.45,157.56)
  BOTTOM w0.165: v2(150.6,158.34) 150.45,158.19 v4(150.45,157.56)
M_B_A2: length 81.2
  TOP w0.089: CPU1.AY47 93.14,171.49 93.57,171.49 93.89,171.56 94.1,171.56 94.23,171.53 94.7,171.53 95.07,171.9 98.89,171.9 98.98,171.99 98.98,172.49 99.07,172.57 99.24,172.57 99.33,172.49 99.33,171.83 99.46,171.7 100.52,171.7 100.64,171.83 100.64,172.03 100.52,172.16 99.88,172.16 99.75,172.29 99.75,172.47 99.88,172.59 100.11,172.59 100.24,172.72 v4(100.24,172.97)
  TOP w0.165: v4(151.39,161.01) 151.01,161.01 150.88,160.88 150.88,159.92 151.15,159.65 151.6,159.65 151.76,159.82 151.76,160.36 151.93,160.53 152.26,160.53 152.42,160.36 152.42,159.82 152.59,159.65 DIMM2.96
  L4 w0.089: 101.26,173.47 101.2,173.41 100.39,173.41 100.24,173.25 v4(100.24,172.97)
  L4 w0.216: 101.26,173.47 101.92,174.13 102.65,174.13 102.99,174.47 120.62,174.47 129.23,165.86 129.51,165.86 129.71,166.07 129.71,166.67 129.92,166.88 130.37,166.88 130.58,166.67 130.58,165.81 130.78,165.61 131.48,165.61 131.73,165.86 132.75,165.86 134.09,164.52 138.08,164.52 138.59,164.01 138.59,162.76 138.79,162.56 139.34,162.56 139.54,162.76 139.54,163.12 139.74,163.32 140.33,163.32 140.53,163.12 140.53,162.81 140.73,162.61 142.53,162.61 143.71,161.43 145,161.43 145.95,160.48 150.41,160.48 150.94,161.01 v4(151.39,161.01)
  BOTTOM w0.102: v4(151.39,161.01) 150.86,160.48 v2(150.86,160.22)
M_B_A3: length 79.5
  TOP w0.089: CPU1.BB46 96.07,170.46 v4(96.43,170.81)
  TOP w0.165: v4(151.03,159.08) 150.17,159.94 146.41,159.94 DIMM2.95
  L4 w0.089: 103.16,167.25 100.89,169.52 97.72,169.52 v4(96.43,170.81)
  L4 w0.216: 103.16,167.25 113.65,167.25 128.01,152.9 132.08,152.9 132.24,153.06 146.22,153.06 146.7,153.54 149.13,153.54 151.16,155.57 152.15,155.57 152.43,155.86 152.66,155.86 153.32,156.52 153.32,159 152.71,159.62 151.58,159.62 v4(151.03,159.08)
  BOTTOM w0.102: v4(151.03,159.08) 151.03,158.96 151.67,158.32 v2(151.85,158.32)
M_B_A4: length 80
  TOP w0.089: v4(100.87,172.97) 100.87,171.7 100.6,171.43 98.99,171.43 98.71,171.71 95.14,171.71 94.77,171.35 94.2,171.35 94.07,171.39 93.91,171.39 93.62,171.31 CPU1.BA47
  TOP w0.165: DIMM2.92 152.94,160.85 v4(152.75,161.04)
  L4 w0.216: v4(152.75,161.04) 152.75,161.24 152.88,161.37 154.8,161.37 154.92,161.24 154.92,160.64 154.8,160.51 151.13,160.51 150.61,159.99 147.45,159.99 147.29,160.14 144.29,160.14 142.31,162.12 138.71,162.12 138.03,162.79 135.31,162.79 135.09,162.58 135.09,162.26 134.89,162.05 134.43,162.05 134.23,162.26 134.23,162.58 134.01,162.79 131.75,162.79 131.48,163.07 131.48,163.55 132.6,164.67 132.6,164.97 132.29,165.28 131.99,165.28 130.87,164.16 130.56,164.16 129.52,165.2 129.19,165.2 120.86,173.53 103.46,173.53 103.03,173.1 101,173.1 v4(100.87,172.97)
  BOTTOM w0.102: v2(153.32,160.29) 153.32,160.47 v4(152.75,161.04)
M_B_A5: length 79.6
  TOP w0.089: v4(99.6,172.97) 99.2,173.37 98.17,173.37 97.26,172.47 94.83,172.47 94.62,172.26 93.69,172.26 93.48,172.04 93.44,172.03 93.29,172.03 93.23,171.98 CPU1.AY48
  TOP w0.165: DIMM2.91 146.4,161.16 147.85,161.16 v4(148.02,160.99)
  L4 w0.089: 101.13,173.86 100.87,173.61 100.24,173.61 v4(99.6,172.97)
  L4 w0.216: v4(148.02,160.99) 146.18,160.99 144.99,162.18 143.67,162.18 142.04,163.8 139.45,163.8 137.96,165.3 134.25,165.3 133.89,165.66 133.89,166.24 133.64,166.5 131.62,166.5 130.73,167.39 128.41,167.39 128.15,167.64 128.15,167.95 129.06,168.85 129.06,169.16 128.75,169.46 128.45,169.46 127.54,168.56 127.24,168.56 126.93,168.86 126.93,169.17 127.83,170.07 127.83,170.38 127.53,170.68 127.22,170.68 126.32,169.78 126.01,169.78 125.71,170.09 125.71,170.39 126.61,171.3 126.61,171.6 126.31,171.91 126,171.91 125.1,171 124.79,171 124.49,171.31 124.49,171.61 125.39,172.52 125.39,172.82 125.09,173.13 124.78,173.13 123.88,172.22 123.57,172.22 123.19,172.61 123.19,172.94 124.03,173.78 124.03,174.07 123.69,174.42 123.4,174.42 122.77,173.79 122.18,173.79 121,174.97 102.89,174.97 102.42,174.5 101.76,174.5 101.13,173.86
  BOTTOM w0.102: v2(148.34,160.2) 148.02,160.52 v4(148.02,160.99)
M_B_A6: length 77.8
  TOP w0.089: CPU1.BA48 93.94,172.06 94.7,172.06 94.92,172.29 97.65,172.29 v4(98.33,172.97)
  TOP w0.165: DIMM2.90 153.41,161.45 153,161.87 v4(152.94,161.87)
  L4 w0.089: 101.38,172.57 98.73,172.57 v4(98.33,172.97)
  L4 w0.216: v4(152.94,161.87) 155.2,161.87 155.33,161.74 155.33,160.2 155.2,160.07 151.33,160.07 150.87,159.61 144.1,159.61 142.2,161.52 140.84,161.52 140.72,161.39 140.72,160.45 140.52,160.25 139.98,160.25 139.85,160.38 139.85,161.39 139.73,161.52 132.01,161.52 130.44,163.09 130.44,163.8 129.67,164.57 129.01,164.57 120.68,172.9 103.48,172.9 103.16,172.57 101.38,172.57
  BOTTOM w0.165: v2(152.23,162.79) 152.23,162.76 152.94,162.05 v4(152.94,161.87)
M_B_A7: length 80.9
  TOP w0.165: CPU1.AP48 88.87,172.41 v4(88.87,172.48) ; DIMM2.86 153.7,162.65 153.57,162.79 152.4,162.79 152.39,162.78 151.59,162.78 151.41,162.61 v4(151.41,162.04)
  L4 w0.089: 102.14,175.8 97.73,175.8 94.01,172.08 89.27,172.08 v4(88.87,172.48)
  L4 w0.216: v4(151.41,162.04) 151.41,162.33 151.56,162.48 152.28,162.48 152.48,162.68 152.48,163.03 152.28,163.23 150.57,163.23 150.44,163.11 150.44,161.7 150.24,161.49 149.78,161.49 149.58,161.7 149.58,162.89 149.45,163.02 145.55,163.02 144.79,163.78 143.62,163.78 142.46,164.95 141.43,164.95 138.51,167.87 131.76,167.87 123.67,175.96 102.56,175.96 102.4,175.8 102.14,175.8
  BOTTOM w0.165: v4(151.41,162.04) v2(150.58,162.04)
M_B_A8: length 76.2
  TOP w0.089: CPU1.BB48 94.69,171.79 95,172.09 98.59,172.09 98.71,172.21 98.71,172.72 v4(98.97,172.97)
  TOP w0.165: DIMM2.89 149.18,161.75 149.38,161.55 v4(149.38,160.97)
  L4 w0.216: v4(98.97,172.97) 98.97,173.23 99.48,173.74 99.48,174.21 100.09,174.82 102.08,174.82 102.73,175.46 123.45,175.46 130.02,168.89 130.03,168.89 130.32,168.6 130.32,168.6 131.87,167.05 134.2,167.05 134.4,166.85 134.4,165.96 134.6,165.76 135.06,165.76 135.26,165.96 135.26,166.85 135.47,167.05 137.49,167.05 137.89,167.44 138.18,167.44 138.5,167.12 138.5,166.83 137.97,166.3 137.97,166 138.28,165.69 138.58,165.69 139.24,166.35 139.52,166.35 139.85,166.03 139.85,165.74 139.19,165.08 139.19,164.78 139.58,164.39 142.26,164.39 143.97,162.67 145.2,162.67 145.36,162.51 146.24,162.51 146.44,162.31 146.44,161.65 146.64,161.44 147.12,161.44 147.32,161.65 147.32,162.41 147.53,162.61 147.98,162.61 148.19,162.41 148.19,161.75 148.39,161.54 149.17,161.54 149.38,161.34 v4(149.38,160.97)
  BOTTOM w0.102: v4(149.38,160.97) 149.38,160.48 v2(149.63,160.23)
M_B_A9: length 76.9
  TOP w0.165: v4(88.91,173.4) 88.91,173.25 89.21,172.95 CPU1.AP50 ; v4(150.45,164.06) 150.45,163.63 149.78,162.95 DIMM2.85
  L4 w0.089: v4(88.91,173.4) 88.91,173.56 90.13,174.78 91.16,174.78
  L4 w0.216: v4(150.45,164.06) 150.45,164.36 150.19,164.63 146.28,164.63 144.64,166.27 143.55,166.27 140.95,168.87 140.95,168.87 140.57,169.25 140.56,169.25 138.93,170.89 135.59,170.89 135.42,171.07 135.42,171.86 135.01,172.26 129.5,172.26 124.32,177.44 102.12,177.44 101.58,176.91 96.93,176.91 95.35,175.32 94.6,175.32 94.38,175.11 94.38,174.75 94.18,174.55 93.72,174.55 93.52,174.75 93.52,175.11 93.3,175.32 92.45,175.32 91.9,174.78 91.16,174.78
  BOTTOM w0.102: v2(149.89,163.27) 149.89,163.5 v4(150.45,164.06)
M_B_A10: length 78.7
  TOP w0.089: CPU1.AW46 92.66,170.36 93,170.25 93.42,170.25 93.51,170.2 94.8,170.2 94.83,170.23 94.88,170.23 94.9,170.25 97.77,170.25 97.87,170.36 98.26,170.36 98.38,170.48 98.38,170.76 v4(98.33,170.81)
  TOP w0.165: v4(149.31,155.38) 149.55,155.62 149.55,155.63 149.71,155.8 149.71,156.79 149.89,156.97 149.89,157.23 149.77,157.35 147.99,157.35 147.87,157.23 147.87,156.99 147.23,156.35 DIMM2.107
  L4 w0.089: 102.9,168.78 102.65,168.78 101.38,170.05 99.09,170.05 v4(98.33,170.81)
  L4 w0.216: v4(149.31,155.38) 149.31,155.12 149.09,154.9 147.78,154.9 147.51,155.17 144.9,155.17 144.78,155.05 144.77,155.05 144.26,154.55 140.16,154.55 140.05,154.43 133.93,154.43 133.58,154.78 128.22,154.78 127.38,155.63 127.38,155.94 128.01,156.58 128.01,156.88 127.71,157.19 127.4,157.19 126.76,156.55 126.46,156.55 126.15,156.85 126.15,157.16 126.79,157.8 126.79,158.1 126.49,158.41 126.18,158.41 125.54,157.77 125.24,157.77 124.93,158.08 124.93,158.38 125.57,159.02 125.57,159.32 125.26,159.63 124.96,159.63 124.32,158.99 124.02,158.99 114.22,168.78 102.9,168.78
  BOTTOM w0.102: v4(149.31,155.38) 149.18,155.26 v2(149.18,154.56)
M_B_A11: length 81.5
  TOP w0.165: v4(88.21,172.49) 88.21,172.42 CPU1.AN48 ; DIMM2.84 v4(152.93,163.25)
  L4 w0.089: 92.11,172.97 92.08,172.94 88.66,172.94 v4(88.21,172.49)
  L4 w0.216: 92.11,172.97 94.39,172.97 97.57,176.15 102.19,176.15 102.5,176.45 123.88,176.45 131.4,168.94 138.16,168.94 140.68,166.41 142.01,166.41 144.14,164.28 144.99,164.28 145.72,163.55 150.78,163.55 151.06,163.83 154.95,163.83 155.15,163.63 155.15,162.56 154.95,162.36 153.06,162.36 152.93,162.48 v4(152.93,163.25)
  BOTTOM w0.102: v2(153.73,163.12) 153.06,163.12 v4(152.93,163.25)
M_B_A12: length 80.3
  TOP w0.165: DIMM2.83 148.98,163.55 149.26,163.83 149.26,165.72 v4(149.65,166.12) ; v4(88.22,173.38) 88.27,173.38 88.6,173.06 CPU1.AN50
  L4 w0.089: v4(88.22,173.38) 87.94,173.38 87.74,173.58 87.74,174.65 87.94,174.85 88.38,174.85 88.68,175.15 88.68,175.72 89.09,176.13 94.38,176.13 94.58,176.32 94.59,176.32 96.94,178.68 96.94,178.79 97.57,179.42 98.03,179.42
  L4 w0.216: v4(149.65,166.12) 147.28,166.12 146.85,166.55 146.85,166.85 147.39,167.39 147.39,167.68 147.06,168.01 146.78,168.01 146.23,167.46 145.93,167.46 145.52,167.87 144.11,167.87 138.34,173.65 138.34,173.69 138.01,174.02 135.69,174.02 134.96,174.75 129.55,174.75 125.36,178.94 102.75,178.94 102.27,179.43 98.03,179.43 98.03,179.42
  BOTTOM w0.102: v4(149.65,166.12) 149.4,165.86 v2(149.4,165.28)
M_B_A13: length 75.9
  TOP w0.089: CPU1.BA43 93.58,168.95 93.91,169.03 94.08,169.03 94.2,169 94.96,169 95.29,169.32 96.37,169.32 v4(96.79,168.91)
  TOP w0.165: DIMM2.119 148.02,152.75 148.19,152.92 148.19,153.82 148.31,153.95 148.72,153.95 148.85,153.82 148.85,153.42 150.15,152.12 150.15,151.72 150.4,151.46 v3(150.4,151.13)
  L4 w0.089: v4(96.79,168.91) 96.71,168.82 96.71,167.94 97.13,167.51 100.36,167.51 103.68,164.2
  L4 w0.216: 103.68,164.2 109.77,164.2 125.51,148.46 132.15,148.46 132.19,148.5 135.09,148.5 135.53,148.94 135.57,148.94 135.69,149.07 138.28,149.07 138.71,148.64 145.65,148.64 147.19,150.18 148.94,150.18 149.89,151.13 v3(150.4,151.13)
  BOTTOM w0.165: v3(150.4,151.13) 149.84,151.13 v2(149.54,151.43)
M_B_A14: length 79.8
  TOP w0.165: CPU1.AN52 88.6,173.97 v4(88.25,174.32) ; v4(153.07,164.4) 153.12,164.45 154.6,164.45 DIMM2.80
  L4 w0.089: v4(88.25,174.32) 88.91,174.98 88.91,175.56 89.3,175.95 94.94,175.95 95.18,176.2
  L4 w0.165: 95.18,176.2 95.18,176.25
  L4 w0.216: 95.18,176.25 97.18,178.25 101.96,178.25 102.14,178.44 124.87,178.44 129.32,173.99 135.11,173.99 135.42,173.69 135.42,173.28 135.85,172.85 138.43,172.85 143.91,167.38 145.31,167.38 147.05,165.63 150.54,165.63 150.9,165.99 154.31,165.99 154.52,165.79 154.52,164.6 154.31,164.4 v4(153.07,164.4)
  BOTTOM w0.165: v2(152.97,165.18) 153.07,165.07 v4(153.07,164.4)
M_B_A15: length 78.7
  TOP w0.165: CPU1.AN53 88.6,174.61 v4(88.93,174.27) ; v4(151.47,164.34) 151.61,164.34 152.32,165.05 DIMM2.78
  L4 w0.089: v4(88.93,174.27) 89.11,174.45 89.11,175.45 89.32,175.66 95.18,175.66 97.36,177.84 101.73,177.84
  L4 w0.216: v4(151.47,164.34) 151.47,164.62 151.7,164.85 152.59,164.85 152.79,165.05 152.79,165.46 152.59,165.66 151.02,165.66 150.67,165.31 146.51,165.31 145.03,166.79 143.79,166.79 138.27,172.31 135.75,172.31 135.14,172.92 129.54,172.92 124.52,177.94 102.1,177.94 102,177.84 101.73,177.84
  BOTTOM w0.102: v2(151.14,163.45) 151.14,164.01 v4(151.47,164.34)
M_B_BS0: length 79.1
  TOP w0.127: v4(100.36,170.81) 101.13,170.81 101.25,170.94 101.25,171.88 101.38,172.01 101.84,172.01 101.96,171.88 101.96,169.93 101.84,169.8 98.1,169.8 97.99,169.7 95.13,169.7 95.11,169.67 95.09,169.67 94.85,169.43 CPU1.BB44
  TOP w0.165: DIMM2.109 147.4,155.75 148.05,156.4 v4(148.05,156.51)
  L4 w0.089: v4(100.36,170.81) 100.49,170.69 102.51,170.69 102.9,170.3
  L4 w0.216: 102.9,170.3 119.09,170.3 119.44,169.95 119.44,169.64 118.69,168.89 118.69,168.58 119,168.28 119.3,168.28 120.25,169.22 120.42,169.22 120.86,168.79 120.86,168.61 119.91,167.66 119.91,167.36 120.22,167.05 120.52,167.05 121.53,168.06 121.71,168.06 122.14,167.63 122.14,167.45 121.13,166.44 121.13,166.14 121.44,165.83 121.75,165.83 122.5,166.59 122.8,166.59 128.83,160.56 128.83,160.1 130.39,158.55 130.39,157.58 131.27,156.69 147.88,156.69 v4(148.05,156.51)
  BOTTOM w0.102: v2(149.41,157) 149.39,156.97 148.51,156.97 v4(148.05,156.51)
M_B_BS1: length 78.6
  TOP w0.089: v4(99.6,170.81) 98.84,170.05 98.46,170.05 98.4,170 98.02,170 97.91,169.89 95.05,169.89 95.03,169.87 95.01,169.87 94.94,169.8 94.92,169.8 94.83,169.71 93.83,169.71 93.66,169.54 CPU1.BA44
  TOP w0.165: DIMM2.108 150.3,156.05 150.18,156.18 v4(150.18,156.41)
  L4 w0.089: 102.52,169.8 101.91,170.41 100,170.41 v4(99.6,170.81)
  L4 w0.216: 102.52,169.8 116.77,169.8 122.04,164.53 122.35,164.53 122.88,165.06 123.18,165.06 123.49,164.76 123.49,164.45 122.96,163.92 122.96,163.61 123.26,163.31 123.57,163.31 124.1,163.84 124.41,163.84 124.71,163.54 124.71,163.23 124.18,162.7 124.18,162.39 124.48,162.09 124.79,162.09 125.32,162.62 125.63,162.62 125.93,162.31 125.93,162.01 125.4,161.48 125.4,161.17 125.71,160.86 126.01,160.86 126.54,161.4 126.85,161.4 127.15,161.09 127.15,160.79 126.62,160.25 126.62,159.95 126.93,159.64 127.23,159.64 127.77,160.18 128.07,160.18 128.38,159.87 128.38,159.57 127.84,159.03 127.84,158.73 128.28,158.29 129.06,158.29 131.11,156.25 138.27,156.25 138.32,156.2 147.55,156.2 147.84,155.91 150.05,155.91 150.18,156.03 v4(150.18,156.41)
  BOTTOM w0.102: v4(150.18,156.41) 150.18,155.77 v2(150.32,155.63)
M_B_BS2: length 79.3
  TOP w0.165: v4(89.55,173.41) 89.55,173.5 89.25,173.8 CPU1.AP52 ; v4(147.91,164.14) 147.97,164.14 148.12,164.29 148.15,164.29 148.42,164.56 148.72,164.56 148.85,164.69 148.85,165.71 148.72,165.84 147.97,165.84 147.85,165.71 147.85,165.03 147.58,164.77 146.42,164.77 DIMM2.79
  L4 w0.089: v4(89.55,173.41) 89.94,173.8 91.85,173.8
  L4 w0.216: 91.85,173.8 94.59,173.8 97.32,176.53 101.86,176.53 102.28,176.95 124.09,176.95 130.2,170.84 130.57,170.84 131.45,171.72 131.74,171.72 132.06,171.4 132.06,171.11 131.14,170.19 131.14,169.82 131.34,169.62 133.1,169.62 133.31,169.82 133.31,170.87 133.52,171.09 133.96,171.09 134.17,170.87 134.17,169.61 134.39,169.39 139.72,169.39 140.07,169.04 140.07,168.74 139.59,168.25 139.59,167.95 139.9,167.64 140.2,167.64 140.69,168.13 140.99,168.13 144.34,164.77 145.34,164.77 145.98,164.14 v4(147.91,164.14)
  BOTTOM w0.102: v2(147.99,163.35) 147.91,163.43 v4(147.91,164.14)
M_B_CAS#: length 80.8
  TOP w0.089: CPU1.AY43 93.06,168.53 93.14,168.51 93.42,168.51 93.56,168.55 93.78,168.55 93.91,168.51 94.09,168.51 94.17,168.55 95.29,168.55 95.31,168.52 95.65,168.52 95.66,168.53 95.74,168.53 v4(96.13,168.92)
  TOP w0.165: v3(151.16,151.13) 151.16,151.58 149.53,153.21 149.53,153.55 148.7,154.38 148.17,154.38 147.73,153.95 DIMM2.115
  L4 w0.089: 103.79,163.7 100.24,167.26 97.14,167.26 96.13,168.27 v4(96.13,168.92)
  L4 w0.216: 103.79,163.7 109.57,163.7 125.3,147.97 132.36,147.97 132.55,148.16 135.23,148.16 135.83,148.75 138.15,148.75 138.77,148.13 145.7,148.13 147.43,149.86 151.54,149.86 152.51,150.83 152.51,151.31 152.13,151.69 151.63,151.69 151.16,151.22 v3(151.16,151.13)
  BOTTOM w0.102: v2(150.91,150.29) 150.91,150.88 v3(151.16,151.13)
M_B_CKE0: length 75.8
  TOP w0.165: DIMM2.73 148.45,166.55 148.57,166.68 148.57,167.49 148.7,167.61 149.64,167.61 149.77,167.49 v3(149.77,167) ; v4(88.27,176.12) 88.27,176.28 CPU1.AN56
  L4 w0.089: v4(88.27,176.12) 88.46,176.31 94.05,176.31 94.37,176.63
  L4 w0.216: 94.37,176.63 97.72,179.99 102.92,179.99 103,179.91 125.15,179.91 129.17,175.9 135.19,175.9 135.42,175.67 135.42,175.18 135.72,174.88 138.49,174.88 145,168.37 147.62,168.37 148.62,167.36 148.62,166.85 148.75,166.73 149.64,166.73 149.77,166.85 v3(149.77,167)
  BOTTOM w0.165: v2(148.83,167.16) 149.61,167.16 v3(149.77,167)
M_B_CKE1: length 77.6
  TOP w0.165: CPU1.AP55 88.73,175.37 v4(88.25,175.28) ; v4(151.29,167) 151.86,166.54 DIMM2.74
  L4 w0.089: 97.83,180.34 97.66,180.34 93.8,176.49 90.63,176.49 90.59,176.52 88.1,176.52 87.87,176.28 87.87,176 v4(88.25,175.28)
  L4 w0.216: v4(151.29,167) 150.91,167.39 150.83,167.41 150.71,167.46 148.11,168.32 147.57,168.86 145.24,168.86 137.6,176.5 129.52,176.5 125.61,180.42 102.95,180.42 102.88,180.34 97.83,180.34
  BOTTOM w0.165: v2(152.48,167.69) 151.98,167.69 v4(151.29,167)
M_B_CLK0: length 79.3
  TOP w0.102: DIMM2.101 147.26,158.15 147.33,158.22 147.34,158.22 147.65,158.53 148.59,158.53 149.22,157.89 v4(149.22,157.85) ; CPU1.AP45 89.25,170.09 v4(88.9,169.74)
  L4 w0.089: 89.7,170.95 89.63,170.88 89.63,170.47 v4(88.9,169.74)
  L4 w0.127: 89.7,170.95 89.82,171.07 93.19,171.07 93.32,170.94 93.32,170.36 93.66,170.01 94.14,170.01 94.49,170.36 94.49,170.94 95.25,171.71 95.94,171.71 96.17,171.48 96.17,171.48 96.32,171.32 101.74,171.32 102.08,170.98 119.75,170.98 126.68,164.05 126.68,163.75 129.07,161.37 129.32,161.37 132.09,158.6 132.09,158.05 132.37,157.76 132.97,157.76 133.26,158.05 133.26,159.16 133.38,159.28 133.77,159.28 133.89,159.16 133.89,158.05 134.18,157.76 135.43,157.76 135.71,158.05 135.71,158.42 135.84,158.55 136.22,158.55 136.34,158.42 136.34,158.05 136.63,157.76 137.64,157.76 137.92,158.05 137.92,158.43 138.05,158.56 138.43,158.56 138.56,158.43 138.56,158.05 138.84,157.76 146.84,157.76 147.49,157.12 148.5,157.12 v4(149.22,157.85)
  BOTTOM w0.102: v4(149.22,157.85) 149.22,158.54 v2(149.33,158.65)
M_B_CLK1: length 78.5
  TOP w0.102: CPU1.AP46 89.31,171.05 89.31,170.76 89.2,170.65 v4(88.97,170.65) ; DIMM2.102 153.54,157.85 153.44,157.95 153.41,157.95 153.41,157.95 152.54,157.95 152.54,157.95 152.23,157.95 151.98,157.7 151.89,157.7 151.77,157.58 v4(151.77,157.52)
  L4 w0.127: v4(151.77,157.52) 152.03,157.78 152.03,158.28 151.95,158.36 149.46,158.36 149.15,158.67 142.71,158.67 142.42,158.95 142.42,159.95 142.26,160.12 141.92,160.12 141.79,159.99 141.79,158.96 141.5,158.67 139.89,158.67 138.69,159.87 132.44,159.87 129.29,163.02 128.99,163.02 124.42,167.59 120.1,171.91 97.28,171.91 96.89,172.3 95.13,172.3 94.39,171.56 88.87,171.56 88.75,171.44 88.75,170.75 88.84,170.65 v4(88.97,170.65)
  BOTTOM w0.102: v2(151.52,156.68) 151.52,157.26 v4(151.77,157.52)
M_B_CLK#0: length 79.4
  TOP w0.102: v4(148.57,157.84) 148.72,157.99 148.72,158.09 148.5,158.32 147.74,158.32 147.48,158.05 147.48,158.01 147.48,157.8 147.23,157.55 DIMM2.103 ; v4(88.23,169.76) 88.6,170.12 CPU1.AN45
  L4 w0.089: v4(88.23,169.76) 88.62,170.14 89.03,170.14 89.44,170.55 89.44,171.07
  L4 w0.127: 89.44,171.07 89.71,171.34 93.3,171.34 93.58,171.05 93.58,170.47 93.77,170.28 94.03,170.28 94.22,170.47 94.22,171.05 95.14,171.97 96.05,171.97 96.28,171.74 96.43,171.59 101.85,171.59 102.19,171.24 119.87,171.24 126.94,164.16 126.94,163.86 129.18,161.63 129.43,161.63 132.36,158.71 132.36,158.16 132.48,158.03 132.86,158.03 132.99,158.16 132.99,159.27 133.27,159.55 133.88,159.55 134.16,159.27 134.16,158.16 134.29,158.03 135.31,158.03 135.44,158.16 135.44,158.53 135.73,158.81 136.33,158.81 136.61,158.53 136.61,158.16 136.74,158.03 137.53,158.03 137.66,158.16 137.66,158.54 137.94,158.82 138.54,158.82 138.83,158.54 138.83,158.16 138.95,158.03 146.95,158.03 147.6,157.39 148.28,157.39 148.57,157.68 v4(148.57,157.84)
  BOTTOM w0.102: v2(148.12,158.62) 148.12,158.29 v4(148.57,157.84)
M_B_CLK#1: length 78.3
  TOP w0.102: CPU1.AN46 88.32,170.85 v4(88.32,170.64) ; v4(152.41,157.52) 152.63,157.73 153.32,157.73 153.81,157.25 DIMM2.104
  L4 w0.127: v4(88.32,170.64) 88.48,170.8 88.48,171.55 88.76,171.83 94.28,171.83 95.02,172.57 97,172.57 97.39,172.17 120.21,172.17 127.98,164.41 129.1,163.28 129.4,163.28 132.55,160.13 138.8,160.13 140,158.93 141.39,158.93 141.52,159.07 141.52,160.1 141.81,160.38 142.37,160.38 142.69,160.06 142.69,159.06 142.82,158.93 149.26,158.93 149.57,158.62 152.06,158.62 152.3,158.39 152.3,157.63 v4(152.41,157.52)
  BOTTOM w0.102: v4(152.41,157.52) 153.21,157.52 v2(153.22,157.53)
M_B_CS#0: length 77.6
  TOP w0.089: CPU1.BB42 94.37,168.17 98.1,168.17 v4(98.84,168.91)
  TOP w0.165: DIMM2.114 154.52,154.33 152.1,154.33 151.75,154.69 151.75,155.52 151.62,155.65 149.94,155.65 149.82,155.52 149.82,154.85 149.94,154.73 150.76,154.73 150.89,154.6 150.89,153.54 150.76,153.42 v3(150.73,153.42)
  L4 w0.089: v4(98.84,168.91) 99.47,168.28 100.87,168.28 103.38,165.77 103.59,165.77
  L4 w0.216: 103.59,165.77 111.23,165.77 112.75,164.24 113.13,164.24 113.7,163.67 113.7,163.29 114.28,162.72 114.66,162.72 115.23,162.14 115.23,161.76 115.81,161.19 116.18,161.19 116.76,160.61 116.76,160.24 117.33,159.66 117.71,159.66 118.29,159.09 118.29,158.71 126.59,150.4 135.78,150.4 135.88,150.5 145.83,150.5 146.97,151.63 148.99,151.63 149.64,152.28 150.87,152.28 151.16,152.57 151.16,152.79 151.04,152.92 151.03,152.92 150.9,153.04 150.9,153.24 v3(150.73,153.42)
  BOTTOM w0.102: v2(150.48,152.58) 150.48,153.16 v3(150.73,153.42)
M_B_CS#1: length 79.7
  TOP w0.089: CPU1.AY42 93.27,167.85 94.47,167.85 94.59,167.97 98.63,167.97 v4(99.59,168.93)
  TOP w0.165: v3(147.99,152.15) 147.99,152.35 148.12,152.48 148.13,152.48 148.35,152.7 149.19,152.7 149.79,152.1 149.79,150.96 149.56,150.72 147.61,150.72 147.49,150.85 147.49,151.86 147.48,151.86 147.48,152.02 147.35,152.15 DIMM2.121
  L4 w0.089: 103.54,166.26 103.26,166.26 101,168.53 100.47,168.53 100.13,168.53 100.13,168.53 99.99,168.53 v4(99.59,168.93)
  L4 w0.216: v3(147.99,152.15) 146.72,152.15 145.7,151.13 135.67,151.13 135.44,150.9 132.75,150.9 132.54,151.11 132.54,151.17 132.32,151.38 131.89,151.38 131.67,151.17 131.67,151.11 131.46,150.9 131.03,150.9 130.81,151.11 130.81,151.17 130.59,151.38 130.16,151.38 129.95,151.17 129.95,151.11 129.73,150.9 129.3,150.9 129.08,151.11 129.08,151.17 128.87,151.38 128.44,151.38 128.22,151.17 128.22,151.11 128,150.9 127.17,150.9 126.49,151.58 126.49,151.88 126.57,151.96 126.57,152.26 126.26,152.57 125.96,152.57 125.88,152.49 125.58,152.49 125.27,152.8 125.27,153.11 125.35,153.18 125.35,153.49 125.04,153.79 124.74,153.79 124.66,153.72 124.36,153.72 124.05,154.02 124.05,154.33 124.13,154.4 124.13,154.71 123.82,155.01 123.51,155.01 123.33,154.83 123.03,154.83 122.72,155.14 122.72,155.44 122.9,155.62 122.9,155.93 122.6,156.23 122.29,156.23 122.09,156.03 121.78,156.03 121.48,156.34 121.48,156.64 121.68,156.85 121.68,157.15 121.38,157.46 121.07,157.46 120.84,157.22 120.53,157.22 120.23,157.53 120.23,157.83 120.46,158.07 120.46,158.37 120.15,158.68 119.85,158.68 119.62,158.45 119.31,158.45 119.01,158.75 119.01,159.06 119.24,159.29 119.24,159.59 118.93,159.9 118.63,159.9 118.55,159.82 118.25,159.82 111.81,166.26 103.54,166.26
  BOTTOM w0.102: v3(147.99,152.15) 147.73,151.9 v2(147.73,151.31)
M_B_DQ0: length 92.8
  TOP w0.102: CPU1.AF65 85.15,181.38 84.85,181.09 v4(84.69,181.09) ; DIMM2.23 146.47,184.02 147.3,184.02 147.33,184.06 148.68,184.06 v4(149.2,184.58)
  L4 w0.127: v4(149.2,184.58) 148.73,185.05 146.96,185.05 136.96,195.05 133.64,195.05 131.07,197.61 123.68,197.61 123.55,197.49 123.55,197.04 123.43,196.91 123.17,196.91 123.05,197.04 123.05,197.49 122.92,197.61 122.67,197.61 122.54,197.49 122.54,197.04 122.41,196.91 122.16,196.91 122.03,197.04 122.03,197.49 121.9,197.61 121.65,197.61 121.52,197.49 121.52,197.04 121.4,196.91 121.14,196.91 121.01,197.04 121.01,197.49 120.89,197.61 120.63,197.61 120.51,197.49 120.51,197.04 120.38,196.91 120.13,196.91 120,197.04 120,197.49 119.87,197.61 112.02,197.61 111.47,198.17 107.94,198.17 107.73,197.95 92.12,197.95 92.11,197.95 91.97,197.95 88.29,194.27 88.29,193.92 88.29,186.86 88.39,186.76 88.39,186.41 88.14,186.17 87.57,186.17 84.06,182.65 84.06,181.72 v4(84.69,181.09)
  BOTTOM w0.102: v2(148.93,183.72) 149.2,183.99 v4(149.2,184.58)
M_B_DQ1: length 91.9
  TOP w0.102: CPU1.AF64 85.02,180.76 v4(84.69,180.44) ; v4(153.14,183.65) 154.6,183.65 DIMM2.24
  L4 w0.127: v4(153.14,183.65) 152.45,184.34 150.81,184.34 149.75,185.4 147.2,185.4 137.21,195.39 133.78,195.39 131.21,197.96 112.17,197.96 111.61,198.51 92.05,198.51 87.79,194.25 87.79,191.64 87.34,191.19 87.34,188.72 87.26,188.65 87.26,186.48 83.84,183.06 83.84,181.29 v4(84.69,180.44)
  BOTTOM w0.102: v2(153.93,183.65) v4(153.14,183.65)
M_B_DQ2: length 92.2
  TOP w0.102: CPU1.AK65 86.84,181.41 v4(86.52,181.09) ; v4(151.75,180.63) 152.34,180.05 DIMM2.36
  L4 w0.127: v4(86.52,181.09) 86.94,181.51 86.94,182.03 86.86,182.11 86.86,182.76 89.29,185.19 90.24,185.19 91.49,186.44 91.49,190.13 90.92,190.69 90.92,193.2 93.14,195.43 100.14,195.43 101,194.56 106.07,194.56 106.54,194.09 123.44,194.09 123.57,193.96 123.57,193.29 123.69,193.17 123.95,193.17 124.07,193.29 124.07,193.96 124.2,194.09 124.46,194.09 124.58,193.96 124.58,193.29 124.71,193.17 124.96,193.17 125.09,193.29 125.09,193.96 125.22,194.09 125.47,194.09 125.6,193.96 125.6,193.29 125.73,193.17 125.98,193.17 126.11,193.29 126.11,193.96 126.23,194.09 129.22,194.09 132.68,190.63 137.85,190.63 146.88,181.6 147.51,181.6 147.54,181.58 148.19,181.58 148.21,181.6 150.79,181.6 v4(151.75,180.63)
  BOTTOM w0.102: v4(151.75,180.63) 151.75,180.1 v2(151.5,179.84)
M_B_DQ3: length 93.6
  TOP w0.102: v4(86.52,180.44) 86.62,180.44 86.94,180.76 CPU1.AK64 ; DIMM2.35 149.04,180.35 149.16,180.48 v4(149.16,180.81)
  L4 w0.127: v4(149.16,180.81) 149.16,180.82 148.71,181.27 148.05,181.27 148.05,181.28 147.68,181.28 147.66,181.26 146.73,181.26 137.87,190.12 132.65,190.12 129.05,193.72 127.29,193.72 126.39,192.82 122.97,192.82 122.84,192.95 122.84,193.62 122.71,193.75 122.46,193.75 122.33,193.62 122.33,192.95 122.21,192.82 121.95,192.82 121.82,192.95 121.82,193.62 121.7,193.75 121.44,193.75 121.32,193.62 121.32,192.95 121.19,192.82 120.94,192.82 120.81,192.95 120.81,193.62 120.68,193.75 120.43,193.75 120.3,193.62 120.3,192.95 120.17,192.82 119.92,192.82 119.79,192.95 119.79,193.62 119.67,193.75 119.41,193.75 119.28,193.62 119.28,192.95 119.16,192.82 118.9,192.82 118.78,192.95 118.78,193.62 118.65,193.75 118.4,193.75 118.27,193.62 118.27,192.95 118.14,192.82 117.72,192.82 116.83,193.72 106.42,193.72 105.92,194.22 100.86,194.22 100,195.09 93.3,195.09 91.38,193.16 91.38,190.68 91.83,190.23 91.83,186.48 90.01,184.66 89.06,184.66 87.07,182.67 87.07,182.32 87.15,182.24 87.15,181.07 v4(86.52,180.44)
  BOTTOM w0.102: v4(149.16,180.81) 149.16,180.8 v2(148.39,180.04)
M_B_DQ4: length 92.5
  TOP w0.102: DIMM2.21 146.44,184.59 v4(147.86,184.59) ; v4(84.69,181.74) 84.87,181.74 85.15,182.02 CPU1.AF66
  L4 w0.127: v4(84.69,181.74) 84.69,181.8 84.27,182.21 84.27,182.56 87.58,185.87 88.15,185.87 88.63,186.35 88.63,193.94 92.26,197.57 92.28,197.57 92.32,197.61 107.87,197.61 108.08,197.82 111.33,197.82 112.75,196.4 113.09,196.4 113.22,196.53 113.22,197.11 113.35,197.24 113.6,197.24 113.73,197.11 113.73,196.53 113.85,196.4 114.11,196.4 114.24,196.53 114.24,197.11 114.36,197.24 114.62,197.24 114.74,197.11 114.74,196.53 114.87,196.4 115.12,196.4 115.25,196.53 115.25,197.11 115.38,197.24 115.63,197.24 115.76,197.11 115.76,196.53 115.89,196.4 116.14,196.4 116.27,196.53 116.27,197.11 116.39,197.24 116.65,197.24 116.78,197.11 116.78,196.53 116.9,196.4 117.16,196.4 117.28,196.53 117.28,197.11 117.41,197.24 117.66,197.24 117.79,197.11 117.79,196.53 117.92,196.4 118.17,196.4 118.3,196.53 118.3,197.11 118.43,197.24 118.68,197.24 118.81,197.11 118.81,196.53 118.93,196.4 127.55,196.4 128.18,197.03 131.17,197.03 133.49,194.7 136.82,194.7 146.93,184.59 v4(147.86,184.59)
  BOTTOM w0.102: v2(147,184.58) 147.85,184.58 v4(147.86,184.59)
M_B_DQ5: length 91.8
  TOP w0.102: DIMM2.22 151.93,184.25 151.8,184.12 v4(151.8,183.69) ; CPU1.AF67 84.96,182.71 84.69,182.45 v4(84.69,182.39)
  L4 w0.127: v4(151.8,183.69) 151.35,183.24 150.51,183.24 149.73,184.02 147.01,184.02 136.68,194.36 133.35,194.36 132.31,195.4 132.13,195.4 131.59,194.86 131.41,194.86 130.88,195.39 130.88,195.57 131.06,195.75 131.24,195.75 131.41,195.58 131.59,195.58 131.77,195.76 131.77,195.94 131.03,196.68 128.32,196.68 127.55,195.92 112.75,195.92 111.19,197.48 108.22,197.48 107.97,197.23 92.41,197.23 89.06,193.88 89.06,193.76 89.06,186.47 88.23,185.64 87.94,185.64 v4(84.69,182.39)
  BOTTOM w0.102: v2(151.55,182.91) 151.8,183.16 v4(151.8,183.69)
M_B_DQ6: length 90.3
  TOP w0.102: v4(147.86,180.83) 147.74,180.95 DIMM2.33 ; CPU1.AK67 87.28,182.71 v4(87.49,182.5)
  L4 w0.127: v4(147.86,180.83) 146.47,180.83 138.56,188.75 135.9,188.75 135.48,189.17 135.48,189.69 135.28,189.89 132.26,189.89 129.73,192.42 116.86,192.42 116.74,192.54 116.74,193.25 116.61,193.38 116.36,193.38 116.23,193.25 116.23,192.54 116.1,192.42 115.85,192.42 115.72,192.54 115.72,193.25 115.59,193.38 115.34,193.38 115.21,193.25 115.21,192.54 115.09,192.42 114.83,192.42 114.71,192.54 114.71,193.25 114.58,193.38 114.32,193.38 114.2,193.25 114.2,192.54 114.07,192.42 113.82,192.42 113.69,192.54 113.69,193.25 113.56,193.38 113.31,193.38 113.18,193.25 113.18,192.54 113.05,192.42 112.8,192.42 112.67,192.54 112.67,193.25 112.55,193.38 112.29,193.38 112.17,193.25 112.17,192.54 112.04,192.42 111.78,192.42 111.66,192.54 111.66,193.25 111.53,193.38 111.28,193.38 111.15,193.25 111.15,192.54 111.02,192.42 110.77,192.42 110.64,192.54 110.64,193.25 110.51,193.38 110.26,193.38 110.13,193.25 110.13,192.54 110.01,192.42 109.75,192.42 109.63,192.54 109.63,193.25 109.5,193.38 109.24,193.38 109.12,193.25 109.12,192.54 108.99,192.42 108.74,192.42 108.61,192.54 108.61,193.25 108.48,193.38 108.23,193.38 108.1,193.25 108.1,192.54 107.97,192.42 107.72,192.42 107.59,192.54 107.59,193.25 107.47,193.38 107.21,193.38 107.09,193.25 107.09,192.54 106.96,192.42 98.22,192.42 96.17,190.37 95.83,190.37 95.37,189.91 94.42,189.91 93.96,189.45 92.69,189.45 92.17,188.93 92.17,186.52 90.05,184.39 89.2,184.39 87.49,182.69 v4(87.49,182.5)
  BOTTOM w0.102: v2(147.02,180.82) 147.03,180.83 v4(147.86,180.83)
M_B_DQ7: length 91.5
  TOP w0.102: DIMM2.34 v4(153.14,180.65) ; CPU1.AK66 86.97,182.06 86.65,181.74 v4(86.52,181.74)
  L4 w0.127: v4(86.52,181.74) 86.58,181.8 86.58,182.79 89.24,185.45 90.02,185.45 90.57,186 90.57,193.35 93,195.77 93,195.77 93.02,195.79 100.34,195.79 101.04,195.1 101.54,195.1 101.66,195.22 101.66,195.74 101.79,195.87 102.05,195.87 102.17,195.74 102.17,195.22 102.3,195.1 102.55,195.1 102.68,195.22 102.68,195.74 102.81,195.87 103.06,195.87 103.19,195.74 103.19,195.22 103.32,195.1 103.57,195.1 103.7,195.22 103.7,195.74 103.82,195.87 104.08,195.87 104.2,195.74 104.2,195.22 104.33,195.1 104.59,195.1 104.71,195.22 104.71,195.74 104.84,195.87 105.09,195.87 105.22,195.74 105.22,195.22 105.35,195.1 106.36,195.1 107,194.45 129.43,194.45 132.91,190.97 137.99,190.97 147.02,181.94 147.66,181.94 147.74,181.86 151.1,181.86 151.87,181.09 152.6,181.09 153.04,180.65 v4(153.14,180.65)
  BOTTOM w0.102: v4(153.14,180.65) 153.14,180.12 v2(152.89,179.86)
M_B_DQ8: length 92.5
  TOP w0.102: v4(84.18,186.41) 83.85,186.08 83.85,185.58 84.14,185.29 84.33,185.29 84.84,184.78 CPU1.AF70 ; v4(148.86,189.64) 148.86,189.48 148.73,189.35 DIMM2.5
  L4 w0.127: v4(148.86,189.64) 148.86,190.05 148.05,190.85 148.05,191.13 144.42,194.75 144.42,195.62 141.72,198.32 139.21,198.32 138.22,199.31 138.22,199.49 138.82,200.09 138.82,200.27 138.64,200.44 138.46,200.44 137.86,199.85 137.68,199.85 137.5,200.03 137.5,200.21 138.01,200.71 138.01,200.89 137.83,201.07 137.65,201.07 137.15,200.57 136.97,200.57 135.54,202 90.85,202 83.42,194.57 83.42,187.61 83.46,187.57 83.46,187.13 v4(84.18,186.41)
  BOTTOM w0.102: v4(148.86,189.64) 148.86,189.11 v2(148.6,188.85)
M_B_DQ9: length 94.1
  TOP w0.089: CPU1.AF68 84.6,183.87 84.6,183.87 84.6,184.12 84.36,184.37 84.11,184.37 83.67,184.81 83.67,186.55 v4(84.18,187.06)
  TOP w0.102: DIMM2.4 v4(153.14,189.65)
  L4 w0.127: v4(84.18,187.06) 83.7,187.54 83.7,190.68 83.76,190.74 83.76,194.43 90.88,201.54 135.51,201.54 139.07,197.98 141.58,197.98 144.07,195.49 144.07,194.16 147.71,190.52 147.71,190.02 149.02,188.7 153.01,188.7 153.14,188.83 v4(153.14,189.65)
  BOTTOM w0.102: v2(152.89,188.86) 153.14,189.12 v4(153.14,189.65)
M_B_DQ10: length 91.7
  TOP w0.089: v4(85.91,188.48) 85.54,188.11 85.54,186.4 86.1,185.84 86.1,185.38 CPU1.AH71
  TOP w0.102: DIMM2.15 v4(147.86,186.35)
  L4 w0.127: v4(85.91,188.48) 86.67,189.24 86.67,194.4 91.77,199.51 112,199.51 112.65,198.85 113.07,198.85 113.2,198.98 113.2,199.38 113.33,199.51 113.58,199.51 113.71,199.38 113.71,198.98 113.83,198.85 114.09,198.85 114.22,198.98 114.22,199.38 114.34,199.51 114.6,199.51 114.72,199.38 114.72,198.98 114.85,198.85 115.1,198.85 115.23,198.98 115.23,199.38 115.36,199.51 115.61,199.51 115.74,199.38 115.74,198.98 115.87,198.85 116.12,198.85 116.25,198.98 116.25,199.38 116.37,199.51 116.63,199.51 116.76,199.38 116.76,198.98 116.88,198.85 117.14,198.85 117.26,198.98 117.26,199.38 117.39,199.51 117.64,199.51 117.77,199.38 117.77,198.98 117.9,198.85 122.43,198.85 122.97,199.39 134.61,199.39 135.2,198.81 135.2,198.51 134.96,198.27 134.96,198.09 135.14,197.91 135.32,197.91 135.68,198.28 135.86,198.28 136.04,198.1 136.04,197.92 135.69,197.56 135.69,197.38 135.87,197.21 136.05,197.21 136.15,197.3 136.59,197.3 144.92,188.97 145.05,188.97 145.41,189.33 145.59,189.33 145.77,189.15 145.77,188.97 145.41,188.62 145.41,188.44 145.59,188.26 145.77,188.26 146.13,188.61 146.31,188.61 146.48,188.43 146.48,188.25 146.13,187.9 146.13,187.72 146.31,187.54 146.49,187.54 146.84,187.89 147.02,187.89 147.2,187.71 147.2,187.53 147.05,187.38 147.05,187.16 v4(147.86,186.35)
  BOTTOM w0.102: v2(147,186.35) v4(147.86,186.35)
M_B_DQ11: length 94.2
  TOP w0.089: v4(85.94,187.85) 85.94,187.53 85.81,187.4 85.81,186.43 86.43,185.82 86.43,185.24 86.39,185.08 86.39,184.89 86.43,184.72 86.43,183.63 CPU1.AH68
  TOP w0.102: DIMM2.17 149,185.75 149.13,185.88 v4(149.13,186.37)
  L4 w0.102: 87.03,193.34 87,193.31 87,188.9 v4(85.94,187.85)
  L4 w0.127: 87.03,193.34 87.03,194.28 91.85,199.1 111.59,199.1 112.18,198.51 112.51,198.51 112.51,198.51 112.8,198.51 122.57,198.51 123.11,199.05 130.89,199.05 132.29,197.65 132.47,197.65 133.42,198.59 133.6,198.59 133.78,198.41 133.78,198.23 132.83,197.29 132.83,197.11 133.01,196.93 133.19,196.93 134.33,198.06 134.51,198.06 134.61,197.95 134.61,197.95 134.69,197.88 134.69,197.7 133.55,196.57 133.55,196.39 133.98,195.96 134.83,195.96 134.96,196.08 134.96,196.25 135.09,196.38 135.34,196.38 135.47,196.25 135.47,196.08 135.6,195.96 136.05,195.96 136.18,196.08 136.18,196.47 136.3,196.6 136.56,196.6 136.69,196.47 136.69,196.08 136.81,195.96 137.41,195.96 147.46,185.91 148.94,185.91 149.13,186.09 v4(149.13,186.37)
  BOTTOM w0.102: v4(149.13,186.37) 149.13,185.83 v2(148.88,185.58)
M_B_DQ12: length 91.7
  TOP w0.102: v4(150.13,189.64) 149.26,188.77 149.26,188.75 DIMM2.7 ; v4(84.26,185.75) 84.69,185.31 CPU1.AF71
  L4 w0.127: v4(84.26,185.75) 84.01,185.99 84,185.99 83.24,186.75 83.24,187.48 83.08,187.64 83.08,194.25 83.08,194.25 83.08,194.71 90.8,202.43 138.1,202.43 144.86,195.67 144.86,194.8 148.18,191.48 148.95,191.48 150.13,190.31 v4(150.13,189.64)
  BOTTOM w0.102: v2(149.87,188.85) 150.13,189.11 v4(150.13,189.64)
M_B_DQ13: length 93.5
  TOP w0.102: v4(84.24,184.8) 84.94,184.1 CPU1.AF69 ; v4(151.76,189.63) 151.76,189.52 152.23,189.05 DIMM2.6
  L4 w0.127: v4(151.76,189.63) 151.39,189.63 150.95,190.07 138.24,202.78 90.66,202.78 82.73,194.85 82.73,193.35 82.74,193.35 82.74,193.06 82.74,187.68 83.03,187.15 83.03,186.38 84.24,185.16 v4(84.24,184.8)
  BOTTOM w0.102: v4(151.76,189.63) 151.76,189.1 v2(151.51,188.84)
M_B_DQ14: length 93.1
  TOP w0.089: v4(85.91,189.12) 85.36,188.57 85.36,186.32 85.9,185.79 85.9,185.26 85.96,185.04 85.96,184.87 CPU1.AH70
  TOP w0.102: v4(150.93,184.86) 150.93,184.94 152.05,186.05 DIMM2.16
  L4 w0.127: v4(85.91,189.12) 86.33,189.53 86.33,190.23 86.32,190.24 86.32,194.26 86.32,194.26 86.32,194.55 91.63,199.85 118.07,199.85 118.65,199.28 118.93,199.28 122.35,199.28 122.84,199.77 134.86,199.77 142.74,191.89 142.92,191.89 143.2,192.18 143.38,192.18 143.56,192 143.56,191.82 143.28,191.53 143.28,191.35 143.45,191.17 143.63,191.17 143.92,191.46 144.1,191.46 144.28,191.28 144.28,191.1 143.87,190.69 143.87,190.51 144.05,190.33 144.23,190.33 144.64,190.74 144.82,190.74 145,190.56 145,190.38 144.84,190.22 144.84,189.97 145.13,189.67 145.73,189.67 148.41,186.99 149.75,186.99 150.21,186.53 150.21,185.58 v4(150.93,184.86)
  BOTTOM w0.102: v2(150.1,185.52) 150.76,184.86 v4(150.93,184.86)
M_B_DQ15: length 93.8
  TOP w0.089: 85.18,189.02 85.18,186.25 85.72,185.72 85.72,185.24 85.77,185.05 85.77,184.41 CPU1.AH69
  TOP w0.102: DIMM2.18 152.95,185.45 v4(152.35,184.84) ; 85.18,189.02 v4(85.91,189.75)
  L4 w0.127: v4(85.91,189.75) 85.91,194.62 91.49,200.19 118.21,200.19 118.31,200.1 118.79,199.62 122.18,199.62 122.72,200.15 134.96,200.15 140.3,194.82 140.48,194.82 140.8,195.14 140.98,195.14 141.16,194.97 141.16,194.79 140.83,194.46 140.83,194.28 141.01,194.1 141.19,194.1 141.52,194.43 141.7,194.43 141.88,194.25 141.88,194.07 141.55,193.74 141.55,193.56 141.73,193.38 141.91,193.38 142.29,193.76 142.47,193.76 142.65,193.58 142.65,193.4 142.4,193.15 142.4,192.91 142.79,192.52 143.52,192.52 148.71,187.33 149.9,187.33 150.52,186.71 150.52,186.49 151.72,185.29 151.9,185.29 v4(152.35,184.84)
  BOTTOM w0.102: v2(152.56,185.7) 152.56,185.06 v4(152.35,184.84)
