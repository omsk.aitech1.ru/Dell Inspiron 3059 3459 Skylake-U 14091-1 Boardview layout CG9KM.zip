# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XTL_24M_X1_CPU: length 19.9
  TOP w0.089: 70.26,166.4 72.78,166.4 72.95,166.24 72.95,166.08 73.19,165.83 73.43,165.83 73.55,165.95 74.09,165.95 CPU1.E37
  TOP w0.102: X9503.1 61.38,159.39 62.16,160.17 64.08,160.17 C12355.1 64.43,159.84 R80060.1 65.98,160.45 67.57,160.45 v3(68.74,161.62) 68.71,161.65 68.71,163.18 69.07,163.54 69.07,165.3 70.17,166.4 70.26,166.4
  BOTTOM w0.102: v2(69.15,160.83) 69.15,161.21 v3(68.74,161.62)
XTL_24M_X2_CPU: length 19.5
  TOP w0.102: X9503.3 62.94,156.77 C12356.1 64.68,156.96 v3(64.68,157.61) 64.68,158.18 66.26,159.77 R80060.2 67.83,159.84 69.23,161.24 69.23,162.83 69.63,163.23 69.63,164.97 70.52,165.86 72.5,165.86 72.69,165.67 72.69,165.43 72.87,165.26 73.87,165.26 CPU1.E35
  BOTTOM w0.102: v2(64.68,158.47) v3(64.68,157.61)
XTL_32K_X1_CPU: length 30.7
  TOP w0.102: v4(88.27,154.2) 87.95,154.53 CPU1.AM18 ; X9504.1 90.6,131.53 C12358.1 R80061.1 89.57,131.57 88.96,132.18 88.96,133.07 89.44,133.55 89.44,133.67 89.45,133.68 89.45,134.09 90.48,135.13 v3(90.58,135.13)
  L3 w0.127: v4(88.27,154.2) 87.87,154.2 86.12,152.45 86.12,150.13 86.77,149.48 86.77,147.84 88.55,146.06 88.55,144.31 90.58,142.28 v3(90.58,135.13)
  BOTTOM w0.102: v2(89.75,135.13) v3(90.58,135.13)
XTL_32K_X2_CPU: length 31.1
  TOP w0.102: CPU1.AM20 87.95,155.44 v4(88.27,155.12) ; X9504.4 90.73,132.38 C12357.1 90.46,132.4 R80061.2 89.57,132.72 90.06,133.21 90.06,133.84 v3(90.58,134.37)
  L3 w0.127: v4(88.27,155.12) 87.81,155.12 85.08,152.39 85.08,150.79 86.52,149.35 86.52,147.7 88.04,146.18 88.04,143.88 89.82,142.1 89.82,135.13 v3(90.58,134.37)
  BOTTOM w0.102: v2(90.58,133.55) v3(90.58,134.37)
N35415300: length 4.8
  TOP w0.152: Q9637.1 16.15,184.04 16.54,183.64 16.54,183.13 16.15,182.74 Q9637.3 15.13,182.74 14.97,182.58 v3(14.38,182.58)
  BOTTOM w0.152: v2(14.18,183.39) 14.18,182.78 v3(14.38,182.58)
N35418666: length 5
  TOP w0.152: Q9639.1 16.27,177.18 16.44,177.01 16.44,176.05 16.27,175.88 Q9639.3 15.01,175.88 v3(14.41,176.48)
  BOTTOM w0.152: v3(14.41,176.48) 14.41,175.82 v2(14.23,175.64)
N37189306: length 7.4
  BOTTOM w0.152: R80239.2 v2(40.27,102.62) 38.59,102.62 38.01,102.03 Q9651.D 40.38,100.9 Q9647.G

## Copper pours and planes (outline as drawn)
1V_EDRAM on BOTTOM: 79.15,178.44 78.9,178.69 78.9,178.94 79.15,179.2 79.54,179.2 79.66,179.32 79.66,179.96 79.79,180.09 80.17,180.09 80.3,179.96 80.3,179.32 80.42,179.2 82.08,179.2 82.46,179.58 82.46,179.96 82.58,180.09 83.09,180.09 83.22,179.96 83.22,179.45 82.71,178.94 82.71,178.69 82.46,178.44
1V_S3 on TOP: 48.67,137.92 48.42,138.18 48.42,138.81 49.06,139.45 49.06,140.21 49.18,140.34 50.96,140.34 51.34,139.95 51.34,138.94 51.6,138.68 52.1,138.68 52.23,138.56 52.23,138.18 52.1,138.05 51.54,138.05 51.42,137.92 ; 1 cut-out
1V_VCCGT on TOP: 76.11,169.54 75.98,169.67 75.98,174.37 76.23,174.62 76.23,175.01 75.98,175.26 75.98,178.94 76.11,179.07 76.36,179.07 76.61,178.82 77,178.82 77.12,178.94 77.12,182.75 77.63,183.26 77.63,185.42 78.77,186.56 78.77,190.12 78.27,190.63 73.82,190.63 71.66,192.79 69.88,192.79 69.38,193.29 64.3,193.29 62.77,191.77 62.77,185.17 62.52,184.91 57.06,184.91 56.93,185.04 56.93,187.58 57.31,187.96 59.34,187.96 59.79,188.4 59.79,192.28 58.83,193.23 58.83,212.98 58.58,213.23 58.58,214 58.96,214.38 63.03,214.38 63.41,214 63.41,211.07 63.79,210.69 71.41,210.69 77.25,204.85 77.25,199.52 77.88,198.88 77.88,195.96 78.67,195.17 82.1,195.17 82.33,194.94 82.33,188.21 83.09,187.45 83.09,185.93 83.47,185.55 83.47,180.59 83.35,180.47 83.22,180.47 82.96,180.21 82.96,178.94 83.47,178.44 83.47,177.93 83.35,177.8 77.88,177.8 77.63,177.55 77.63,170.31 76.87,169.54 ; 14 cut-outs
1V_VCCGT on BOTTOM: outline of 85 points within 73.19,170.69 85.89,187.45 ; 4 cut-outs
1V_VCCGT on BOTTOM: 78.65,191.64 77.88,192.41 77.88,195.45 78.01,195.58 78.27,195.58 78.39,195.45 78.39,195.07 79.41,194.06 80.81,194.06 80.93,193.93 80.93,192.79 79.79,191.64
1V_VCCGT on BOTTOM: 57.06,184.91 56.93,185.04 56.93,187.58 57.31,187.96 59.34,187.96 59.72,188.34 59.72,192.41 57.95,194.18 57.95,215.52 58.07,215.65 65.06,215.65 65.57,215.14 65.57,197.1 66.2,196.47 68.23,196.47 68.23,195.07 66.07,192.91 63.91,192.91 62.77,191.77 62.77,185.17 62.52,184.91
1V_VCCGT on L3: 59.72,215.65 65.06,215.65 65.57,215.14 65.57,197.61 66.07,197.1 67.85,197.1 68.11,196.85 68.11,195.45 67.6,194.94 64.93,194.94 63.41,193.42 63.41,186.94 62.9,186.44 59.98,186.44 59.72,186.69 59.72,192.33 58.77,193.28 58.77,214.69
1V_VCCGT on L3: 77.38,187.45 82.33,187.45 82.58,187.2 82.58,186.31 83.35,185.55 83.35,174.24 82.96,173.86 76.61,173.86 76.36,174.12 76.36,186.44
1V_VCCGT on L4: 77.38,187.45 76.36,186.44 76.36,174.12 76.61,173.86 82.96,173.86 83.35,174.24 83.35,185.55 82.58,186.31 82.58,187.2 82.33,187.45
1V_VCCGT on L4: 59.85,215.65 64.17,215.65 64.42,215.39 64.42,200.41 64.17,200.15 59.34,200.15 58.83,200.66 58.83,214.63
1V_VCCGT on L5GND: 78.85,171.49 76.41,173.93 75.42,173.93 68.04,181.31 68.04,187.78 67.17,188.66 64.98,188.66 62.82,186.5 57.39,186.5 57.12,186.77 57.12,187.88 57.52,188.28 59.29,188.28 59.79,188.77 59.79,197.44 58.9,198.33 58.9,214.17 59.17,214.44 64.98,214.44 65.37,214.04 65.37,211.25 65.74,210.88 67.52,210.88 82.14,196.26 82.14,185.21 83.28,184.07 83.28,172.29 82.48,171.49
1V_VCCGTUS on TOP: 86.77,168.15 86.65,168.28 86.27,168.28 86.14,168.4 86.14,169.29 85.5,169.93 85.5,177.16 85.89,177.55 86.39,177.55 86.65,177.8 86.65,178.31 86.9,178.56 87.28,178.56 88.17,177.67 88.17,177.42 88.04,177.29 87.28,177.29 87.16,177.16 87.16,176.91 87.28,176.78 88.04,176.78 88.17,176.66 88.17,176.53 87.16,175.51 86.9,175.51 86.77,175.64 86.39,175.64 86.27,175.51 86.27,175.01 86.39,174.88 86.9,174.88 87.03,175.01 88.04,175.01 88.17,174.88 88.17,174.75 87.92,174.5 87.92,174.12 88.04,173.99 88.04,173.74 87.79,173.48 87.79,173.35 88.04,173.1 88.04,172.85 87.92,172.72 87.92,172.21 88.04,172.09 88.04,171.83 87.92,171.7 87.66,171.7 87.54,171.83 86.9,171.83 86.77,171.96 86.39,171.96 86.27,171.83 86.27,171.32 86.39,171.2 86.77,171.2 86.9,171.32 87.28,171.32 87.66,170.94 87.66,170.31 87.28,169.93 87.28,169.42 87.66,169.04 87.66,168.53 87.28,168.15
1V_VCCGTUS on BOTTOM: 86.14,168.78 86.01,168.91 86.01,169.93 85.63,170.31 85.63,170.81 85.76,170.94 85.89,170.94 86.01,171.07 86.01,177.29 86.27,177.55 89.7,177.55 89.95,177.8 89.95,178.18 90.08,178.31 90.33,178.31 90.58,178.56 90.58,179.96 90.71,180.09 97.19,180.09 98.08,179.2 98.08,178.82 96.74,177.48 94.71,177.48 93.76,176.53 88.04,176.53 87.79,176.28 87.79,168.91 87.66,168.78 ; 1 cut-out
1V_VCCIO on TOP: 38.77,135.64 38.39,136.02 38.39,137.03 38.51,137.16 38.51,138.43 40.93,138.43 41.05,138.3 41.05,136.14 40.55,135.64 ; 3 cut-outs
1V_VCCIO on TOP: 86.27,160.78 86.14,160.91 86.14,161.93 86.39,162.18 88.04,162.18 88.17,162.05 88.17,161.04 88.04,160.91 86.77,160.91 86.65,160.78
1V_VCCIO on BOTTOM: 87.16,160.27 86.77,160.66 86.27,160.66 86.14,160.78 86.14,162.56 87.16,163.58 87.54,163.58 87.66,163.45 87.66,163.07 87.54,162.94 87.41,162.94 87.16,162.69 87.16,161.93 87.28,161.8 87.54,161.8 87.66,161.67 87.66,160.4 87.54,160.27 ; 1 cut-out
1V_VCCIO on L3: 86.77,160.02 86.01,159.26 82.46,159.26 82.08,158.88 80.81,158.88 80.55,158.62 80.55,155.07 80.42,154.94 80.42,153.8 79.92,153.29 79.92,142.75 78.27,141.1 70.14,141.1 69.63,141.6 69.63,144.78 70.77,145.92 75.73,145.92 77,147.19 77,149.86 76.36,150.5 76.36,154.31 76.87,154.81 76.87,159.38 77.76,160.27 77.76,162.05 78.27,162.56 86.52,162.56 86.77,162.31
1V_VCCIO on L4: 70.52,141.73 70.01,141.22 68.36,141.22 62.26,135.13 56.29,135.13 55.02,133.86 48.29,133.86 45.88,136.27 38.77,136.27 38.39,136.65 38.39,139.7 38.9,140.21 46.26,140.21 49.82,136.65 50.58,136.65 51.98,138.05 59.85,138.05 65.95,144.15 68.99,144.15 69.63,144.78 70.14,144.78 70.52,144.4
1V_VCCMPHYGTAON on TOP: 53.88,137.79 53.63,138.05 53.63,140.59 53.75,140.72 56.04,140.72 56.17,140.59 56.17,139.06 56.04,138.94 55.66,138.94 55.53,138.81 55.53,137.92 55.41,137.79 ; 2 cut-outs
1V_VCCMPHYGTAON on TOP: 79.03,152.15 78.9,152.27 78.9,152.53 78.65,152.78 78.65,153.29 78.52,153.42 78.52,154.18 78.65,154.31 78.9,154.31 79.41,153.8 79.66,153.8 79.92,153.54 79.92,152.78 79.28,152.15
1V_VCCMPHYGTAON on BOTTOM: 78.9,152.02 78.77,152.15 78.77,153.31 79,153.54 83.14,153.54 83.22,153.47 83.22,152.88 83.12,152.78 80.04,152.78 79.79,152.53 79.79,152.4 79.41,152.02
1V_VCCSA on TOP: 75.98,157.73 75.47,158.24 75.47,159.26 75.6,159.38 76.36,159.38 76.49,159.51 76.49,159.89 76.36,160.02 75.98,160.02 75.9,159.94 75.62,159.94 75.47,160.1 75.47,161.11 75.6,161.24 76.31,161.24 76.49,161.42 76.49,162.05 76.61,162.18 77.38,162.18 77.5,162.05 77.5,159.38 76.87,158.75 76.87,158.24 76.36,157.73
1V_VCCSA on TOP: 43.47,162.05 43.21,162.31 43.21,168.02 41.94,169.29 41.94,171.07 47.28,171.07 49.31,169.04 58.2,169.04 58.33,168.91 58.33,168.4 57.69,167.77 57.69,163.58 57.18,163.07 47.66,163.07 47.15,162.56 46.01,162.56 45.5,162.05 ; 13 cut-outs
1V_VCCSA on TOP: 86.9,158.12 86.27,158.75 86.27,159.77 86.39,159.89 86.65,159.89 87.28,159.26 87.28,159.13 87.16,159 87.16,158.5 87.28,158.37 87.28,158.24 87.16,158.12
1V_VCCSA on BOTTOM: 67.72,158.37 67.09,159 66.33,159 65.06,160.27 59.85,160.27 57.06,163.07 47.66,163.07 46.64,162.05 43.47,162.05 43.21,162.31 43.21,168.02 41.94,169.29 41.94,171.07 47.28,171.07 49.31,169.04 50.71,169.04 51.47,168.28 55.15,168.28 55.53,168.66 55.53,168.91 55.66,169.04 58.2,169.04 58.33,168.91 58.33,168.4 57.69,167.77 57.69,165.61 60.61,162.69 64.68,162.69 65.44,163.45 68.13,163.45 68.44,163.14 68.44,162.99 70.01,161.42 74.71,161.42 75.09,161.04 76.61,161.04 76.74,161.16 76.74,161.67 76.87,161.8 77.25,161.8 77.38,161.67 77.38,161.04 77.5,160.91 85.25,160.91 86.27,159.89 86.65,159.89 87.16,159.38 87.16,158.75 87.03,158.62 86.39,158.62 86.27,158.75 86.27,159.13 85.63,159.77 81.74,159.77 81.11,159.13 78.14,159.13 77.12,160.15 74.33,160.15 74.07,159.89 72.3,159.89 71.79,159.38 70.77,159.38 69.76,158.37 ; 11 cut-outs
1V_VCCSA on L4: 74.2,161.16 74.2,160.53 74.46,160.27 79.92,160.27 80.55,159.64 82.46,159.64 82.58,159.77 85.63,159.77 86.27,159.13 86.27,158.75 86.39,158.62 86.77,158.62 86.9,158.75 86.9,159.64 86.65,159.89 86.27,159.89 85.63,160.53 85.63,161.67 85.25,162.05 75.09,162.05
1V_VCCSA on L5GND: 68.57,157.16 65.52,160.21 60.18,160.21 59.04,161.35 52.69,161.35 50.91,163.13 48.5,163.13 48.23,163.4 48.23,170.1 50.91,172.78 58.25,172.78 69.55,161.48 75.93,161.48 76.57,162.12 87.6,162.12 87.6,158.07 86.7,157.16 76.38,157.16 76.25,157.29 76.07,157.33 76.07,157.33 75.37,157.31 75.37,157.31 75.22,157.27 75.1,157.16 ; 1 cut-out
1V_VCCST on TOP: 51.72,136.27 51.6,136.4 51.6,137.67 51.72,137.79 53.12,137.79 53.25,137.67 53.25,136.4 53.12,136.27 ; 1 cut-out
3V3AUX on BOTTOM: 174.02,148.72 174.02,153.42 174.28,153.67 174.91,153.67 175.04,153.54 175.04,149.73 174.28,148.97 174.28,148.72 ; 3 cut-outs
3V_VA on TOP: 165.54,68.55 165.26,68.83 165.26,69.34 164.63,69.98 164.63,71.75 164.45,71.93 164.45,72.31 164.29,72.47 164.29,73.91 164.5,73.91 164.5,72.87 165.06,72.31 165.26,72.31 165.46,72.52 165.46,72.75 165.13,73.08 165.13,74.35 166.1,74.35 166.15,74.3 166.15,73.41 166.66,72.9 166.66,72.26 167.17,71.75 167.17,68.71 167.01,68.55 ; 7 cut-outs
+19V_AMP_PVCC on TOP: 163.99,46.61 163.86,46.74 163.86,47.75 163.61,48.01 161.83,48.01 161.83,48.77 164.12,48.77 164.5,49.15 165.51,49.15 166.53,48.13 166.53,46.86 166.28,46.61 ; 2 cut-outs
+19V_AMP_PVCC on TOP: 150.78,47.75 150.66,47.88 150.66,50.04 151.29,50.67 151.93,50.67 152.05,50.55 152.05,49.53 152.43,49.15 154.72,49.15 155.1,48.77 157.77,48.77 157.77,48.01 156.24,48.01 155.99,47.75 ; 3 cut-outs
AGND on L2GND: outline of 118 points within 72.58,1.68 184.24,87.86
GND on TOP: 126.27,3.3 126.14,3.43 126.14,4.95 126.65,5.46 126.65,9.53 126.53,9.65 126.53,11.05 126.78,11.3 128.05,11.3 128.15,11.2 128.15,9.5 127.41,8.76 127.41,5.33 127.8,4.95 127.8,3.43 127.67,3.3 ; 4 cut-outs
GND on TOP: 106.97,106.43 106.84,106.55 106.84,108.33 107.35,108.84 109.13,108.84 109.25,108.71 109.25,106.55 109.13,106.43 ; 1 cut-out
GND on TOP: 86.65,63.12 86.39,63.37 86.39,64.52 87.16,64.52 87.16,63.37 86.9,63.12
GND on TOP: 63.91,211.46 63.79,211.58 63.79,214.12 63.03,214.88 58.58,214.88 57.69,215.77 57.69,218.57 57.95,218.82 64.68,218.82 67.34,216.15 67.34,211.58 67.22,211.46
GND on TOP: 137.9,19.28 137.75,19.43 137.75,22.43 137.57,22.61 133.26,22.61 133,22.86 133,27.18 133.38,27.56 141.38,27.56 141.89,27.05 141.89,22.86 141.64,22.61 139.61,22.61 139.23,22.23 139.23,19.66 138.84,19.28 ; 1 cut-out
GND on TOP: 35.72,111.25 35.47,111.51 35.47,114.94 35.59,115.06 37.63,115.06 38.01,114.68 38.01,111.38 37.88,111.25
GND on TOP: 112.17,218.57 112.05,218.69 112.05,223.01 111.92,223.14 109.63,223.14 109.63,223.39 110.02,223.77 110.02,224.92 110.14,225.04 112.94,225.04 113.44,224.54 113.44,219.46 112.56,218.57
GND on TOP: 63.03,19.43 62.9,19.56 62.9,21.21 63.28,21.59 67.85,21.59 68.23,21.21 68.23,19.68 67.98,19.43
GND on TOP: 29.5,161.16 29.37,161.29 29.37,164.97 29.5,165.1 31.28,165.1 31.4,164.97 31.4,163.83 31.53,163.7 32.93,163.7 33.05,163.58 33.05,161.16
GND on TOP: 23.4,198.5 23.27,198.63 23.27,204.6 23.4,204.72 23.78,204.72 24.29,204.22 26.45,204.22 26.58,204.09 26.58,203.84 26.7,203.71 28.48,203.71 28.86,204.09 28.86,204.6 28.99,204.72 29.37,204.72 29.5,204.6 29.5,203.07 28.35,201.93 28.35,199.14 25.05,199.14 24.42,198.5 ; 10 cut-outs
GND on TOP: 35.09,76.96 34.83,77.22 34.83,78.49 35.09,78.74 37.88,78.74 38.01,78.61 38.01,77.09 37.88,76.96
GND on TOP: 38.13,4.45 38.01,4.57 38.01,5.08 37.75,5.33 37.37,5.33 36.74,4.7 34.58,4.7 34.32,4.95 34.32,9.14 33.94,9.53 33.94,10.54 35.34,10.54 35.59,10.29 35.59,9.78 35.34,9.53 35.34,8.38 35.47,8.26 36.23,8.26 36.36,8.13 36.36,7.11 36.23,6.99 34.83,6.99 34.58,6.73 34.58,5.46 34.83,5.21 36.36,5.21 36.86,5.71 36.86,6.48 37.12,6.73 38.64,6.73 38.9,6.99 38.9,7.01 38.96,7.07 38.96,8.45 39.17,8.66 39.17,9.37 39.25,9.45 39.81,9.45 39.91,9.35 39.91,7.37 38.9,6.35 38.9,5.97 39.02,5.84 39.91,5.84 40.04,5.71 40.04,5.08 39.4,4.45 ; 2 cut-outs
GND on TOP: 122.59,24.13 122.46,24.26 122.46,27.43 122.59,27.56 127.03,27.56 127.03,24.38 126.78,24.13
GND on TOP: 46.9,94.23 46.64,94.49 46.64,105.79 46.52,105.92 45.37,105.92 45.25,106.05 45.25,106.93 45.75,107.44 45.75,107.95 46.01,108.2 48.17,108.2 48.29,108.08 48.29,107.44 48.55,107.19 48.55,102.87 48.17,102.49 48.17,97.54 47.66,97.03 47.66,94.36 47.53,94.23 ; 22 cut-outs
GND on TOP: 46.26,160.27 46.13,160.4 46.13,162.18 46.26,162.31 47.53,162.31 47.91,162.69 53.25,162.69 53.37,162.81 56.8,162.81 57.06,162.56 57.06,161.42 56.68,161.04 48.55,161.04 47.79,160.27 ; 4 cut-outs
GND on TOP: 73.31,21.59 72.42,22.48 72.42,26.16 72.68,26.42 81.44,26.42 81.57,26.29 81.57,22.61 80.55,21.59
GND on TOP: 19.46,179.71 19.21,179.96 19.21,184.66 19.34,184.78 25.18,184.78 25.31,184.91 25.31,185.42 26.07,185.42 26.07,184.91 26.2,184.78 29.24,184.78 29.24,181.48 27.08,181.48 26.96,181.36 26.96,180.21 26.45,179.71
GND on TOP: 104.68,78.23 104.55,78.36 104.55,79.88 104.81,80.14 106.59,80.14 106.84,79.88 106.84,78.36 106.71,78.23 ; 2 cut-outs
GND on TOP: 110.65,200.28 110.4,200.53 110.4,200.91 108.75,202.56 108.75,203.96 109,204.22 113.7,204.22 113.83,204.09 113.83,200.66 113.44,200.28
GND on TOP: 97.82,125.48 97.7,125.6 97.7,127.51 98.18,127.99 98.18,128.52 98.31,128.65 99.6,128.65 99.98,128.27 99.98,125.6 99.86,125.48 ; 5 cut-outs
GND on TOP: 26.45,160.66 26.32,160.78 26.32,163.58 26.45,163.7 26.83,163.7 26.96,163.58 26.96,160.78 26.83,160.66
GND on TOP: 34.7,198.63 34.58,198.75 34.58,205.74 37.5,208.66 39.15,208.66 39.28,208.79 39.28,209.55 40.67,210.95 43.85,210.95 43.85,207.65 42.07,207.65 41.94,207.52 41.94,204.47 42.07,204.34 43.85,204.34 43.85,201.04 42.2,201.04 41.94,200.79 41.94,198.75 41.82,198.63
GND on TOP: 38.51,49.78 38.26,50.04 38.26,54.74 40.67,54.74 40.8,54.61 40.8,51.69 40.55,51.44 40.55,50.04 40.29,49.78
GND on TOP: 117.51,4.06 117.25,4.32 117.25,7.37 117.38,7.49 118.14,7.49 118.65,8 118.65,11.18 119.79,12.32 119.79,14.86 120.18,15.24 121.57,15.24 121.7,15.11 121.7,13.72 121.95,13.46 123.35,13.46 123.35,12.19 122.97,11.81 122.97,8.64 123.22,8.38 123.6,8.38 123.6,7.24 121.7,7.24 120.3,5.84 120.3,4.32 120.05,4.06 ; 4 cut-outs
GND on TOP: 34.2,72.9 33.94,73.15 33.94,74.93 33.56,75.31 32.04,75.31 32.04,76.45 33.94,76.45 34.45,75.95 37.88,75.95 38.01,75.82 38.01,73.15 37.75,72.9 ; 3 cut-outs
GND on TOP: 88.55,6.6 88.43,6.73 88.43,18.92 88.68,19.18 90.58,19.18 90.71,19.05 90.71,13.34 90.08,12.7 90.08,6.73 89.95,6.6 ; 1 cut-out
GND on TOP: 138.34,74.68 138.08,74.93 138.08,77.34 138.46,77.72 143.04,77.72 143.16,77.6 143.16,74.93 142.91,74.68
GND on TOP: 80.57,95.36 80.45,95.48 80.45,95.61 80.96,96.12 80.96,96.88 80.45,97.39 80.45,97.64 80.96,98.15 80.96,98.91 80.45,99.42 80.45,99.67 80.96,100.18 80.96,100.82 80.45,101.33 80.45,101.58 80.96,102.09 80.96,102.6 80.32,103.23 80.32,103.48 80.45,103.61 80.7,103.61 81.72,102.6 81.72,102.21 81.21,101.71 81.21,101.07 81.72,100.56 81.72,100.31 81.21,99.8 81.21,99.29 81.84,98.66 81.84,98.53 81.34,98.02 81.34,97.26 82.86,95.74 82.86,95.48 82.73,95.36
GND on TOP: 131.99,93.57 131.86,93.7 131.86,95.73 131.99,95.86 133.64,95.86 133.76,95.73 133.76,93.83 133.51,93.57 ; 1 cut-out
GND on TOP: 136.3,193.93 133.76,196.47 133.76,198.63 134.02,198.88 142.02,198.88 142.65,198.25 142.65,196.34 140.75,194.44 140.75,194.18 140.5,193.93
GND on TOP: 136.3,119.25 132.62,122.94 121.06,122.94 120.68,123.32 120.68,128.27 120.81,128.4 125.51,128.4 125.64,128.27 125.64,125.73 126.14,125.22 136.18,125.22 136.43,125.48 143.54,125.48 143.8,125.22 143.8,122.43 140.62,119.25
GND on TOP: 34.83,64.01 34.58,64.26 34.58,66.04 34.45,66.17 34.45,66.93 34.58,67.06 35.21,67.06 35.72,66.55 37.12,66.55 37.12,64.14 36.99,64.01 ; 1 cut-out
GND on TOP: 82.66,188.24 82.63,188.26 82.63,195.12 82.28,195.48 78.75,195.48 78.52,195.71 78.52,198.63 77.88,199.26 77.88,199.64 78.01,199.77 78.52,199.77 81.69,196.6 83.98,196.6 84.74,195.83 84.74,189.84 84.59,189.69 83.95,189.69 83.35,189.08 83.35,188.34 83.24,188.24 ; 10 cut-outs
GND on TOP: 80.42,152.53 80.3,152.65 80.3,152.91 80.55,153.16 80.68,153.16 80.81,153.29 80.81,153.8 80.68,153.92 79.54,153.92 79.41,154.05 79.41,154.18 79.54,154.31 79.79,154.31 80.17,154.69 80.17,154.94 80.3,155.07 81.44,155.07 81.69,154.81 81.69,154.69 81.95,154.43 82.2,154.43 82.33,154.31 82.33,153.92 82.2,153.8 81.95,153.8 81.57,153.42 81.57,153.29 81.44,153.16 81.19,153.16 80.55,152.53
GND on TOP: 103.54,98.93 103.28,99.19 103.28,100.71 103.41,100.84 104.81,100.84 104.94,100.71 105.82,100.71 105.95,100.58 105.95,100.08 106.33,99.69 106.33,99.19 106.08,98.93 ; 1 cut-out
GND on TOP: 84.49,224.28 84.23,224.54 84.23,225.81 83.85,226.19 83.85,226.69 83.98,226.82 89.31,226.82 89.82,226.31 89.82,224.54 89.57,224.28
GND on TOP: 23.53,36.96 23.27,37.21 23.27,38.99 24.29,40.01 24.29,42.42 24.42,42.55 25.69,42.55 25.81,42.42 25.81,38.48 24.29,36.96
GND on TOP: 146.59,103.63 146.21,104.01 146.21,108.33 148.5,108.33 148.88,107.95 148.88,105.54 148.37,105.03 148.37,103.89 148.12,103.63
GND on TOP: 120.81,189.36 120.56,189.61 120.56,193.68 120.81,193.93 125.36,193.93 125.84,193.45 128.71,193.45 128.81,193.34 128.81,189.87 128.3,189.36
GND on TOP: 97.95,131.19 97.57,131.57 97.57,133.73 97.7,133.86 98.08,133.86 98.33,133.6 98.33,133.35 98.46,133.22 99.22,133.22 99.73,132.72 99.73,131.32 99.6,131.19
GND on TOP: 110.65,103.12 110.65,105.66 112.17,105.66 112.17,103.12
GND on TOP: 101.89,69.6 101.76,69.72 101.76,73.03 101.89,73.15 102.78,73.15 103.03,72.9 103.03,71.37 103.16,71.25 104.43,71.25 104.55,71.37 104.55,72.52 104.68,72.64 107.73,72.64 107.86,72.52 107.86,71.63 108.24,71.25 108.24,69.98 108.11,69.85 107.35,69.85 106.46,70.74 104.05,70.74 102.9,69.6 ; 5 cut-outs
GND on TOP: 53.63,169.29 52.74,170.18 48.8,170.18 47.53,171.45 41.82,171.45 41.69,171.58 41.69,173.99 41.82,174.12 47.4,174.12 47.53,173.99 47.53,173.1 48.17,172.47 61.76,172.47 61.88,172.34 61.88,171.32 59.85,169.29 ; 8 cut-outs
GND on TOP: 97.21,110.98 97.08,111.1 97.08,111.61 97.21,111.74 97.97,111.74 98.23,111.99 98.23,115.55 98.48,115.8 99.75,115.8 100.01,115.55 100.01,112.76 98.23,110.98 ; 5 cut-outs
GND on TOP: 144.43,205.74 141.77,208.41 127.41,208.41 126.65,209.17 126.65,215.01 127.03,215.39 129.57,215.39 131.86,217.68 146.21,217.68 150.02,213.87 150.02,208.91 146.85,205.74
GND on TOP: 158.66,191.26 157.64,192.28 157.64,195.2 158.28,195.83 159.93,195.83 160.05,195.71 160.05,191.52 159.8,191.26 ; 1 cut-out
GND on TOP: 32.67,148.59 32.29,148.97 32.29,150.24 31.91,150.62 28.35,150.62 27.97,151 27.97,154.94 28.35,155.32 31.78,155.32 32.04,155.07 33.82,155.07 34.07,154.81 34.07,148.72 33.94,148.59
GND on TOP: 93.96,198.27 93.89,198.35 93.89,203.84 94.14,204.09 101.89,204.09 102.14,203.84 102.14,199.64 102.13,199.63 102.13,199 101.4,198.27
GND on TOP: 41.94,136.27 41.44,136.78 41.44,138.3 46.9,138.3 47.02,138.18 47.02,136.53 46.77,136.27
GND on TOP: 45.75,114.17 45.63,114.3 45.63,118.87 45.75,119 47.91,119 48.29,118.62 48.29,114.17 ; 8 cut-outs
GND on TOP: 132.88,83.19 132.37,83.69 132.37,86.49 132.24,86.61 130.59,86.61 130.59,89.92 132.24,89.92 132.37,90.04 132.37,91.69 132.62,91.95 137.96,91.95 138.08,91.82 138.08,83.31 137.96,83.19
GND on TOP: 110.02,106.43 109.89,106.55 109.89,107.57 110.02,107.7 110.27,107.7 110.4,107.82 110.4,108.84 110.52,108.97 111.79,108.97 111.92,108.84 111.92,106.55 111.79,106.43 ; 2 cut-outs
GND on TOP: 121.06,223.9 120.81,224.16 120.81,224.92 121.06,225.17 126.02,225.17 126.4,224.79 126.4,224.16 126.14,223.9 ; 4 cut-outs
GND on TOP: 33.94,56.01 33.31,56.64 30.89,56.64 30.64,56.9 30.64,59.31 33.82,59.31 34.2,58.93 35.34,58.93 35.85,58.42 35.85,56.52 35.34,56.01
GND on TOP: 51.09,187.2 50.45,187.83 47.15,187.83 46.9,188.09 46.9,191.01 47.28,191.39 55.28,191.39 55.91,192.02 59.09,192.02 59.34,191.77 59.34,188.72 59.09,188.47 56.68,188.47 55.41,187.2
GND on TOP: 102.01,156.72 101.89,156.84 101.89,157.61 102.01,157.73 103.41,157.73 103.92,157.23 103.92,156.84 103.79,156.72
GND on TOP: 146.72,3.3 146.59,3.43 146.59,5.46 145.7,6.35 145.7,10.79 145.83,10.92 151.8,10.92 151.93,10.79 151.93,3.56 151.67,3.3
GND on TOP: 135.8,7.11 135.67,7.24 135.67,10.54 135.8,10.67 139.23,10.67 139.35,10.54 139.35,7.24 139.23,7.11
GND on TOP: 136.18,95.25 136.05,95.38 136.05,101.85 136.56,102.36 136.56,103.25 136.05,103.76 136.05,104.14 136.18,104.27 136.69,104.27 137.7,103.25 137.7,95.38 137.57,95.25 ; 13 cut-outs
GND on TOP: 120.81,202.82 120.56,203.07 120.56,203.84 120.81,204.09 126.4,204.09 126.65,203.84 126.65,203.07 126.4,202.82 ; 2 cut-outs
GND on TOP: 166.66,116.71 165.77,117.6 163.23,117.6 163.1,117.73 163.1,118.11 163.23,118.24 165.01,118.24 165.26,118.49 165.26,119.13 165.39,119.25 169.83,119.25 169.96,119.13 169.96,117.86 168.82,116.71 ; 1 cut-out
GND on TOP: 64.68,197.49 64.17,197.99 64.17,202.44 64.3,202.56 71.66,202.56 72.55,201.68 72.55,199.14 72.93,198.75 72.93,197.61 72.8,197.49
GND on TOP: 147.1,40.51 146.97,40.64 146.97,43.31 147.23,43.56 147.23,45.09 148.75,45.09 148.75,42.42 147.73,41.4 147.73,40.77 147.48,40.51
GND on TOP: 13.88,202.31 13.75,202.44 13.75,204.34 14,204.6 17.05,204.6 17.05,202.31
GND on TOP: 57.06,180.47 56.93,180.59 56.93,184.4 57.06,184.53 62.64,184.53 62.77,184.4 62.77,180.59 62.64,180.47 ; 2 cut-outs
GND on TOP: 56.29,175.77 56.17,175.9 56.17,177.42 56.29,177.55 60.99,177.55 61.12,177.42 61.12,175.9 60.99,175.77 ; 4 cut-outs
GND on TOP: 48.93,19.18 48.29,19.81 48.29,30.73 47.15,31.88 46.01,31.88 45.75,32.13 45.75,36.32 46.01,36.58 47.53,36.58 47.91,36.96 47.91,37.97 48.04,38.1 50.07,38.1 51.09,39.12 54.39,39.12 54.64,38.86 54.64,30.99 55.15,30.48 55.15,28.96 54.77,28.57 53.75,28.57 53.12,27.94 53.12,25.65 54.14,24.64 57.82,24.64 59.98,22.48 61.25,22.48 61.63,22.1 61.63,19.68 61.5,19.56 58.33,19.56 57.95,19.18 ; 1 cut-out
GND on TOP: 64.17,155.57 64.04,155.7 64.04,155.83 65.06,156.84 65.06,158.12 66.2,159.26 66.2,160.02 65.69,160.53 60.99,160.53 60.49,160.02 60.49,158.37 60.23,158.12 60.23,160.4 60.87,161.04 65.06,161.04 65.82,161.8 66.45,161.8 68.36,163.7 68.36,166.24 69.88,167.77 74.96,167.77 75.34,167.39 75.34,162.69 74.8,162.14 71.51,162.14 71.51,162.13 68.41,159.03 68.26,159.03 68.25,159.04 67.97,159.04 67.81,158.88 66.45,158.88 66.2,158.62 66.2,157.23 64.55,155.57
GND on TOP: 17.31,193.42 17.31,194.82 16.67,195.45 16.67,197.61 18.45,197.61 18.7,197.36 18.7,193.68 18.45,193.42 ; 3 cut-outs
GND on TOP: 83.12,98.4 82.99,98.53 82.99,98.79 82.48,99.29 82.48,99.67 82.99,100.18 82.99,100.56 82.35,101.2 82.35,101.45 82.99,102.09 82.99,102.6 82.35,103.23 82.35,103.36 82.48,103.48 82.73,103.48 83.62,102.6 83.62,102.09 83.11,101.58 83.11,101.07 83.62,100.56 83.62,100.31 83.11,99.8 83.11,99.42 83.62,98.91 83.62,98.58 83.45,98.4
GND on TOP: outline of 161 points within 0.76,0.76 184.24,229.24 ; 11 cut-outs
GND on TOP: 89.57,71.12 89.19,71.5 85.76,71.5 85.63,71.63 85.63,74.3 86.14,74.8 89.7,74.8 91.09,73.41 91.09,71.25 90.97,71.12 ; 2 cut-outs
GND on TOP: 87.66,211.96 87.54,212.09 87.54,213.61 86.9,214.25 86.14,214.25 86.01,214.38 86.01,216.28 86.14,216.41 91.22,216.41 91.47,216.15 91.47,214.25 91.22,214 89.44,214 89.19,213.74 89.19,212.09 89.06,211.96
GND on BOTTOM: 137.45,19.43 137.32,19.56 137.32,21.08 137.7,21.46 137.7,22.48 137.57,22.61 135.42,22.61 135.29,22.48 135.29,21.21 133.13,21.21 132.88,21.46 132.88,27.56 133.13,27.81 142.91,27.81 143.04,27.69 143.04,22.73 142.91,22.61 141.77,22.61 141.64,22.48 141.64,21.21 139.1,21.21 138.46,20.57 138.46,19.56 138.34,19.43 ; 4 cut-outs
GND on BOTTOM: 27.72,150.62 27.72,154.69 28.35,155.32 31.78,155.32 32.04,155.07 33.56,155.07 33.56,150.75 33.43,150.62
GND on BOTTOM: 80.81,179.32 80.68,179.45 80.68,184.4 80.81,184.53 81.19,184.53 81.31,184.4 81.31,179.45 81.19,179.32
GND on BOTTOM: 85.38,182.12 85.25,182.25 85.25,182.5 85.5,182.75 86.01,182.75 86.39,183.13 86.39,185.55 85.89,186.06 85.89,186.69 86.01,186.82 86.27,186.82 87.66,185.42 87.66,183.01 87.54,182.88 87.28,182.88 86.52,182.12
GND on BOTTOM: 83.6,180.34 83.47,180.47 83.47,181.23 83.35,181.36 82.58,181.36 82.46,181.48 82.46,181.86 82.58,181.99 83.22,181.99 83.35,182.12 83.35,183.26 83.22,183.39 82.71,183.39 82.58,183.51 82.58,183.77 82.33,184.02 82.33,184.66 82.46,184.78 82.84,184.78 82.96,184.66 82.96,184.02 83.09,183.9 83.85,183.9 84.11,183.64 84.11,180.47 83.98,180.34
GND on BOTTOM: 89.31,201.42 88.43,202.31 87.79,202.31 86.01,204.09 85.38,204.09 85,204.47 84.11,204.47 83.85,204.72 83.85,205.49 83.98,205.61 88.43,205.61 88.93,205.1 90.33,205.1 90.58,204.85 90.58,201.55 90.46,201.42
GND on BOTTOM: 48.93,19.18 48.29,19.81 48.29,30.23 48.8,30.73 54.9,30.73 55.15,30.48 55.15,28.96 54.77,28.57 53.75,28.57 53.12,27.94 53.12,25.65 54.14,24.64 57.82,24.64 57.95,24.51 57.95,20.32 56.8,19.18
GND on BOTTOM: 132.11,32.38 131.86,32.64 131.86,33.02 131.73,33.15 130.46,33.15 130.08,33.53 130.08,37.72 130.21,37.85 134.02,37.85 134.15,37.72 134.15,34.54 133.38,33.78 133.38,32.51 133.26,32.38 ; 8 cut-outs
GND on BOTTOM: 7.4,214.76 7.27,214.88 7.27,216.03 8.29,217.04 9.56,217.04 9.69,216.92 9.69,214.88 9.56,214.76
GND on BOTTOM: 98.33,107.7 98.2,107.82 98.2,112.65 98.46,112.9 101.63,112.9 102.14,112.39 102.14,108.2 101.63,107.7
GND on BOTTOM: 39.66,11.94 39.53,12.06 39.53,12.57 39.4,12.7 36.61,12.7 36.36,12.95 36.36,14.35 36.61,14.61 36.61,15.37 36.23,15.75 35.59,15.75 35.47,15.88 35.47,17.27 35.59,17.4 38.64,17.4 39.02,17.78 39.91,17.78 40.29,17.4 40.29,14.86 40.17,14.73 39.53,14.73 39.28,14.48 39.28,13.59 39.4,13.46 40.04,13.46 40.17,13.34 40.17,12.06 40.04,11.94 ; 11 cut-outs
GND on BOTTOM: 98.59,223.52 97.44,224.66 96.43,224.66 96.3,224.79 96.3,227.08 96.43,227.2 102.78,227.2 103.03,226.95 103.03,225.3 102.78,225.04 102.78,223.52 ; 1 cut-out
GND on BOTTOM: 127.54,123.95 127.29,124.21 127.29,125.35 127.41,125.48 133.51,125.48 134.4,124.59 135.92,124.59 136.81,125.48 147.86,125.48 148.12,125.22 148.12,124.84 148.37,124.59 150.91,124.59 151.67,125.35 154.85,125.35 155.1,125.09 155.1,124.46 154.59,123.95 ; 21 cut-outs
GND on BOTTOM: 78.01,167.64 77.88,167.77 77.88,168.91 78.01,169.04 78.01,169.67 77.88,169.8 77.12,169.8 77,169.67 77,169.16 76.87,169.04 76.11,169.04 75.85,169.29 75.85,170.56 75.98,170.69 77.76,170.69 78.27,170.18 83.6,170.18 83.73,170.05 83.73,169.04 83.98,168.78 85.38,168.78 86.01,168.15 86.01,167.77 85.89,167.64 ; 7 cut-outs
GND on BOTTOM: 176.06,135.38 175.8,135.64 175.17,135.64 174.66,136.14 174.66,138.18 174.91,138.43 174.91,140.84 175.17,141.1 175.42,141.1 175.55,140.97 175.55,137.16 175.8,136.91 177.33,136.91 177.71,136.53 177.71,135.64 177.45,135.38 ; 2 cut-outs
GND on BOTTOM: 69.88,161.93 68.99,162.81 68.87,162.81 68.74,162.94 68.74,163.32 68.49,163.58 68.46,163.58 68.31,163.73 67.32,163.73 67.09,163.96 65.44,163.96 64.55,163.07 60.74,163.07 59.34,164.47 59.34,166.37 61.12,168.15 63.66,168.15 67.47,164.34 70.01,164.34 70.26,164.08 70.26,162.05 70.14,161.93
GND on BOTTOM: 132.88,82.3 132.75,82.42 132.75,83.31 132.37,83.69 132.37,87.76 132.24,87.88 130.59,87.88 130.59,91.19 131.99,91.19 132.11,91.31 132.11,91.44 132.62,91.95 137.96,91.95 138.08,91.82 138.08,82.55 137.83,82.3 ; 1 cut-out
GND on BOTTOM: 157.77,45.09 157.64,45.21 157.64,50.93 157.77,51.05 158.53,51.05 158.66,50.93 160.31,50.93 160.82,51.44 163.86,51.44 164.37,50.93 164.37,50.29 164.24,50.16 162.97,50.16 162.72,49.91 162.72,48.01 162.85,47.88 163.36,47.88 163.61,47.62 163.61,46.86 163.36,46.61 162.47,46.61 161.96,46.1 161.96,45.21 161.83,45.09 ; 3 cut-outs
GND on BOTTOM: 57.06,180.47 56.93,180.59 56.93,184.4 57.06,184.53 62.64,184.53 62.77,184.4 62.77,180.59 62.64,180.47 ; 2 cut-outs
GND on BOTTOM: 46.01,82.3 45.5,82.8 45.5,90.55 45.88,90.93 46.01,90.93 46.08,91 48.48,91 48.55,90.93 48.55,90.56 48.29,90.3 48.29,86.97 48.01,86.69 48.01,82.52 47.79,82.3 ; 12 cut-outs
GND on BOTTOM: 82.33,172.59 82.2,172.72 82.2,178.05 82.33,178.18 83.35,178.18 83.47,178.05 83.47,177.67 83.85,177.29 84.49,177.29 84.62,177.16 84.62,176.66 85.89,175.39 85.89,173.48 85.76,173.35 84.36,173.35 84.23,173.23 84.23,172.85 83.98,172.59 ; 1 cut-out
GND on BOTTOM: 88.04,161.16 87.92,161.29 87.92,161.93 87.79,162.05 87.41,162.05 87.28,162.18 87.28,162.56 87.41,162.69 87.79,162.69 87.92,162.81 87.92,167.26 88.04,167.39 89.06,167.39 89.19,167.26 89.19,166.75 89.06,166.62 88.81,166.62 88.55,166.37 88.55,165.74 88.68,165.61 89.82,165.61 89.95,165.48 89.95,164.85 89.82,164.72 88.81,164.72 88.55,164.47 88.55,163.83 88.68,163.7 89.06,163.7 89.19,163.58 89.19,163.19 88.55,162.56 88.55,162.31 88.93,161.93 89.95,161.93 90.08,161.8 90.08,161.29 89.95,161.16 ; 2 cut-outs
GND on BOTTOM: 151.8,21.34 151.8,23.11 153.45,23.11 153.45,21.34
GND on BOTTOM: 78.9,179.32 78.77,179.45 78.77,184.91 78.9,185.04 79.28,185.04 79.41,184.91 79.41,179.45 79.28,179.32
GND on BOTTOM: 83.85,224.92 83.73,225.04 83.73,226.57 83.98,226.82 89.31,226.82 89.82,226.31 89.82,225.17 89.57,224.92 ; 2 cut-outs
GND on BOTTOM: 94.9,176.15 94.78,176.28 94.78,177.16 94.9,177.29 97.32,177.29 98.2,178.18 99.6,178.18 99.73,178.31 99.73,178.82 99.86,178.94 100.11,178.94 100.24,178.82 100.24,178.31 100.36,178.18 101.63,178.18 101.76,178.31 101.76,179.32 104.94,182.5 106.46,182.5 106.59,182.37 106.59,177.55 105.19,176.15 ; 7 cut-outs
GND on BOTTOM: 23.53,199.14 23.53,203.96 28.35,203.96 28.35,199.14
GND on BOTTOM: 85.5,160.93 85.15,161.29 84.62,161.29 84.49,161.42 77.88,161.42 77.76,161.54 77.76,163.32 78.01,163.58 84.62,163.58 85.38,164.34 85.89,164.34 86.01,164.21 86.01,163.45 85.89,163.32 85.5,163.32 84.87,162.69 84.87,162.31 85.25,161.93 85.63,161.93 85.94,161.62 85.94,161.11 85.76,160.93 ; 10 cut-outs
GND on BOTTOM: 67.34,68.96 67.22,69.09 67.22,73.28 67.34,73.41 69.63,73.41 69.76,73.28 69.76,69.22 69.5,68.96
GND on BOTTOM: 45.33,101.26 45.08,101.51 45.08,106.68 45.5,107.1 45.5,116.79 46.31,117.6 48.01,117.6 48.29,117.32 48.29,112.52 48.55,112.26 48.55,111.12 48.42,111 48.42,110.9 48.39,110.87 48.39,109.67 48.19,109.47 46.49,109.47 46.36,109.34 46.36,108.3 46.51,108.15 48.26,108.15 48.52,107.89 48.52,101.62 48.16,101.26 ; 12 cut-outs
GND on BOTTOM: 146.97,149.1 146.59,149.48 146.59,165.99 147.1,166.5 154.47,166.5 154.72,166.24 154.72,151 154.47,150.75 152.31,150.75 150.66,149.1 ; 19 cut-outs
GND on BOTTOM: 68.61,174.75 68.49,174.88 68.49,176.91 68.87,177.29 71.03,177.29 71.15,177.42 71.15,178.05 71.28,178.18 72.55,178.18 72.8,177.93 72.8,176.28 73.19,175.9 73.19,174.88 73.06,174.75 ; 4 cut-outs
GND on BOTTOM: 90.2,94.23 90.08,94.36 90.08,95.12 89.7,95.5 89.7,97.03 89.82,97.16 90.46,97.16 91.73,95.89 94.01,95.89 94.39,95.5 95.03,95.5 95.16,95.38 95.16,94.61 94.9,94.36 94.27,94.36 94.14,94.49 94.14,94.87 94.01,95 91.47,95 91.22,94.74 91.22,94.36 91.09,94.23 ; 5 cut-outs
GND on BOTTOM: 29.5,161.16 29.37,161.29 29.37,164.97 29.5,165.1 31.28,165.1 31.4,164.97 31.4,163.83 31.53,163.7 32.93,163.7 33.05,163.58 33.05,161.29 32.93,161.16
GND on BOTTOM: 19.34,178.56 19.21,178.69 19.21,184.66 19.34,184.78 26.7,184.78 26.83,184.66 26.83,183.77 27.08,183.51 29.24,183.51 29.24,180.21 27.34,180.21 27.08,179.96 27.08,178.94 26.7,178.56
GND on BOTTOM: 46.13,31.88 46.13,38.86 47.53,38.86 49.82,36.58 49.82,32 49.69,31.88
GND on BOTTOM: outline of 325 points within 0.76,0.76 184.24,229.24 ; 7 cut-outs
GND on BOTTOM: 38.39,219.71 38.26,219.84 38.26,221.11 38.39,221.23 44.74,221.23 44.86,221.11 44.86,219.96 44.61,219.71
GND on BOTTOM: 64.68,22.86 64.42,23.11 64.42,25.02 65.69,26.29 66.84,26.29 67.85,25.27 67.85,23.11 67.6,22.86 ; 4 cut-outs
GND on BOTTOM: 160.43,74.17 160.31,74.3 160.31,78.23 160.82,78.74 164.75,78.74 164.88,78.61 164.88,74.3 164.75,74.17 ; 3 cut-outs
GND on BOTTOM: 42.07,197.99 41.56,198.5 34.45,198.5 34.45,199.64 34.58,199.77 34.58,205.74 37.37,208.53 37.37,211.46 37.5,211.58 41.05,211.58 41.69,212.22 41.69,212.85 42.2,212.85 42.2,211.71 41.94,211.46 41.94,209.8 42.07,209.68 43.85,209.68 43.85,206.38 42.2,206.38 41.94,206.12 41.94,204.47 42.07,204.34 42.07,203.2 42.2,203.07 43.85,203.07 43.85,199.77 42.45,199.77 42.32,199.64 42.32,198.88 42.71,198.5 42.71,198.12 42.58,197.99 ; 1 cut-out
GND on BOTTOM: 118.91,8 118.78,8.13 118.78,11.43 118.91,11.56 120.81,11.56 120.94,11.43 120.94,8.13 120.81,8 ; 2 cut-outs
GND on BOTTOM: 56.8,57.4 55.79,58.42 54.9,58.42 54.52,58.04 54.14,58.04 54.01,58.17 54.01,58.8 53.75,59.05 53.75,59.82 53.88,59.94 54.9,59.94 55.02,60.07 55.66,60.07 56.17,59.56 58.07,59.56 58.96,58.67 60.74,58.67 60.74,57.4 ; 3 cut-outs
GND on BOTTOM: 51.09,187.2 50.45,187.83 44.99,187.83 44.74,188.09 44.74,188.98 44.99,189.23 46.52,189.23 46.9,189.61 46.9,191.01 47.28,191.39 55.28,191.39 55.91,192.02 59.09,192.02 59.34,191.77 59.34,188.72 59.09,188.47 56.68,188.47 55.41,187.2
GND on BOTTOM: 33.31,38.23 33.18,38.35 33.18,42.42 35.59,42.42 35.85,42.16 35.85,38.48 35.59,38.23
GND on BOTTOM: 82.71,121.16 82.46,121.41 82.46,121.67 82.96,122.17 82.96,123.7 83.6,124.33 84.49,124.33 85.89,125.73 85.89,126.36 85,127.25 86.27,128.52 86.9,128.52 88.55,126.87 88.55,126.62 83.73,121.79 83.6,121.79 82.96,121.16
GND on BOTTOM: 114.59,57.85 113.95,58.48 113.95,62.55 114.21,62.8 120.94,62.8 121.06,62.67 121.06,58.1 120.81,57.85
GND on BOTTOM: 57.31,175.77 57.06,176.02 57.06,177.29 57.18,177.42 60.87,177.42 60.99,177.29 60.99,176.02 60.74,175.77 ; 3 cut-outs
GND on BOTTOM: 81.72,105.26 81.46,105.52 81.46,106.91 81.44,106.94 81.44,107.19 81.31,107.31 80.93,107.31 80.83,107.42 80.83,107.93 81.1,108.2 82.96,108.2 83.22,108.46 83.22,108.71 83.35,108.84 84.74,108.84 85.38,108.2 85.5,108.2 85.65,108.05 85.65,106.15 84.77,105.26 ; 10 cut-outs
GND on BOTTOM: 46.26,160.15 46.01,160.4 46.01,160.78 47.91,162.69 53.25,162.69 53.37,162.81 56.8,162.81 57.06,162.56 57.06,161.67 56.93,161.54 51.85,161.54 51.6,161.8 48.17,161.8 46.52,160.15 ; 2 cut-outs
GND on BOTTOM: 38.51,49.78 38.26,50.04 38.26,54.74 40.67,54.74 40.8,54.61 40.8,51.69 40.55,51.44 40.55,50.04 40.29,49.78 ; 2 cut-outs
GND on BOTTOM: 23.66,36.07 23.27,36.45 23.27,41.66 24.16,42.55 25.69,42.55 25.81,42.42 25.81,36.2 25.69,36.07
GND on BOTTOM: 47.53,93.47 46.37,94.63 46.37,96.5 46.33,96.54 46.33,98.44 47.04,99.16 48.16,99.16 48.29,99.03 48.29,98.42 47.28,97.41 47.28,95.38 47.4,95.25 48.04,95.25 48.29,95 48.29,93.6 48.17,93.47 ; 5 cut-outs
GND on BOTTOM: 131.48,151 131.22,151.26 131.22,168.53 131.48,168.78 138.84,168.78 139.35,168.28 139.35,153.67 138.21,152.53 138.21,151.38 137.83,151 ; 20 cut-outs
GND on BOTTOM: 62.9,19.43 62.64,19.68 62.64,21.34 62.9,21.59 67.09,21.59 67.34,21.34 67.34,19.68 67.09,19.43
GND on BOTTOM: 82.71,189.74 81.82,190.63 81.82,196.34 82.2,196.72 83.73,196.72 83.98,196.47 83.98,196.34 84.11,196.22 85,196.22 85.5,196.72 86.14,196.72 86.27,196.6 86.27,191.26 84.74,189.74 ; 7 cut-outs
GND on BOTTOM: 173.26,149.48 172.75,149.99 172.75,151.89 173.01,152.15 173.52,152.15 173.77,151.89 173.77,149.61 173.64,149.48
GND on BOTTOM: 79.66,194.44 78.65,195.45 78.65,196.72 79.66,197.74 80.55,197.74 80.81,197.49 80.81,195.07 80.17,194.44
GND on BOTTOM: 66.33,196.98 65.95,197.36 65.95,215.77 65.44,216.28 58.07,216.28 57.82,216.53 57.82,218.44 57.95,218.57 64.8,218.57 68.04,215.33 68.04,197.07 67.95,196.98
GND on BOTTOM: outline of 81 points within 80.73,91.82 88.92,103.12 ; 11 cut-outs
GND on BOTTOM: 79.43,110.34 79.18,110.6 79.18,113.54 79.29,113.65 80.95,113.65 82.61,111.99 82.61,110.6 80.45,110.6 80.19,110.34 ; 10 cut-outs
GND on BOTTOM: 41.05,107.82 40.8,108.08 40.8,111.12 40.93,111.25 42.58,111.25 42.71,111.12 42.71,107.95 42.58,107.82 ; 4 cut-outs
GND on BOTTOM: 77.35,154.97 77.25,155.07 77.25,155.83 77.38,155.96 77.76,155.96 78.01,156.21 78.01,156.97 78.14,157.1 78.52,157.1 78.65,157.23 79.41,157.23 79.66,157.48 80.42,157.48 80.55,157.35 80.55,156.08 80.81,155.83 80.81,155.4 80.73,155.32 80.25,155.32 80.17,155.4 80.17,156.08 79.54,156.72 79.15,156.72 78.9,156.46 78.9,155.22 78.65,154.97 ; 1 cut-out
GND on BOTTOM: 53.37,168.78 51.98,170.18 48.8,170.18 47.53,171.45 41.82,171.45 41.69,171.58 41.69,173.99 41.82,174.12 47.4,174.12 47.53,173.99 47.53,173.1 48.17,172.47 57.31,172.47 57.95,171.83 58.45,171.83 58.58,171.7 58.58,169.67 58.33,169.42 58.33,169.29 55.53,169.29 55.02,168.78 ; 5 cut-outs
GND on L2GND: outline of 175 points within 0.76,0.76 184.24,229.24 ; 21 cut-outs
GND on L3: outline of 169 points within 0.76,0.76 184.24,229.24 ; 3 cut-outs
GND on L3: 48.29,27.43 48.29,20.83 48.61,20.51 56.48,20.51 57.95,21.97 57.95,24.51 57.82,24.64 52.36,24.64 51.72,25.27 51.72,29.08 51.6,29.21 50.07,29.21
GND on L3: 114.21,62.8 120.94,62.8 121.06,62.67 121.06,58.1 120.81,57.85 114.59,57.85 113.95,58.48 113.95,62.55
GND on L3: 69.76,52.83 69.76,49.78 70.14,49.4 73.82,49.4 74.84,50.42 74.84,52.83 74.58,53.09 70.01,53.09
GND on L3: 116.87,226.95 117.51,226.31 117.51,209.3 116.87,208.66 105.32,208.66 104.94,209.04 104.94,225.43 106.46,226.95
GND on L4: outline of 156 points within 0.76,0.76 184.24,229.24 ; 2 cut-outs
GND on L4: 70.01,53.09 74.58,53.09 74.84,52.83 74.84,50.42 73.82,49.4 70.14,49.4 69.76,49.78 69.76,52.83
GND on L4: 121.06,62.48 121.06,58.17 120.94,58.04 114.33,58.04 113.95,58.42 113.95,62.36 114.21,62.61 120.94,62.61
PVCC_3V3 on TOP: 77.88,56.39 77.76,56.52 77.76,57.15 78.01,57.4 78.01,59.05 78.14,59.18 79.92,59.18 80.04,59.05 80.04,57.53 79.92,57.4 79.79,57.4 79.54,57.15 79.54,56.64 79.28,56.39 ; 1 cut-out
PVCC_3V3 on BOTTOM: 56.55,67.94 56.42,68.07 56.42,69.47 56.68,69.72 56.68,72.26 57.95,73.53 59.72,73.53 59.98,73.28 62.01,73.28 62.14,73.41 62.14,76.83 62.26,76.96 74.07,76.96 75.47,75.56 75.47,74.17 75.22,73.91 74.84,73.91 74.71,74.04 74.71,74.8 73.69,75.82 66.07,75.82 65.82,76.07 64.17,76.07 63.79,75.69 63.79,73.66 64.04,73.41 64.55,73.41 64.68,73.28 64.68,72.77 64.55,72.64 62.64,72.64 62.14,72.14 60.36,72.14 59.85,72.64 58.96,72.64 58.83,72.52 58.83,70.87 57.95,70.87 57.82,70.74 57.82,69.85 57.95,69.72 58.2,69.72 58.33,69.6 58.33,68.83 57.44,67.94 ; 4 cut-outs
VCC on TOP: 121.45,3.3 121.06,3.68 121.06,5.97 121.32,6.22 124.37,6.22 124.87,6.73 126.27,6.73 126.27,5.59 125.76,5.08 125.76,3.56 125.51,3.3 ; 2 cut-outs
VCC on TOP: 10.96,187.71 10.7,187.96 10.7,188.98 10.83,189.1 14.64,189.1 14.77,189.23 14.77,190.88 14.89,191.01 18.32,191.01 18.45,190.88 18.45,189.99 16.16,187.71
VCC on BOTTOM: 35.59,108.2 35.09,108.71 34.32,108.71 34.2,108.84 34.2,110.62 34.32,110.74 40.17,110.74 40.29,110.62 40.29,108.46 40.04,108.2 ; 1 cut-out
VCC on BOTTOM: 122.59,29.72 121.06,31.24 117.89,31.24 116.49,32.64 116.49,34.42 116.62,34.54 118.4,34.54 118.78,34.16 118.78,32.77 119.03,32.51 122.08,32.51 124.11,30.48 124.11,29.84 123.99,29.72 ; 2 cut-outs
VCC on BOTTOM: 5.37,208.03 5.24,208.15 5.24,210.31 5.37,210.44 9.18,210.44 9.3,210.31 9.3,208.15 9.18,208.03
VCC on L3: 92.24,8.26 92.49,8.51 94.52,8.51 94.78,8.26 94.78,5.08 95.41,4.45 117.25,4.45 118.02,5.21 124.49,5.21 124.62,5.08 124.62,3.43 124.49,3.3 93.12,3.3 92.24,4.19
VCC on L3: 85.63,1.65 22,1.65 21.88,1.78 21.88,43.69 22,43.81 25.43,43.81 25.56,43.69 25.56,20.68 26.47,19.76 26.47,19.13 25.69,18.34 25.69,5.33 26.83,4.19 48.17,4.19 48.42,4.45 48.42,4.7 49.44,5.71 54.26,5.71 55.41,4.57 83.85,4.57 83.98,4.7 83.98,7.24 84.11,7.37 86.01,7.37 86.14,7.24 86.14,2.16
VCC on L4: 22,43.81 26.96,43.81 30.39,47.24 30.39,57.78 27.97,60.2 27.97,72.9 29.88,74.8 29.88,132.08 28.1,133.86 22.39,133.86 14.57,141.67 14.57,147.51 10.57,151.51 10.57,183.26 9.69,184.15 9.69,188.85 9.94,189.1 12.35,189.1 12.99,188.47 12.99,187.07 11.97,186.06 11.97,185.04 12.99,184.02 12.99,152.53 17.18,148.34 17.18,142.49 23.15,136.53 29.24,136.53 32.67,133.1 32.67,111.12 33.05,110.74 36.23,110.74 36.36,110.62 36.36,108.46 36.1,108.2 33.82,108.2 33.43,107.82 33.43,82.93 34.51,81.85 34.51,73.72 31.66,70.87 31.66,61.72 33.18,60.2 33.18,45.34 28.74,40.89 22.13,40.89 21.88,41.15 21.88,43.69
VCC on L4: 124.62,3.43 124.49,3.3 85.38,3.3 85.25,3.43 85.25,8.13 85.63,8.51 94.39,8.51 94.78,8.13 94.78,6.1 95.16,5.71 124.24,5.71 124.62,5.33
VCC3 on TOP: 124.49,8.13 124.24,8.38 124.24,10.29 123.99,10.54 123.35,10.54 123.22,10.67 123.22,11.18 123.35,11.3 123.6,11.3 124.11,11.81 124.11,13.34 124.24,13.46 125.26,13.46 125.38,13.34 125.38,13.08 126.27,12.19 126.27,8.13
VCC3 on TOP: 148.5,60.07 148.37,60.2 148.37,63.37 148.24,63.5 148.24,63.88 148.37,64.01 150.02,64.01 150.4,64.39 150.4,65.79 150.66,66.04 151.04,66.04 151.16,66.17 151.16,67.06 151.04,67.18 149.26,67.18 149.13,67.06 149.13,66.55 148.88,66.29 148.37,66.29 148.24,66.42 148.24,67.82 148.37,67.94 152.31,67.94 152.56,67.69 153.32,67.69 153.83,68.2 153.83,71.88 153.7,72.01 153.7,72.9 153.96,73.15 155.1,73.15 156.12,74.17 158.28,74.17 158.4,74.04 158.4,73.53 158.28,73.41 157.51,73.41 157.26,73.15 157.01,73.15 155.48,71.63 155.48,67.18 154.08,65.79 153.45,65.79 152.18,64.52 152.18,63.12 152.05,62.99 152.05,60.2 151.93,60.07 ; 11 cut-outs
VCC3 on TOP: 161.96,184.78 161.83,184.91 161.83,186.56 161.96,186.69 164.88,186.69 165.01,186.56 165.01,185.04 164.75,184.78 ; 1 cut-out
VCC3 on BOTTOM: 134.65,30.61 134.53,30.73 134.53,31.24 134.27,31.5 133,31.5 132.88,31.62 132.88,31.88 133,32 133.51,32 133.89,32.38 133.89,33.78 134.53,34.42 134.53,39.24 134.65,39.37 134.65,42.42 134.42,42.65 129.55,42.65 129.32,42.42 129.32,41.27 129.07,41.02 128.68,41.02 128.18,41.53 128.18,43.33 129.04,44.2 134.48,44.2 137.57,41.1 137.57,34.92 137.83,34.67 137.83,32.89 137.57,32.64 135.67,32.64 135.29,32.26 135.29,30.73 135.16,30.61 ; 10 cut-outs
VCC3 on BOTTOM: 123.6,54.48 123.22,54.86 123.22,60.33 123.48,60.58 124.24,60.58 124.62,60.2 124.62,55.37 124.87,55.12 124.87,54.74 124.62,54.48
VCC3 on BOTTOM: 176.06,137.29 175.93,137.41 175.93,140.84 175.17,141.6 175.17,141.99 175.29,142.11 175.67,142.11 176.82,140.97 176.82,138.94 177.2,138.56 177.96,138.56 178.6,137.92 178.6,137.41 178.47,137.29
VCC3 on BOTTOM: 58.45,66.42 58.45,68.45 58.58,68.58 60.87,68.58 61.12,68.33 61.12,66.67 60.87,66.42
VCC3 on L3: 155.48,78.74 154.59,79.63 154.59,80.39 154.72,80.52 156.88,80.52 157.26,80.14 157.26,72.39 156.88,72.01 155.35,72.01 155.23,72.14 155.23,73.28 155.48,73.53
VCC3 on L3: 171.48,88.9 171.86,89.28 171.86,90.55 171.74,90.68 160.94,90.68 160.05,89.79 160.05,89.03 160.18,88.9
VCC3 on L4: 132.49,26.8 128.43,26.8 128.18,26.54 128.18,12.57 125.38,9.78 124.62,9.78 124.24,10.16 124.24,12.19 124.75,12.7 124.75,16.38 125,16.64 125,27.81 126.53,29.34 130.59,29.34 132.88,31.62 132.88,31.88 133.13,32.13 135.03,32.13 135.16,32 135.16,29.46
VCC3 on L4: 154.47,46.23 153.2,47.5 153.2,52.7 151.67,54.23 151.67,55.37 150.53,56.52 150.53,60.96 151.04,61.47 153.83,61.47 154.59,60.71 154.59,56.9 155.61,55.88 155.61,55.75 156.5,54.86 156.5,51.44 157.13,50.8 157.13,45.59 156.5,44.96 156.5,37.72 155.23,36.45 152.56,36.45 147.48,41.53 139.1,41.53 137.7,40.13 137.7,38.61 137.45,38.35 135.67,38.35 135.54,38.48 135.54,43.69 136.81,44.96 146.59,44.96 151.29,40.26 154.08,40.26 154.47,40.64
VCC3 on L4: 183.04,137.41 182.91,137.29 177.96,137.29 177.83,137.41 177.83,138.56 177.96,138.68 182.91,138.68 183.04,138.56
VCC3_CAM on TOP: 160.69,187.2 160.31,187.58 160.31,195.96 161.58,197.23 161.58,199.01 162.47,199.01 162.47,197.23 162.59,197.1 162.59,190.75 164.88,188.47 164.88,187.32 164.75,187.2 ; 5 cut-outs
VCC5_PANEL on TOP: 41.94,107.06 41.69,107.31 41.69,108.58 41.82,108.71 44.36,108.71 44.61,108.46 44.99,108.46 45.12,108.33 45.12,107.31 44.86,107.06
VCC5_PANEL on BOTTOM: 43.31,106.76 43.09,106.98 43.09,115.44 43.34,115.7 44.86,115.7 44.86,113.79 44.23,113.16 44.23,108.84 44.61,108.46 44.99,108.46 45.12,108.33 45.12,107.16 44.71,106.76 ; 2 cut-outs
VCC5_USB on TOP: 93.63,3.3 93.38,3.56 93.38,6.22 93.51,6.35 96.81,6.35 97.44,5.71 99.98,5.71 100.62,6.35 100.62,6.73 100.87,6.99 102.27,6.99 102.65,6.6 102.65,3.81 102.14,3.3 ; 2 cut-outs
VCC5_USB on TOP: 160.05,120.02 159.8,120.27 159.8,122.94 160.31,123.44 161.96,123.44 162.34,123.06 162.34,120.65 161.7,120.02 ; 2 cut-outs
VCC5_USB on BOTTOM: 116.87,5.46 116.62,5.71 116.62,7.37 115.98,8 115.1,8 114.97,8.13 114.97,8.89 115.22,9.14 118.4,9.14 118.52,9.02 118.52,8 118.78,7.75 121.06,7.75 121.19,7.87 121.19,8.76 123.48,8.76 123.6,8.64 123.6,5.71 123.35,5.46 ; 3 cut-outs
VCC5_USB on L4: outline of 96 points within 100.62,5.84 166.56,122.05
VCC_CORE on TOP: 75.6,161.8 75.47,161.93 75.47,162.94 75.6,163.07 76.36,163.07 76.49,163.19 76.49,163.58 76.36,163.7 75.85,163.7 75.73,163.58 75.6,163.58 75.47,163.7 75.47,164.72 75.6,164.85 76.74,164.85 76.87,164.72 77.38,164.72 77.5,164.85 77.5,165.48 77.38,165.61 76.87,165.61 76.74,165.48 75.6,165.48 75.47,165.61 75.47,166.62 75.6,166.75 76.36,166.75 76.49,166.88 76.49,167.13 76.36,167.26 75.6,167.26 75.47,167.39 75.47,168.4 75.6,168.53 76.36,168.53 76.49,168.66 76.49,169.42 77.12,169.42 77.25,169.54 77.86,169.54 78.01,169.39 78.01,166.75 78.27,166.5 78.27,162.69 77.88,162.31 76.36,162.31 75.85,161.8
VCC_CORE on TOP: 48.29,173.23 48.17,173.35 48.17,175.01 47.4,175.77 45.25,175.77 44.61,176.4 44.61,186.94 44.86,187.2 50.2,187.2 50.83,186.56 56.29,186.56 56.55,186.31 56.55,180.09 56.8,179.83 62.77,179.83 62.77,179.07 61.88,178.18 61.88,173.35 61.76,173.23 ; 12 cut-outs
VCC_CORE on TOP: 86.14,162.69 85.89,162.94 85.89,167.39 86.14,167.64 87.16,167.64 88.17,166.62 88.17,166.5 88.04,166.37 87.41,166.37 87.28,166.24 87.28,165.86 87.41,165.74 87.79,165.74 87.92,165.86 88.04,165.86 88.17,165.74 88.17,164.72 88.04,164.59 87.41,164.59 87.28,164.47 87.28,164.08 87.41,163.96 88.04,163.96 88.17,163.83 88.17,162.81 88.04,162.69
VCC_CORE on BOTTOM: 70.39,161.54 70.26,161.67 70.26,161.93 70.52,162.18 70.52,162.69 70.39,162.81 70.39,164.34 70.01,164.72 67.47,164.72 63.53,168.66 59.34,168.66 58.96,169.04 58.96,172.21 58.83,172.34 57.95,172.34 57.06,173.23 48.29,173.23 48.17,173.35 48.17,175.01 47.4,175.77 45.25,175.77 44.61,176.4 44.61,186.94 44.86,187.2 50.2,187.2 50.83,186.56 56.29,186.56 56.55,186.31 56.55,180.09 56.8,179.83 62.9,179.83 62.9,176.02 64.42,174.5 73.06,174.5 73.19,174.37 73.19,174.12 73.57,173.74 73.57,173.35 75.6,171.32 75.6,169.29 76.11,168.78 77,168.78 77.12,168.91 77.12,169.42 77.25,169.54 77.63,169.54 77.76,169.42 77.76,167.64 78.14,167.26 86.01,167.26 86.14,167.39 87.66,167.39 87.79,167.26 87.79,163.83 87.66,163.7 87.16,163.7 87.03,163.83 86.39,163.83 86.27,163.96 86.27,164.47 86.01,164.72 85.38,164.72 84.49,163.83 77.25,163.83 76.49,163.07 74.96,163.07 74.58,162.69 74.58,161.8 74.33,161.54 ; 50 cut-outs
VCC_CORE on L3: 86.65,162.81 77.25,162.81 76.74,163.32 76.74,169.42 76.87,169.54 85.76,169.54 86.01,169.29 86.01,167.89 86.77,167.13 86.77,162.94
VCC_CORE on L4: 86.01,167.89 86.77,167.13 86.77,162.94 86.65,162.81 77.25,162.81 76.74,163.32 76.74,171.2 77.25,171.7 85.63,171.7 86.01,171.32
VCC_CORE on L5GND: 69.71,161.86 58.41,173.16 50.75,173.16 48.23,170.64 48.23,174.7 47.36,175.58 45.32,175.58 44.67,176.23 44.67,186.87 44.94,187.13 50.37,187.13 50.88,186.63 56.74,186.63 56.74,186.61 57.23,186.12 62.98,186.12 65.14,188.28 67.01,188.28 67.66,187.63 67.66,181.15 75.27,173.55 76.26,173.55 78.69,171.11 82.39,171.11 82.39,170.48 83.39,169.48 86.31,169.48 86.71,169.09 86.71,167.43 87.46,166.69 87.71,166.69 88.11,166.29 88.11,163.05 87.6,162.54 87.6,162.5 76.41,162.5 75.77,161.86
VCC_FAN on BOTTOM: 5.49,210.82 5.24,211.07 5.24,213.87 5.49,214.12 10.07,214.12 10.45,213.74 15.27,213.74 15.65,213.36 15.65,212.04 14.43,210.82
VCC_VTT on BOTTOM: 89.06,205.61 88.55,206.12 85.25,206.12 85.12,206.25 85.12,208.41 85.5,208.79 85.5,209.4 85.55,209.45 85.55,210.39 85.73,210.39 85.73,209.4 85.76,209.37 85.76,208.91 86.27,208.41 86.52,208.41 86.9,208.79 86.9,209.68 86.39,210.19 86.39,210.69 86.52,210.82 87.28,210.82 87.28,210.57 87.79,210.06 88.81,210.06 89.19,209.68 89.19,209.17 89.31,209.04 90.46,209.04 90.58,208.91 90.58,205.87 90.33,205.61
0D95V_VGA_PWR on TOP: 105.19,100.97 104.94,101.22 101.63,101.22 101.13,101.73 101.13,102.49 101.51,102.87 102.9,102.87 103.16,103.12 103.16,107.57 103.67,108.08 105.95,108.08 106.21,107.82 106.21,103.12 105.7,102.62 105.7,101.09 105.57,100.97 ; 1 cut-out
