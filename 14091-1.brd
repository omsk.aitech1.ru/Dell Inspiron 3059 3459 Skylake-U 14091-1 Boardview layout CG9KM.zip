# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CK_P_33M_EC: length 3.9
  TOP w0.102: U4101.2 98.14,55.06 99.22,53.98 v1(99.32,53.98) 99.54,53.98 R79699.1
CKEA0: length 53.6
  TOP w0.127: MEM1.K9 58.81,110.68 59.22,111.09 59.63,111.09 59.77,110.94 60.95,110.94 v4(60.97,110.96) ; v1(49.25,110.17) 49.77,110.69 51.65,110.69 v4(51.83,110.87) ; GPU1.K20 77.48,103.32 v4(77.48,103.53)
  L3 w0.165: v4(77.48,103.53) 77.65,103.71 77.65,103.73 77.9,103.98 77.93,103.98 78.75,104.81 78.75,108.06 78.45,108.36 78.01,108.36 77.65,108.72 77.15,108.72 76.78,108.35 76.78,108.35 75.98,107.55 74.8,107.55 74.03,108.33 74.02,108.33 73.76,108.59 73.76,108.59 73.5,108.86 69.36,108.86 68.92,109.3 62.39,109.3 61.72,109.96 59.22,109.96 58.67,110.52 58.25,110.52 57.91,110.17 57.32,110.17 56.89,110.6 56.89,111.18 56.06,112.01 56.06,112.2 55.81,112.45 55.18,112.45 v4(55.07,112.34) 54.95,112.34 54.7,112.09 54.64,112.09 54.18,111.63 54.18,111.55 53.78,111.14 52.54,111.14 52.33,111.35 52.33,111.73 52.22,111.84 51.13,111.84 51.01,111.71 51.01,111 51.13,110.87 v4(51.83,110.87)
  L4 w0.165: v4(55.07,112.34) 55.18,112.45 55.81,112.45 55.81,112.45 56.07,112.45 56.92,111.59 57.88,111.59 58.25,111.23 59.72,111.23 60,110.94 60.71,110.94 60.73,110.96 v4(60.97,110.96)
  BOTTOM w0.127: v4(51.83,110.87) 51.89,110.93 52.74,110.93 52.87,110.8 52.87,110.57 52.77,110.48 MEM3.K9
CKEA1: length 45.5
  TOP w0.127: v4(77.26,100) 77,100.26 GPU1.J17 ; MEM2.K9 51.67,92.82 v3(51.66,92.84)
  L3 w0.165: v4(77.26,100) 77.4,100 77.81,99.59 78.14,99.59 79.03,98.7 79.03,97.56 77.81,96.34 77.81,95.98 78.21,95.59 78.45,95.59 78.71,95.33 78.71,94.93 78.07,94.29 78.07,94.13 77.65,93.71 77.34,93.71 76.77,93.14 74.59,93.14 74.38,93.35 72.76,93.35 72.22,93.89 69.84,93.89 69.7,94.04 66.56,94.04 66.39,94.21 61.6,94.21 61.52,94.29 60.43,94.29 59.88,93.74 59.88,93.31 59.62,93.05 59.26,93.05 58.65,93.66 56.98,93.66 56.78,93.46 v4(56.78,93.18) 56.78,93.14 56.33,92.68 56.19,92.68 56,92.49 55.88,92.49 55.46,92.07 55.41,92.07 55.13,91.79 54.67,91.79 54.05,92.41 54.05,92.6 53.79,92.86 51.68,92.86 v3(51.66,92.84)
  L4 w0.165: v4(56.78,93.18) 56.59,92.99 56.59,92.94 56.29,92.65 56.29,92.5 56.55,92.24 56.73,92.24 56.86,92.37 56.86,92.53 56.96,92.63 58.77,92.63 59.08,92.94 59.08,93.23 58.92,93.39 58.59,93.39 v4(58.42,93.22)
  BOTTOM w0.127: MEM4.K9 58.81,93.12 58.71,93.22 v4(58.42,93.22)
CLINK_CLK_LAN: length 4.2
  TOP w0.102: TP67.1 121.57,214.63 120.43,214.63 120.06,215 NGFF1.42
CLINK_DATA_LAN: length 2.7
  TOP w0.102: NGFF1.40 120.05,214.5 120.56,214 TP66.1
CLINK_RST_LAN_N: length 5.4
  TOP w0.102: NGFF1.38 119.79,214 120.33,213.46 123.07,213.46 TP65.1
CLK: length 21.5
  TOP w0.102: v3(74.96,54.86) 74.96,53.67 75.47,53.16 v1(76.13,53.16) 76.21,53.16 76.87,53.82 R9501.2 ; SCA1.115 61.12,55.75 v3(60.74,56.13)
  L4 w0.127: v3(74.96,54.86) 74.58,55.24 70.14,55.24 68.91,56.48 63.34,56.48 62.49,55.63 61.25,55.63 v3(60.74,56.13)
CLK_1: length 3
  TOP w0.102: U9501.6 v1(77.12,56.59) 76.87,56.34 R9501.1
CLK_CR_N: length 197.6
  TOP w0.102: CPU1.D40 74.06,168.03 v4(74.15,167.94)
  L3 w0.127: v4(74.15,167.94) 74.15,167.82 73.48,167.14 73.48,166.41 71.78,164.71 68.6,164.71 64.87,160.97 61.08,160.97 60.17,160.06 60.17,153.35 62.26,151.26 62.9,151.26 64.8,149.35 64.8,148.72 63.28,147.19 63.28,138.08 72.02,129.34 79.23,129.34 94.01,114.55 120.81,114.55 123.33,112.03 147.71,112.03 149.63,110.11 151.67,110.11 v3(151.93,110.36)
  BOTTOM w0.102: 160.41,114.73 180.4,134.72 180.4,141.46 180.29,141.58 180.29,141.88 180.4,141.99 180.4,142.3 180.29,142.41 180.29,142.71 180.4,142.83 180.4,143.13 180.29,143.24 180.29,143.55 180.4,143.66 180.4,144.02 179.38,145.03 177.55,145.03 177.46,144.94 U14.6 ; 160.41,114.73 158.29,112.61 152.9,112.61 152.47,112.18 152.47,111.42 152.36,111.31 152.36,111.02 152.47,110.91 152.47,110.17 152.34,110.05 152.24,110.05 v3(151.93,110.36) ; 160.41,114.73 v2(160.15,114.99)
CLK_CR_P: length 197.6
  TOP w0.102: v4(73.21,167.56) 72.99,167.78 CPU1.C40
  L3 w0.127: v4(73.21,167.56) 73.21,166.52 71.66,164.97 68.49,164.97 64.75,161.24 60.97,161.24 59.9,160.17 59.9,159.64 59.9,153.24 62.15,150.99 62.79,150.99 64.54,149.24 64.54,148.83 63.17,147.46 63.01,147.3 63.01,137.97 71.91,129.07 79.12,129.07 93.9,114.29 120.7,114.29 123.22,111.76 147.6,111.76 149.52,109.84 151.68,109.84 v3(151.93,109.6)
  BOTTOM w0.102: U14.5 177.46,145.34 177.55,145.25 179.47,145.25 180.61,144.11 180.61,134.63 158.38,112.39 156.88,112.39 ; 156.88,112.39 152.99,112.39 152.69,112.09 152.69,110.08 152.43,109.83 152.15,109.83 v3(151.93,109.6) ; 156.88,112.39 v2(156.88,112.06)
CLK_GFX_N: length 98.1
  TOP w0.102: CPU1.D42 74.04,169.16 74.34,168.85 v4(74.68,168.85) ; 86.89,116.22 87.99,115.11 91.92,115.11 93.47,113.56 93.47,111.99 92.86,111.38 92.86,110.94 GPU1.AK32 ; 86.89,116.22 v1(87.18,116.51) ; 86.89,116.22 81.57,121.54 81.57,121.92 81.69,122.05 v3(82.08,122.05)
  L3 w0.127: v4(74.68,168.85) 74.46,169.06 73.72,169.06 73.44,168.78 73.44,168.78 72.41,167.75 72.41,166.86 71.25,165.7 68.2,165.7 64.44,161.94 58.67,161.94 57.46,160.73 57.46,158.7 59.08,157.09 59.08,150.43 58.49,149.84 58.49,134.71 59.36,133.85 63.61,129.59 64.76,128.45 70.72,128.45 77.5,121.67 81.31,121.67 81.69,122.05 v3(82.08,122.05)
CLK_GFX_P: length 98.1
  TOP w0.102: v4(73.9,168.63) 73.73,168.63 73.2,169.16 CPU1.C42 ; v1(84.59,117.65) 84.87,117.93 ; 84.87,117.93 81.35,121.45 81.35,122.01 81.44,122.1 v3(81.44,122.56) ; 84.87,117.93 87.9,114.9 91.83,114.9 93.25,113.47 93.25,112.08 92.64,111.47 92.64,110.36 GPU1.AK30
  L3 w0.127: v4(73.9,168.63) 73.67,168.63 72.68,167.64 72.68,166.75 71.36,165.43 68.31,165.43 64.55,161.67 58.78,161.67 57.73,160.62 57.73,158.81 59.34,157.2 59.34,150.32 58.76,149.73 58.76,134.82 59.76,133.82 59.95,133.82 60.22,133.55 60.22,133.36 60.49,133.09 60.69,133.09 60.96,132.82 60.96,132.62 61.95,131.63 62.15,131.63 62.41,131.36 62.41,131.17 62.68,130.9 62.88,130.9 63.15,130.63 63.15,130.43 63.42,130.16 63.61,130.16 63.88,129.89 63.88,129.7 64.87,128.71 70.83,128.71 75.28,124.27 75.47,124.27 75.74,124 75.74,123.81 76.01,123.54 76.2,123.54 76.47,123.27 76.47,123.07 76.74,122.8 76.94,122.8 77.2,122.54 77.2,122.34 77.61,121.93 78.76,121.93 78.89,122.07 79.27,122.07 79.41,121.93 79.79,121.93 79.93,122.07 80.31,122.07 80.45,121.93 81.2,121.93 81.44,122.17 v3(81.44,122.56)
CLK_GLAN_N: length 212
  TOP w0.102: v3(27.85,55.5) 27.55,55.79 27.55,56.04 27.68,56.17 29.97,56.17 32.29,53.85 32.29,46.54 28.4,42.65 27.06,42.65 26.8,42.39 26.32,41.91 26.32,38.43 23.03,35.14 23.03,19.37 25.34,17.06 32.63,17.06 33.21,17.63 36.47,17.63 36.57,17.53 36.57,17.4 36.48,17.31 U16.16 ; CPU1.B42 71.91,168.74 60.74,168.74 59.18,167.17 59.18,161.55 58.85,161.22 58.85,159.42 v3(59.11,159.16)
  BOTTOM w0.102: v2(51.21,133.27) 50.92,133.27 ; 50.92,133.27 50.92,131.28 46.63,126.99 32.15,126.99 30.13,124.97 30.13,73.28 27.97,71.12 27.97,56.64 27.59,56.26 27.59,55.75 v3(27.85,55.5) ; 50.92,133.27 50.92,142.01 52.1,143.19 52.1,157.17 52.79,157.86 58.17,157.86 58.64,158.33 58.64,158.8 59,159.16 v3(59.11,159.16)
CLK_GLAN_P: length 212.1
  TOP w0.102: U16.15 36.88,17.33 36.79,17.42 36.79,17.62 36.56,17.84 33.12,17.84 32.55,17.27 25.43,17.27 23.25,19.46 23.25,35.05 26.54,38.34 26.54,41.82 26.89,42.18 27.15,42.43 28.49,42.43 32.51,46.45 32.51,53.94 30.06,56.39 27.59,56.39 27.34,56.13 27.34,55.75 v3(27.08,55.5) ; CPU1.A42 71.48,168.95 60.65,168.95 58.96,167.26 58.96,161.64 58.63,161.31 58.63,159.44 v3(58.35,159.16)
  BOTTOM w0.102: 50.71,135.1 50.71,131.37 46.54,127.2 32.06,127.2 29.92,125.06 29.92,73.37 27.76,71.21 27.76,56.73 27.38,56.35 27.38,55.79 v3(27.08,55.5) ; 50.71,135.1 50.71,142.1 51.89,143.28 51.89,157.26 52.7,158.08 58.08,158.08 58.43,158.42 58.43,159.08 v3(58.35,159.16) ; 50.71,135.1 v2(50.4,135.1)
CLK_WLAN_N: length 96.9
  TOP w0.102: v3(80.42,202.56) 80.15,202.29 80.15,201.88 80.81,201.22 83.73,201.22 86.95,197.99 87.89,197.99 ; CPU1.D41 73.13,168.6 72.8,168.28 72.55,168.28 72.5,168.33 71.33,168.33 71.03,168.02 69.88,168.02 69.76,167.89 69.76,167.77 v4(70.01,167.51) ; R23.2 105.61,217.02 105.12,217.02 103.87,215.77 103.87,210.44 104.72,209.59 104.72,201.25 101.46,197.99 87.89,197.99 ; 87.89,197.99 v1(87.89,198.42)
  L3 w0.127: v3(80.42,202.56) 80.18,202.33 80.18,200.42 78.07,198.31 75.73,198.31 67.33,189.91 67.33,176.67 68.99,175.01 70.01,175.01 72.17,172.85 72.17,169.42 71.15,168.4 70.21,168.4 69.83,168.02 69.83,167.7 v4(70.01,167.51)
CLK_WLAN_P: length 96.8
  TOP w0.102: R22.2 105.61,216.81 105.21,216.81 104.08,215.68 104.08,210.53 104.94,209.68 104.94,201.16 101.55,197.78 86.86,197.78 85.21,199.43 ; v3(79.66,202.56) 79.94,202.29 79.94,201.79 80.72,201 83.64,201 85.21,199.43 ; 85.21,199.43 v1(84.92,199.14) ; v4(69.38,167.51) 69.54,167.68 69.54,167.98 69.79,168.24 70.94,168.24 71.24,168.54 72.61,168.54 CPU1.C41
  L3 w0.127: v4(69.38,167.51) 69.56,167.7 69.56,168.13 70.1,168.67 71.04,168.67 71.9,169.53 71.9,172.74 69.9,174.74 68.88,174.74 67.06,176.56 67.06,190.02 75.62,198.58 77.96,198.58 79.92,200.53 79.92,202.31 v3(79.66,202.56)
CLKA0: length 48.9
  TOP w0.127: v4(76.6,107.2) 76.6,107.2 GPU1.H26 ; MEM1.J7 56.66,111.52 56.4,111.63 55.88,111.63 55.68,111.6 55.58,111.59 v4(54.95,111.39) ; R80089.1 49.62,111.76 50.3,111.76 v4(50.57,112.03)
  L4 w0.152: v4(50.57,112.03) 50.94,111.65 52.17,111.65 52.6,111.23 54.78,111.23 v4(54.95,111.39) 54.82,111.52 54.75,111.52 53.95,112.32 53.24,112.32 52.85,112.71 52.85,116.29 55.91,119.35 63.08,119.35 73.25,109.18 73.25,109.11 74.98,107.38 76.24,107.38 76.42,107.2 v4(76.6,107.2)
  BOTTOM w0.127: MEM3.J7 54.21,111.48 54.21,111.76 54.38,111.93 54.86,111.93 54.89,111.9 55.01,111.9 55.16,111.75 55.16,111.6 v4(54.95,111.39) ; v4(50.57,112.03) 49.94,112.65 v2(49.88,112.65)
CLKA0#: length 49.2
  TOP w0.127: v4(55.53,111.08) 55.69,111.08 56,111.38 56.34,111.38 57.21,110.51 MEM1.K7 ; GPU1.H25 76.2,106.79 76.58,106.41 v4(76.6,106.41) ; v4(50.51,111.22) 50.22,111.51 49.38,111.51 R1906.1
  L4 w0.152: v4(50.51,111.22) 50.64,111.35 52.05,111.35 52.47,110.92 55.09,110.92 55.24,111.08 v4(55.53,111.08) 55.55,111.09 55.55,111.48 55.17,111.86 54.84,111.86 54.07,112.62 53.37,112.62 53.15,112.84 53.15,116.16 56.04,119.04 62.96,119.04 72.94,109.06 72.94,108.98 74.85,107.07 76.11,107.07 76.42,106.77 76.47,106.77 76.6,106.64 v4(76.6,106.41)
  BOTTOM w0.127: v2(49.94,110.67) 49.97,110.67 v4(50.51,111.22) ; v4(55.53,111.08) 55.32,110.86 55,110.86 54.95,110.91 54.8,110.91 54.74,110.98 54.28,110.98 54.01,110.71 MEM3.K7
CLKA1: length 49.2
  TOP w0.127: MEM2.J7 54.15,92.02 54.65,91.52 55.09,91.52 55.43,91.18 v4(55.43,91.01) ; v4(75.01,93.6) 75.24,93.6 75.4,93.76 GPU1.G9 ; v4(50.6,91.86) 50.15,92.3 49.58,92.3 R1909.1
  L4 w0.152: v4(50.6,91.86) 50.71,91.97 52.08,91.97 52.66,91.39 55.06,91.39 v4(55.43,91.01) 55.58,91.16 55.79,91.16 55.89,91.26 56.59,91.26 57.37,92.05 59,92.05 59.16,92.22 61.1,92.22 62.56,93.67 62.56,94.58 62.23,94.91 61.97,94.91 61.81,95.06 61.81,95.36 61.97,95.52 62.23,95.52 62.56,95.85 62.56,96.4 62.23,96.74 61.97,96.74 61.81,96.89 61.81,97.19 61.97,97.34 62.22,97.34 62.53,97.65 62.53,98.26 61.94,98.84 61.94,99.46 62.6,100.12 62.87,100.12 63.57,100.82 63.87,100.82 64.03,100.66 64.03,100.45 64.36,100.12 64.91,100.12 65.25,100.45 65.25,100.87 65.37,100.99 65.73,100.99 65.85,100.87 65.85,100.45 66.19,100.12 72.31,100.12 74.34,98.09 74.34,96.72 74.49,96.56 74.49,95.15 75.44,94.2 75.44,93.83 75.21,93.6 v4(75.01,93.6)
  BOTTOM w0.127: MEM4.J7 57.08,92.02 56.25,91.19 55.61,91.19 v4(55.43,91.01) ; v2(74.23,93.75) 74.38,93.6 v4(75.01,93.6)
CLKA1#: length 49.7
  TOP w0.127: MEM2.K7 54.34,92.49 54.5,92.05 54.72,91.82 54.76,91.81 55.14,91.81 55.2,91.79 v4(55.59,91.64) ; v4(75.81,93.6) 76.2,93.99 GPU1.H9 ; R80090.1 49.88,92.56 50.5,92.56 v4(50.61,92.67)
  L4 w0.152: v4(75.81,93.6) 75.75,93.65 75.75,94.32 74.8,95.27 74.8,96.69 74.64,96.84 74.64,98.22 72.43,100.42 66.31,100.42 66.16,100.58 66.16,100.99 65.85,101.3 65.25,101.3 64.94,100.99 64.94,100.58 64.79,100.42 64.48,100.42 64.33,100.58 64.33,100.79 64,101.12 63.44,101.12 62.74,100.42 62.48,100.42 61.64,99.58 61.64,98.72 62.22,98.13 62.22,97.78 62.1,97.65 61.84,97.65 61.51,97.32 61.51,96.76 61.84,96.43 62.1,96.43 62.25,96.28 62.25,95.97 62.1,95.82 61.84,95.82 61.51,95.49 61.51,94.93 61.84,94.6 62.1,94.6 62.25,94.45 62.25,93.8 60.98,92.52 59.04,92.52 58.87,92.35 57.25,92.35 56.49,91.6 55.63,91.6 v4(55.59,91.64) 55.54,91.69 52.79,91.69 52.21,92.27 51.01,92.27 v4(50.61,92.67)
  BOTTOM w0.127: MEM4.K7 57.21,92.53 56.14,91.46 55.77,91.46 v4(55.59,91.64) ; v4(75.81,93.6) 75.75,93.65 v2(75.75,94.44)
CLKTESTA: length 10
  TOP w0.102: C764.1 76.55,85.66 v4(77.25,86.36) ; GPU1.K8 77.48,92.88 77.48,92.83 v4(77.45,92.8)
  L3 w0.127: v4(77.25,86.36) 77.15,86.46 77.15,87.86 76.7,88.31 76.7,90.42 76.95,90.67 76.95,92.31 v4(77.45,92.8)
  BOTTOM w0.102: v4(77.25,86.36) 77.5,86.36 v2(77.88,86.74)
CLKTESTA_C: length 2.5
  TOP w0.102: v1(77.12,82.61) 77.44,82.93 R1207.1 C764.2
CLKTESTB: length 14.3
  TOP w0.102: GPU1.L7 79.21,92.4 79.66,91.95 80.32,91.95 80.53,91.74 80.53,89.92 80.53,89.92 80.47,89.77 80.47,89.42 80.51,89.32 80.55,89.13 80.55,87.64 82.47,85.72 83.1,85.72 83.51,85.32 v1(84.97,85.32) 86.26,85.32 86.34,85.39 86.89,85.39 C763.1
CLKTESTB_C: length 2.3
  TOP w0.102: R1206.1 C763.2 88.36,86.47 v1(87.82,87.02)
CPU_A16_TP: length 4.7
  TOP w0.102: CPU1.BB9 94.31,149.3 96.76,146.86 TP1902.1
CPU_A17_TP: length 3.7
  TOP w0.089: CPU1.BA9 94.02,149.8 94.1,149.8 94.21,149.84 94.47,149.84 94.83,149.48 94.83,149.17
  TOP w0.102: 94.83,149.17 95.54,148.46 TP1901.1
CPU_B16_TP: length 1.6
  TOP w0.102: CPU1.AP7 89.25,148.13 v4(88.92,147.8)
  BOTTOM w0.102: TP2011.1 89.06,147.67 v4(88.92,147.8)
CPU_B17_TP: length 3.2
  TOP w0.102: v4(88.92,148.72) 89.25,149.05 CPU1.AP8
  BOTTOM w0.102: v4(88.92,148.72) 88.92,148.47 TP2012.1
CPU_C18_TP: length 5.2
  TOP w0.102: CPU1.U8 80.75,148.71 80.95,148.92 v4(81.26,148.92)
  BOTTOM w0.102: v4(81.26,148.92) 81.69,148.49 81.69,147.04 81.67,147.01 81.67,146.77 81.31,146.42 81.31,146.05 80.68,145.41 TP2016.1
CPU_C19_TP: length 7.4
  TOP w0.102: v4(81.28,149.59) 80.95,149.59 CPU1.U9
  BOTTOM w0.102: TP2017.1 80.42,143.76 81.31,144.65 81.31,145.67 81.86,146.22 81.86,146.94 81.88,146.96 81.88,148.98 v4(81.28,149.59)
CPU_D4_TP: length 7.1
  TOP w0.089: CPU1.V1 81.16,144.57 81.06,144.47
  TOP w0.102: 81.06,144.47 80.86,144.27 80.86,143.4 80.2,142.73 80.2,140.06 81.31,138.94 TP1804.1
CPU_D5_TP: length 7.4
  TOP w0.089: CPU1.V2 81.16,145.52 80.81,145.16 80.81,144.53 80.68,144.4 80.68,143.48 80.46,143.26
  TOP w0.102: TP1805.1 79.92,139.24 79.92,142.72 80.46,143.26
CPU_DDR_EN: length 16.5
  TOP w0.102: R504.2 82.53,207.53 82.53,209.1 v1(81.62,210.02) 80.84,210.79 80.84,218.99 81.19,219.33 U501.2
CPU_DDR_VTT_CNTL: length 31.7
  TOP w0.102: R80162.1 R504.1 81.05,205.56 81.38,205.56 86.73,200.2 v3(86.73,200.11) ; CPU1.AW67 92.55,183.19 93.58,183.19 v4(93.82,183.43)
  BOTTOM w0.102: v4(93.82,183.43) 93.18,183.43 90.08,186.54 v2(90.08,196.27) 90.08,196.77 v3(86.73,200.11)
CPU_FAN_CTRL_SIO: length 333.2
  TOP w0.165: U109.6 141.01,65.92 v3(141.77,66.67) ; R68.1 v3(10.57,219.46)
  L3 w0.165: v3(10.57,219.46) 10.57,221.67 16.87,227.97 117.51,227.97 118.65,226.82 118.65,211.64 121.36,208.93 154.8,208.93 156.58,207.16 159.31,207.16 159.55,207.39 160.82,207.39 v3(161.32,206.88)
  BOTTOM w0.165: v3(161.32,206.88) 161.32,201.9 162.47,200.75 162.47,151.1 160.18,148.82 v2(160.18,147.32) 160.18,145.08 159.56,144.46 159.56,123.77 156.1,120.3 144.53,120.3 143.18,118.95 143.18,118.54 143.77,117.96 143.77,74.77 141.77,72.77 v3(141.77,66.67)
CPU_FAN_TACH_SIO: length 331.2
  TOP w0.165: U109.5 141.41,65.56 v3(141.77,65.91) ; v3(15.78,216.79) 16.67,215.9 16.67,213.74 17.99,212.42 17.99,210.32 R74.1
  L3 w0.165: v3(161.83,200.15) 161.7,200.28 160.05,200.28 155.61,204.72 128.02,204.72 126.65,206.09 114.05,206.09 113.3,205.34 108.83,205.34 108.79,205.3 90.36,205.3 90.24,205.42 86.34,205.42 81.19,210.57 81.19,217.37 80.95,217.6 80.95,218.01 80.95,218.01 80.95,224 79.21,225.74 59.26,225.74 58.63,225.1 49.8,225.1 48.2,223.5 35.07,223.5 33.45,221.89 17.04,221.89 15.67,220.52 15.67,216.9 v3(15.78,216.79)
  BOTTOM w0.165: v3(141.77,65.91) 141.28,66.4 141.28,72.89 143.35,74.96 143.35,117.78 142.76,118.37 142.76,119.12 144.36,120.72 155.93,120.72 159.14,123.94 159.14,144.64 159.51,145 159.51,148.74 161.83,151.06 v2(161.83,195.83) v3(161.83,200.15)
CPU_POPIRCOMP: length 7.5
  TOP w0.203: CPU1.AT16 90.55,153.88 v4(90.22,154.2)
  BOTTOM w0.203: v4(90.22,154.2) 90.68,154.66 91.33,154.66 91.71,154.66 92.27,154.1 93.4,154.1 94.6,152.91 R80007.1 94.71,152.82 95.66,151.87 v2(95.71,151.87)
CPVEE: length 2.8
  TOP w0.203: v1(162.9,71.94) 163.12,72.16 163.12,72.56 163.19,72.63 U6.20
  TOP w0.508: C1491.1 162.21,71.25 v1(162.9,71.94)
CR_CLKREQ_R: length 5.5
  BOTTOM w0.102: U14.2 178.07,146.54 179.74,148.21 v2(179.74,148.84) R458.1
CRCLK_REQ_N: length 118.2
  TOP w0.102: v4(179.61,151.89) 176.56,151.89 171.61,156.84 163.74,156.84 v4(163.67,156.78)
  L4 w0.127: v4(163.67,156.78) 164.56,155.89 164.56,132.52 153.58,121.54 138.72,121.54 135.31,118.14 130.63,118.14 108.55,140.21 v3(107.86,140.21)
  BOTTOM w0.102: R79764.2 108.11,140.46 v3(107.86,140.21) 107.6,140.46 R80064.2 ; v4(163.67,156.78) 163.67,157.41 v2(163.52,157.55) ; v4(179.61,151.89) 179.74,151.76 R458.2
CSA0#_0: length 44.6
  TOP w0.127: v4(56.1,109.15) 55.49,109.15 55.36,109.28 55.36,109.61 55.24,109.74 54.49,109.74 54.38,109.62 54.38,109.44 54.25,109.31 53.34,109.31 53.21,109.43 MEM1.L2 ; GPU1.H22 76.04,104.2 75.84,104.4 v4(75.84,104.78)
  L3 w0.102: v4(75.84,104.78) 76.17,105.11 76.17,105.76 75.94,105.99 74.7,105.99 74.26,106.43 73.4,106.43 73.11,106.14
  L3 w0.165: 73.11,106.14 72.94,105.97 72.47,105.97 72.27,106.18 72.27,106.41 72.01,106.66 71,106.66 70.86,106.52 70.86,106.2 70.73,106.07 70.11,106.07 69.98,106.2 69.98,106.53 69.86,106.66 69.53,106.66 69.35,106.84 69.08,106.84 68.61,107.31 68.23,107.69 67.21,107.69 67.09,107.56 67.09,106.91 66.96,106.79 63.25,106.79 62.97,106.51 62.67,106.51 62.39,106.79 62.14,106.79 61.96,106.6 61.43,106.6 61.19,106.84 61.19,107.15 61.07,107.28 60.18,107.28 60.07,107.17 58.12,107.17 57.26,108.03 56.67,108.03 56.51,108.18 56.06,108.18 55.79,107.92 55.73,107.92 55.51,107.7 52.86,107.7 52.66,107.9 52.66,109.35 52.89,109.58 54.03,109.58 54.23,109.38 54.23,109.02 54.44,108.82 55.07,108.82 55.55,109.3 55.95,109.3 v4(56.1,109.15)
  BOTTOM w0.127: v4(56.1,109.15) 56.1,109.37 56.3,109.57 56.3,109.75 56.43,109.87 56.7,109.87 56.85,109.72 56.85,109.37 56.98,109.24 57.29,109.24 57.73,109.68 MEM3.L2 ; v2(75.8,106.38) 76.21,105.97 76.21,105.15 v4(75.84,104.78)
CSA1#_0: length 43.7
  TOP w0.127: MEM2.L2 57.65,93.98 55.6,93.98 v4(55.32,93.7) ; GPU1.G13 75.71,97 76.06,96.66 76.09,96.66 76.54,96.2 76.54,95.27 v4(76.59,95.23)
  L3 w0.165: v3(59.4,98.28) 59.19,98.48 57.36,98.48 57.23,98.35 57.23,97.8 57.36,97.67 58.58,97.67 58.66,97.59 60.08,97.59 62.24,95.44 66.9,95.44 67.06,95.27 70.49,95.27 70.63,95.42 72.23,95.42 72.57,95.08 74.24,95.08 74.5,94.83 74.78,94.55 76.06,94.55 76.59,95.08 v4(76.59,95.23)
  L4 w0.102: v4(55.32,93.7) 55.74,94.12 58.71,94.12 58.97,94.38
  L4 w0.165: 58.97,94.38 58.97,95.89 59.33,96.26 60.2,96.26 60.33,96.38 60.33,97.43 60.14,97.62 60.14,97.69 60.14,97.69 60.14,98.58 60.04,98.68 59.81,98.68 v3(59.4,98.28)
  BOTTOM w0.127: v3(59.4,98.28) 59.47,98.34 v2(59.47,99.55) ; MEM4.L2 53.21,93.92 53.34,94.05 54.32,94.05 54.4,94.13 54.76,94.13 54.82,94.07 54.96,94.07 v4(55.32,93.7)
CSI2_COMP: length 2.5
  TOP w0.203: v4(74.08,151.45) 74.41,151.79 CPU1.E13
  BOTTOM w0.203: v4(74.08,151.45) 73.89,151.64 v2(73.26,151.64) R1501.1
CTF_TRIP: length 8.1
  TOP w0.102: v3(92.3,81.79) 92.93,82.42 94.88,82.42 v1(95.54,83.08) 95.33,83.29 94.69,83.29 R80085.2
  BOTTOM w0.102: Q48.B 92.33,83.41 C755.2 92.68,82.17 v3(92.3,81.79)
CTFB: length 10.6
  BOTTOM w0.102: R354.2 93.7,86.17 v2(93.76,86.23) 93.57,86.42 Q48.C 90.14,86.42 87.54,83.82 R1920.2
DC_19V: length 99
  TOP w0.254: PR8523.1 36.36,58.8 35.8,59.36 34.4,59.36 v3(33.94,59.82)
  TOP w0.508: 38.9,73.91 v5(38.9,75.36) ; PR4424.1 46.88,41.33 49.97,41.33 v3(50.3,41.66)
  L3 w0.381: v5(62.9,36.45) 62.05,35.6 60.49,35.6 59.22,36.87 59.22,38.73 56.71,41.24 56.71,44.16 v3(56.42,44.45) 52.61,48.26 52.61,51.82 ; 52.61,51.82 51.72,51.82 48.42,48.51 v3(48.42,48.01) ; 52.61,51.82 52.61,55.24 43.98,63.87 v3(43.98,64.64)
  L3 w0.508: v3(48.42,48.01) 48.85,48.01 50.3,46.56 50.3,45.59 49.44,44.73 49.44,42.52 v3(50.3,41.66)
  BOTTOM w0.254: 39.34,72.77 34.48,67.91 34.48,64.26 34.58,64.16 34.58,60.45 v3(33.94,59.82)
  BOTTOM w0.381: PR4433.1 55.34,45.5 55.82,45.02 55.85,45.02 v3(56.42,44.45) ; v5(38.9,75.36) 38.9,74.42 38.32,73.85 PR4417.1 PC4403.2 39.34,72.77 39.85,72.26 44.1,72.26 44.48,71.88 v2(44.48,68.88) 44.48,65.14 v3(43.98,64.64)
  BOTTOM w0.508: PR4403.1 47.86,48.56 v3(48.42,48.01)
  vias: v2(69.27,35.15) v5(63.84,36.45) v5(64.75,36.45) v5(65.67,36.45) v5(66.58,36.45)
DC_IN_D: length 2.8
  BOTTOM w0.254: PQ4404.3 55.48,43.81 55.69,44.02 v2(55.69,44.1) 55.69,44.15 55.23,44.62 PR4433.2
DCBATOUT: length 148.2
  TOP w0.203: 150.43,23.75 150.55,23.62 150.55,23.61 150.58,23.58 150.58,23.24 150.79,23.03 PU4501.11
  TOP w0.254: v3(123.1,23.62) 126.38,23.62 128.46,21.54 128.46,16.74 129.34,15.85 129.34,15.27 128.8,14.73 R733.1 R1778.1
  TOP w0.381: R288.1 147.04,75.37 v3(146.59,75.82)
  TOP w0.508: PR4511.1 147.29,23.6 147.54,23.85 148.04,23.85 149.16,24.97 PC4507.1 ; v3(139.23,74.04) 137.96,74.04 137.7,73.79 135.67,73.79 135.29,74.17 ; PR101.1 v3(120.87,94.18) ; 150.43,23.75 PC4507.1 ; PC4507.1 149.21,26.44 PC4506.1 149.39,26.62 149.39,30.1 v5(147.48,32) ; PR4458.1 41.18,48.77 41.89,49.48 PC4407.1
  TOP w1.016: v5(147.48,32) 147.48,32.89 149.44,34.85 149.44,39.02 151.26,40.85 151.26,45.36
  L3 w1.27: v5(51.47,49.91) 51.47,41.15 v5(52.61,40.01)
  L4 w0.381: v3(139.23,74.04) 139.99,74.8 145.58,74.8 v3(146.59,75.82)
  BOTTOM w0.254: R1777.1 119.74,14.06 R1780.1 119.41,14.44 117.42,14.44 117,14.86 117,18.41 119.39,20.8 119.39,24.13
  BOTTOM w0.508: v3(75.09,49.28) 75.12,49.3 75.12,50.31 75.85,51.04 75.85,57.12 73.29,59.69 v2(73.29,60.22) 73.29,62.43 73.24,62.48 73.24,62.49 R9601.1 73.21,62.52 73.21,63.51 R9602.1 ; v3(120.87,94.18) 119.85,93.16 119.85,93.15 v2(119.16,92.46) 118.65,91.95 110.02,91.95 108.57,90.5 106.28,90.5 104.5,88.72 104.5,83.49 106.61,81.38 106.61,79.43 106.33,79.15 106.33,70.87 106.97,70.23 108.77,70.23 109.41,69.6 109.41,64.16
  vias: v2(16.49,183.85) v2(16.82,141.22) v2(25.61,214.96) v2(39.23,188.8) v2(40.14,79.38) v2(53.65,222.48) v2(62.64,47.14) v2(79.38,223.37) v2(100.87,61.34) v2(135.52,76.56) v2(141.77,29.69) v5(16.19,138.33) v5(16.19,137.41) v5(16.19,136.5) v5(17.1,138.33) v5(17.1,137.41) v5(17.1,136.5) v5(18.07,137.41) v5(18.07,136.5) v5(22.39,167.61) v5(22.39,166.7) v5(23.38,167.61) v5(23.38,166.7) v5(24.29,166.7) v5(25.28,166.7) v5(35.49,81.03) v5(35.62,80.01) v5(36.41,81.03) v5(36.53,80.01) v5(37.32,81.03) v5(37.45,80.01) v5(39.53,76.33) v5(40.52,76.35) v5(40.52,75.44) v5(41.44,76.35) v5(41.44,75.44) v5(42.4,75.44) v5(42.45,52.98) v5(42.45,52.07) v5(43.37,52.98) v5(43.37,52.07) v5(43.37,51.16) v5(44.28,52.98) v5(44.28,52.07) v5(44.28,51.16) v5(58.58,221.49) v5(59.6,221.49) v5(63.76,45.59) v5(64.68,45.59) v5(77.88,221.87) v5(77.88,220.85) v5(77.88,219.84) v5(95.21,46.74) v5(95.64,47.62) v5(96.12,46.74) v5(96.55,47.62) v5(97.04,46.74) v5(97.95,46.74) v5(106.51,62.61) v5(107.42,62.61) v5(108.34,62.61) v5(109.25,62.61) v5(128.1,76.58) v5(129.01,76.58) v5(129.93,76.58) v5(130.84,76.58) v5(133.13,79.65) v5(133.13,78.74) v5(133.13,77.83) v5(134.4,79.68) v5(134.4,78.77) v5(134.4,77.85)
DCBATOUT_VCCGTA: length 12.2
  TOP w0.508: PR4638.2 v3(30.41,208.66)
  L4 w0.254: v5(38.69,216.03) 38.05,216.03 33.32,211.3 33.29,211.3 30.64,208.66 v3(30.41,208.66)
  vias: v2(34.5,219) v2(39.28,214.63) v5(39.61,217.04) v5(39.61,216.03) v5(40.52,217.04) v5(40.52,216.03) v5(41.44,217.04) v5(41.44,216.03)
DCBATOUT_VCCGTB:
  vias: v2(37.83,195.38) v2(45.6,195.63) v5(36.46,195.33) v5(36.48,194.31) v5(39.23,195.33) v5(39.23,194.31) v5(40.14,195.33) v5(40.14,194.31) v5(41.05,195.33) v5(41.05,194.31)
DCBATOUT_VCCSA:
  vias: v2(30.34,170) v5(30.01,167.77) v5(31.28,167.77)
DCBATOUT_VCORE:
  vias: v2(20.12,175.46) v2(24.67,175.31) v5(25.79,175.92) v5(26.7,175.92) v5(26.7,175.01) v5(26.7,173.99)
DCIN_EN: length 4.2
  TOP w0.102: v3(134.15,39.88) 133.75,39.48 U118.13
  BOTTOM w0.102: v3(134.15,39.88) 134.02,40.01 v2(134.02,40.92) 134.02,42 R2087.2
DDC5V_HDMI: length 29.5
  TOP w0.254: D5201.3 120.05,24.99 121.85,23.19 121.85,22.5 v3(121.32,21.97) ; 126.78,21.72 126.78,20.1 C12217.1 126.59,19.91 R5209.1 127.22,18.41 v3(127.41,18.41) 127.95,17.88 127.95,17.02 127.21,16.28 126.62,16.28 125.98,16.92 125.54,16.92 124.92,16.3 124.92,14.28 124.59,13.94 123.38,13.94 122.65,14.67 R5213.1
  BOTTOM w0.254: v3(127.41,18.41) 126.08,19.75 R5214.1 126.27,20.38 126.27,20.85 125.15,21.97 v2(124.32,21.97) v3(121.32,21.97)
DDC5V_HDMI_R: length 5.2
  TOP w0.508: R5217.2 121.78,28.45 121.27,27.94 v3(121.27,26.39) 121.27,25.43 D5201.2
  BOTTOM w0.254: v2(120.45,26.39) v3(121.27,26.39)
DDC_WP: length 103.6
  TOP w0.102: v3(66.58,72.77) 67.09,73.28 67.09,73.66 67.62,74.19 SCA1.39 ; v3(124.37,17.65) 124.49,17.53 125.99,17.53 126.52,16.99 v1(126.86,16.99) 126.96,17.09 126.96,17.68 126.6,18.03 R5212.2
  L3 w0.127: v3(124.37,17.65) 123.35,18.67 123.35,22.61 120.56,25.4 108.83,25.4 107.05,27.18 101.76,27.18 100.87,28.07 100.87,30.61 95.66,35.82 95.66,43.94 89.7,49.91 84.89,49.91 81.69,53.1 81.69,54.1 77.32,58.48 77.32,67.33 75.17,69.47 73.44,69.47 72.3,70.61 69.5,70.61 68.99,71.12 66.81,71.12 66.11,71.81 66.11,72.3 v3(66.58,72.77)
DDC_WP_1: length 3.8
  TOP w0.102: 125.51,21.72 125.51,20.29 125.7,20.1 v1(125.7,20.04) R5209.2 R5212.1
DDCBUF: length 6.1
  TOP w0.102: U118.14 133.35,38.82 133.51,38.98 133.51,39.75 v3(133.38,39.88)
  BOTTOM w0.102: R1598.2 132.8,41.9 132.8,40.98 132.8,40.98 v2(132.8,40.83) 132.8,40.46 v3(133.38,39.88) 133.51,39.75 133.51,38.8 R2089.1
DDPB_CTRL_CLK_CONN: length 22.3
  TOP w0.102: U118.32 131.35,32.51 130.72,31.88 v3(130.72,31.75) R2083.2 ; v3(125.38,40.13) 125.14,39.89 U29.1 U29.10 121.97,39.89 121.51,39.43 119.82,39.43 119.44,39.82 HDMI1.15
  BOTTOM w0.102: v3(130.72,31.75) 129.94,31.75 126.27,35.42 v2(126.27,38.89) 126.27,39.24 v3(125.38,40.13)
DDPB_CTRL_DATA_CONN: length 25.1
  TOP w0.102: HDMI1.16 119.26,40.32 119.92,39.66 121.41,39.66 122.12,40.37 U29.9 U29.2 124.86,40.37 v3(125.38,40.89) ; R2084.2 131.48,30.8 v3(131.48,31.75) 131.75,32.02 U118.33
  BOTTOM w0.102: v3(125.38,40.89) 124.92,40.44 124.92,39.67 125.64,38.96 v2(125.64,37.03) 125.89,36.78 125.89,35.3 129.9,31.29 131.02,31.29 v3(131.48,31.75)
DDR0_PAR: length 2.6
  TOP w0.102: CPU1.AT52 90.55,173.7 v4(90.25,173.4)
  BOTTOM w0.102: v4(90.25,173.4) 90.65,173.81 91.42,173.81 TP501.1
DDR1_PAR: length 3.5
  TOP w0.102: v4(89.62,168.83) 89.61,168.83 89.25,169.19 CPU1.AP43
  BOTTOM w0.102: TP9908.1 89.49,170.51 89.96,170.04 89.96,169.17 v4(89.62,168.83)
DDSP_B_HPD_CONN: length 21.6
  TOP w0.102: U118.28 129.21,34.56 v3(129.2,34.57) ; v3(128.74,39.37) 128.23,39.88 127.88,39.88 127.46,40.3 127.46,41.01 R80196.1 126.21,41.47 126.16,41.41 U29.4 U29.7 122.66,41.41 122.03,42.05 122.03,42.86 121.76,43.13 119.54,43.13 118.23,41.82 HDMI1.19
  BOTTOM w0.102: v3(128.74,39.37) 128.38,39.01 v2(128.38,35.69) 128.38,35.39 v3(129.2,34.57)
DET_HDMI#: length 154.5
  TOP w0.102: R5215.1 R5216.2 110.03,27.11 U5202.2 110.08,26.99 v3(109.38,26.29) ; v3(151.8,52.96) 150.91,52.96 v1(150.86,53.01) 150.86,53.52 151.6,54.26 Q5008.G ; v3(66.58,72.01) 67.42,72.85 67.42,73.61 67.71,73.9 SCA1.37
  L3 w0.127: v3(151.8,52.96) 151.04,52.2 151.04,40.48 144.25,33.69 129.88,33.69 129.65,33.47 128.63,33.47 127.35,34.74 127.35,35.75 126.69,36.41 123.79,36.41 123.13,35.75 123.13,35.37 123.22,35.28 123.22,26.8 122.25,25.82 109.85,25.82 v3(109.38,26.29) 108.24,27.43 101.89,27.43 101.13,28.19 101.13,30.72 95.92,35.93 95.92,44.05 89.8,50.16 84.99,50.16 81.95,53.21 81.95,54.23 77.57,58.61 77.57,67.43 75.28,69.72 73.57,69.72 72.42,70.87 69.63,70.87 68.99,71.5 67.22,71.5 66.71,72.01 v3(66.58,72.01)
DET_HDMI_C: length 21.1
  TOP w0.102: HDMI2.11 118.48,14.82 118.98,15.32 v3(118.98,15.88) ; v3(109.79,23.16) 109.79,23.89 107.9,25.78 107.32,25.78 107.09,26 R5215.2 v1(106.08,26.23)
  L3 w0.127: v3(118.98,15.88) 118.42,15.88 115.32,18.97 112.3,18.97 109.79,21.49 v3(109.79,23.16)
DGPU_EN: length 75.6
  TOP w0.102: v3(107.98,99.44) 107.6,99.82 PR8513.2 ; PR8515.2 121.31,80.7 105.19,80.7 v3(105.11,80.77)
  BOTTOM w0.102: PR8517.1 133.64,105.73 133.64,108.22 132.99,108.86 126.03,108.86 v2(123.94,106.78) 122.99,105.83 122.99,104.36 122.99,104.07 119.28,100.36 108.9,100.36 v3(107.98,99.44) 108.39,99.03 108.39,91.6 107.98,91.19 105.78,91.19 103.44,88.84 103.44,82.45 v3(105.11,80.77)
DGPU_HOLD_RST#: length 62.5
  TOP w0.089: CPU1.AB2 83.38,145.11 83.38,144.87 83.41,144.79 83.41,144.53 83.75,144.2 83.75,142.89 v4(83.35,142.49)
  TOP w0.102: D34.1 D34.2 105.76,111.52 v3(105.06,112.22) 103.27,112.22 R79921.1
  L4 w0.127: v4(83.35,142.49) 83.35,138.27 88.43,133.19 88.43,130.67 89.92,129.17 107.59,129.17 107.66,129.25 108.15,129.25 v3(108.62,128.78)
  BOTTOM w0.102: v3(105.06,112.22) 104.88,112.39 104.88,122.12 v2(107.88,125.12) 108.62,125.86 v3(108.62,128.78)
DGPU_PWR_ EN#: length 150.6
  TOP w0.089: CPU1.AB1 83.15,144.28 83.54,143.89 83.54,143.32 v4(83.35,143.13)
  TOP w0.102: v3(168.56,90.93) 168.56,91.5 R79922.1
  L3 w0.127: v3(168.56,90.93) 168.56,92.84 165.09,96.3 165.09,128.44 v3(165.01,128.52)
  L4 w0.127: v3(165.01,128.52) 163.24,126.75 160.91,126.75 150.78,116.61 140.74,116.61 137.67,113.54 137.59,113.54 127.28,113.54 111.19,129.63 107.5,129.63 107.43,129.55 90.08,129.55 88.81,130.82 88.81,133.35 83.76,138.39 83.76,142.71 v4(83.35,143.13)
  BOTTOM w0.102: D5206.K 167.67,88.01 168.56,88.9 v3(168.56,90.93) v2(168.56,91.77)
DGPU_PWROK: length 73.2
  TOP w0.102: PR6.2 135.22,105.28 v3(134.65,105.28) 134.65,104.81 133.83,103.99 133.04,103.99 132.46,103.4 132.06,103.4 131.88,103.22 U9.1 ; PR8505.1 103.79,69.98 v3(103.92,70.1)
  BOTTOM w0.102: v3(134.65,105.28) 134.2,105.74 134.2,108.16 133.14,109.22 125.66,109.22 122.64,106.2 122.64,104.21 119.64,101.22 v2(117.36,101.22) 116.36,101.22 115.85,100.71 108.61,100.71 105.06,97.17 105.06,90.97 103.08,88.99 103.08,70.8 103.78,70.1 v3(103.92,70.1)
DGPU_PWROK_S: length 106.2
  TOP w0.089: v4(83.14,143.73) 82.89,143.97 82.89,145.73 CPU1.AB3
  TOP w0.102: v3(105.44,70.13) 106.18,70.13 106.84,69.47 PR8518.1
  L4 w0.127: v4(83.14,143.73) 82.93,143.52 82.93,138.15 88.04,133.03 88.04,130.51 89.77,128.78 v3(107.86,128.78)
  BOTTOM w0.102: v3(107.86,128.78) 108.16,128.47 108.16,126.21 v2(105.51,123.56) 104.53,122.58 104.53,111.31 107.02,108.82 107.02,101.54 104.71,99.22 104.71,91.11 102.73,89.13 102.73,70.65 103.73,69.65 104.96,69.65 v3(105.44,70.13)
DIMM_TMPIN2+: length 164.2
  TOP w0.127: U109.86 139.01,50.08 v3(139.35,50.42) ; v3(149.26,97.92) 149.51,97.66 149.77,97.66 150.03,97.93 150.03,101.93 150.62,102.52 150.62,107.99 149.02,109.59 145.62,109.59 137.85,117.36 132.98,117.36 128.74,121.6 118.35,121.6 117,122.95 117,151.51 105.54,162.97 105.54,168.54 104.67,169.42 103.78,169.42 103.46,169.1 RT1.1
  BOTTOM w0.127: v2(148.62,87.63) 148.28,87.63 ; 148.28,87.63 148.28,53.53 145.95,51.19 140.13,51.19 v3(139.35,50.42) 139.54,50.23 C231.2 139.73,49.26 R397.1 ; 148.28,87.63 148.28,89.85 150.02,91.59 150.02,97.39 149.74,97.66 149.51,97.66 v3(149.26,97.92)
DIMM_TMPIN2-: length 163.3
  TOP w0.127: v3(149.26,97.16) 149.51,97.41 149.87,97.41 150.29,97.82 150.29,101.83 150.87,102.41 150.87,108.09 149.12,109.84 145.72,109.84 137.95,117.61 133.09,117.61 128.84,121.86 118.45,121.86 117.25,123.05 117.25,151.62 105.8,163.07 105.8,168.65 104.77,169.67 103.78,169.67 103.46,169.99 RT1.2
  BOTTOM w0.127: v3(149.26,97.16) 149.51,97.41 149.64,97.41 149.77,97.28 149.77,91.69 148.03,89.95 148.03,89.51 ; 148.03,89.51 148.03,53.63 145.84,51.45 139.72,51.45 138.88,50.61 138.88,49.68 C231.1 138.64,49.44 138.64,48.58 R399.2 ; 148.03,89.51 v2(147.73,89.51)
DISP_UTIL_CPU: length 157.9
  TOP w0.102: R79778.2 45.37,55.94 45.37,59.05 44.36,60.07 44.36,63.5 43.47,64.39 43.47,65.41 v3(43.59,65.53) ; CPU1.B52 72.07,173.85 71.59,173.85 70.52,172.78 69.18,172.78 68.66,172.26 66.15,172.26 64.45,170.56 61.69,170.56 58.55,167.43 58.55,161.9 56.6,159.94 49.51,159.94 v3(49.06,160.4)
  L3 w0.127: v3(36.61,128.52) 36.06,127.98 36.06,127.57 32.86,124.37 32.86,83.1 34.41,81.55 34.41,79.57 35.88,78.11 41.33,78.11 43.34,76.09 43.34,65.79 v3(43.59,65.53)
  BOTTOM w0.102: v3(36.61,128.52) 36.61,128.89 37.07,129.35 37.07,129.37 38.3,130.61 43.22,130.61 v2(45.23,132.62) 47.02,134.41 47.02,137.95 49.82,140.74 49.82,142.47 51,143.65 51,158.46 v3(49.06,160.4)
DP_AUXN: length 3.3
  TOP w0.102: TP73.1 121.06,208.91 120.81,209.17 120.3,209.17 119.83,209.64 119.64,209.64 119.5,209.5 NGFF1.20
DP_AUXN_C: length 14.4
  TOP w0.102: R9530.1 64.52,50.74 64.38,50.6 64.38,50.08 65.6,48.86 65.97,48.86 ; C12175.2 74.84,50.74 74.44,50.74 74.12,50.42 74.12,49.12 73.86,48.86 65.97,48.86 ; 65.97,48.86 v1(65.97,49.23)
DP_AUXP: length 3.2
  TOP w0.102: TP72.1 120.94,209.51 120.81,209.38 120.39,209.38 119.92,209.86 119.64,209.86 119.5,210 NGFF1.22
DP_AUXP_C: length 14.4
  TOP w0.102: C12176.2 74.8,50.52 74.53,50.52 74.34,50.33 74.34,49.03 73.95,48.64 65.51,48.64 64.52,49.63 ; 64.52,49.63 64.17,49.99 64.17,50.5 63.94,50.72 63.93,50.72 R9527.1 ; 64.52,49.63 v1(64.27,49.38)
DP_HPD: length 2.7
  TOP w0.102: NGFF1.31 109.16,212.25 TP78.1
DP_LANE0N_C: length 6.2
  TOP w0.102: C12180.2 71.94,61.05 71.66,61.05 70.95,61.76 70.17,61.76 70.03,61.9 SCA1.13 v3(67.57,61.9)
  BOTTOM w0.102: v3(67.57,61.9) 68.13,61.9 v2(68.36,61.67)
DP_LANE0P_C: length 4.2
  TOP w0.102: 71.24,61.17 71.57,60.83 72.11,60.83 C12179.2 ; 71.24,61.17 v1(70.98,60.91) ; 71.24,61.17 70.86,61.54 70.17,61.54 70.03,61.4 SCA1.12
DP_LANE1N_C: length 6
  TOP w0.102: v3(67.57,62.76) 67.71,62.9 SCA1.15 70.03,62.9 70.17,62.76 71.3,62.76 71.47,62.93 72.04,62.93 C12182.2
  BOTTOM w0.102: v2(68.37,62.9) 68.24,62.76 v3(67.57,62.76)
DP_LANE1P_C: length 4
  TOP w0.102: 71.33,62.54 70.17,62.54 70.03,62.4 SCA1.14 ; 71.33,62.54 v1(71.33,62.18) ; 71.33,62.54 71.39,62.54 71.56,62.71 72,62.71 C12181.2
DP_LANE2N_C: length 4.3
  TOP w0.102: C12373.2 72.02,64.69 71.33,64.69 ; SCA1.17 69.74,63.9 69.88,63.76 70.34,63.76 71.27,64.69 71.33,64.69 ; v1(71.33,65.05) 71.33,64.69
DP_LANE2P_C: length 4.4
  TOP w0.102: 70.87,63.98 70.43,63.54 69.88,63.54 69.74,63.4 SCA1.16 ; 70.87,63.98 v1(71.18,63.68) ; 70.87,63.98 71.36,64.47 72.02,64.47 C12371.2
DP_LANE3N_C: length 5.7
  TOP w0.102: C12374.2 72.12,67.32 71.34,67.32 ; SCA1.19 69.74,64.9 69.88,64.76 70.01,64.76 70.31,65.06 70.31,66.29 71.34,67.32 ; 71.34,67.32 v1(71.34,67.69)
DP_LANE3P_C: length 5.7
  TOP w0.102: SCA1.18 69.75,64.4 69.89,64.54 70.1,64.54 70.52,64.97 70.52,66.2 70.9,66.57 ; C12372.2 71.93,67.11 71.43,67.11 70.9,66.57 ; 70.9,66.57 v1(71.15,66.32)
DP_ML0N: length 3.2
  TOP w0.102: NGFF1.32 119.5,212.5 119.64,212.64 119.74,212.64 120.52,211.86 120.81,211.86 120.94,211.74 TP69.1
DP_ML0P: length 3.5
  TOP w0.102: NGFF1.34 119.5,213 119.64,212.86 119.83,212.86 120.61,212.08 120.81,212.08 120.94,212.21 TP68.1
DP_ML1N: length 4.4
  TOP w0.102: NGFF1.26 119.5,211 119.64,211.14 119.98,211.14 120.56,210.57 121.85,210.57 122.21,210.21 TP71.1
DP_ML1P: length 4.4
  TOP w0.102: TP70.1 122.21,211.14 121.85,210.78 120.65,210.78 120.07,211.36 119.64,211.36 119.5,211.5 NGFF1.28
DP_ML2N: length 4.1
  TOP w0.102: NGFF1.25 109.5,210.75 109.36,210.89 109.2,210.89 108.66,210.35 107.39,210.35 TP76.1
DP_ML2P: length 4.2
  TOP w0.102: TP77.1 106.97,211.18 107.58,210.57 108.57,210.57 109.11,211.11 109.36,211.11 109.5,211.25 NGFF1.27
DP_ML3N: length 2.6
  TOP w0.102: TP74.1 108.95,209.25 NGFF1.19
DP_ML3P: length 2.7
  TOP w0.102: NGFF1.21 109.15,209.75 108.8,209.4 108.64,209.4 TP75.1
DPLL_PVDD: length 6.3
  TOP w0.356: GPU1.AF14 90.86,97.94 v4(90.86,97.64)
  BOTTOM w0.508: L52.2 C830.1 93.7,96.39 C827.1 92.72,96.46 C829.1 91.92,96.46 v2(91.52,96.86) 90.86,97.51 v4(90.86,97.64)
DPLL_VDDC: length 8.3
  TOP w0.356: GPU1.AD14 89,98.06 v4(89.38,97.68)
  BOTTOM w0.508: L53.2 91.24,93.75 89.55,93.75 89.19,94.11 C828.1 89.12,94.81 C825.1 C826.1 89.12,97.42 v4(89.38,97.68) 89.59,97.89 v2(89.59,98.4)
DPLVDS_BL_EN: length 133
  TOP w0.102: U109.54 128.14,54.57 v3(127.67,54.1) ; v3(66.58,56.01) 66.62,55.96 SCA1.126
  L3 w0.127: v3(51.98,53.72) 51.98,52.79 47.91,48.72 47.91,45.59 48.37,45.14 48.37,41.93 45.63,39.19 v3(45.63,29.59)
  L4 w0.127: v3(66.58,56.01) 66.58,55.97 ; 66.58,55.97 65.73,55.12 53.37,55.12 v3(51.98,53.72) ; 66.58,55.97 67.81,54.74 74.33,54.74 74.67,54.39 75.47,54.39 76.61,55.54 76.61,56.9 77.46,57.75 81.02,57.75 84.87,61.59 87.28,61.59 87.54,61.6 87.85,61.91 91.12,61.91 91.63,62.42 95.64,62.42 95.99,62.06 97.76,62.06 99.31,60.52 100.15,60.52 101.99,58.67 107.62,58.67 110.76,55.54 111.54,55.54 112.05,55.03 112.05,52.07 112.47,51.65 117.72,51.65 121.19,55.12 121.91,55.12 122.33,55.54 126.23,55.54 v3(127.67,54.1)
  BOTTOM w0.102: v3(45.63,29.59) 46.13,29.08 46.13,27.53 v2(46.39,27.28) 47.15,26.52 47.15,24.61 46.49,23.95 46.02,23.95 R1985.2 ; R9528.1 64.04,54.91 65.59,56.46 66.12,56.46 v3(66.58,56.01) ; v3(127.67,54.1) 128.05,53.72 R280.1
DPLVDS_HPD: length 4.5
  TOP w0.102: SCA1.110 58.62,53.03 59.15,52.5 59.45,52.5 60,51.96 v1(60,51.87) 59.75,51.63 R79925.1
DPLVDS_PANEL_VCC: length 62.8
  TOP w0.102: R39.2 44.1,121.16 v3(44.36,121.41) ; v3(59.47,74.29) 59.47,74.67 59.62,74.83 SCA1.55
  L3 w0.127: v3(59.47,74.29) 59.09,74.67 59.09,77.51 57.43,79.17 54.48,79.17 53.95,79.17 52.73,80.39 50.96,80.39 50.71,80.64 50.71,81.03 44.44,87.29 44.44,89.25 42.27,91.42 42.27,113.58 43.59,114.9 43.59,120.65 v3(44.36,121.41)
  BOTTOM w0.102: v2(58.96,75.31) 58.58,74.93 R9545.1 59.41,74.23 v3(59.47,74.29)
DPLVDS_PWMIN: length 3.8
  TOP w0.165: R79778.1 R79777.1 47.21,56.26 v1(48.17,56.26) 48.56,56.66 Q9614.1
DPLVDS_PWMOUT: length 40.7
  TOP w0.165: v3(46.52,25.53) 46.52,26.16 45.83,26.85 v1(45.12,26.85) R1984.2 ; SCA1.103 53.03,54.53 52.21,55.36 Q9614.4 51.21,55.05 v3(51.21,54.61)
  L3 w0.165: v3(51.21,54.61) 51.21,52.59 47.51,48.89 47.51,45.43 47.97,44.97 47.97,42.09 45.12,39.24 45.12,26.92 v3(46.52,25.53)
DQMA0: length 39.2
  TOP w0.127: v1(71.36,114.07) 71.36,113.31 v4(72.34,112.32) 72.43,112.32 73.47,111.28 73.47,111.13 GPU1.E32
  L3 w0.165: v4(54.9,115.49) 55.13,115.25 55.13,115.19 55.35,114.97 55.35,114.67 55.22,114.54 55.22,114.54 54.91,114.23 54.39,114.23 54.18,114.43 54.18,115.47 54.06,115.6 53.09,115.6 52.96,115.47 52.96,114.64 52.84,114.51 52.53,114.51 52.41,114.39 52.41,113.06 52.53,112.93 52.89,112.93 53.02,113.06 53.02,113.82 53.14,113.95 53.8,113.95 54.11,113.64 54.84,113.64 55.09,113.4 55.09,113.3 55.34,113.04 55.37,113.04 55.39,113.02 56,113.02 57.39,111.63 57.7,111.63 58.15,111.17 58.78,111.17 59.07,111.46 59.67,111.46 59.97,111.16 60.55,111.16 60.79,111.4 62.07,111.4 62.62,110.85 68.92,110.85 69.25,111.18 69.5,111.18 70.13,111.82 70.57,111.82 70.95,111.43 70.95,111.18 71.07,111.05 71.81,111.05 71.94,111.18 71.94,111.91 v4(72.34,112.32)
  BOTTOM w0.127: v4(54.9,115.49) 54.73,115.49 54.34,115.09 54.34,114.8 MEM3.E7 ; v2(71.15,112.52) 71.36,112.32 v4(72.34,112.32)
DQMA1: length 35.6
  TOP w0.127: v4(71.71,109.55) 71.79,109.63 73.43,109.63 GPU1.E30
  BOTTOM w0.127: MEM3.D3 57.21,115.57 56.86,115.92 56.86,116.18 56.02,117.03 55.31,117.03 55.05,116.78 55.05,116.39 54.38,115.71 53.79,115.71 53.61,115.89 53.61,117.16 53.76,117.32 54.16,117.32 54.44,117.59 54.44,118.28 54.26,118.47 54.26,119.16 55.03,119.93 60.67,119.93 64.55,116.05 64.55,113.21 66.28,111.48 v2(66.28,111.48) 66.28,111.48 67.39,110.37 69.73,110.37 70,110.11 70,109.87 70.31,109.55 v4(71.71,109.55)
DQMA2: length 36.1
  TOP w0.102: 57.59,115.17 57.37,114.95 57.08,114.95 56.72,115.31 56.72,115.68 56.39,116.01
  TOP w0.127: MEM1.D3 54.01,115.52 54.49,116 54.49,116.31 55.2,117.01 55.66,117.01 56.21,116.47 56.21,116.19 56.39,116.01 ; GPU1.A21 72.17,103.57 62.48,103.57 v1(62.32,103.73) 62.32,113.51 62.82,114.01 62.82,115.01 62.49,115.34 62.14,115.34 62.02,115.22 62.02,114.36 61.89,114.23 61.64,114.23 61.51,114.36 61.51,115.22 61.38,115.34 61.13,115.34 61,115.22 61,114.84 60.87,114.71 60.62,114.71 60.49,114.84 60.49,115.22 60.37,115.34 59.24,115.34 58.96,115.62 57.87,115.62 57.59,115.34 57.59,115.17
DQMA3: length 36.2
  TOP w0.127: v4(69.98,102.93) 70.4,103.34 71.11,103.34 71.28,103.18 72.58,103.18 GPU1.C21 ; MEM1.E7 57.21,114.5 56.13,115.59 v4(56.13,115.62)
  L4 w0.165: v4(56.13,115.62) 56.13,116.07 56.38,116.33 58.21,116.33 58.55,116.67 59.1,116.67 59.44,116.33 60.04,116.33 60.43,116.72 61.06,116.72 61.45,116.33 62.02,116.33 66.01,112.34 66.01,111.74 65.62,111.35 65.62,111.17 65.94,110.85 66.12,110.85 66.66,111.4 66.9,111.4 67.13,111.16 67.13,110.93 66.56,110.36 66.56,110.18 66.85,109.89 67.03,109.89 67.27,110.14 67.56,110.14 67.72,109.97 67.72,108.2 69.24,106.68 69.4,106.68 69.98,106.1 69.98,105.69 69.88,105.59 69.53,105.59 69.4,105.47 69.4,105.05 69.56,104.88 70.45,104.88 70.62,104.72 70.62,104.35 70.45,104.19 69.61,104.19 69.45,104.02 69.45,103.69 69.61,103.53 69.82,103.53 69.98,103.36 v4(69.98,102.93)
  BOTTOM w0.127: v4(69.98,102.93) 70.41,103.35 71.1,103.35 v2(71.33,103.58)
DQMA4: length 35.6
  TOP w0.102: GPU1.E13 73.53,97.2 73.2,96.87 72.93,96.87 72.78,96.93 72.42,96.93 72.27,96.87 72.11,96.87 71.88,97.01 71.28,97.01 71.14,96.87 70.84,96.87 v4(70.67,96.7)
  L4 w0.165: v4(70.67,96.7) 69.98,96.7 69.69,96.99 67.17,96.99 66.58,96.4 66.58,89.84 62.19,85.45 58.96,85.45 58.76,85.65 58.76,86.35 58.63,86.48 58.21,86.48 58.08,86.35 58.08,85.67 57.86,85.45 56.77,85.45 56.35,85.87 56.35,86.46 v4(55.52,87.29)
  BOTTOM w0.127: v2(70.85,95.94) 70.67,96.11 v4(70.67,96.7) ; v4(55.52,87.29) 55.44,87.29 55.05,87.68 55.05,87.86 55.27,88.09 55.45,88.09 55.58,87.96 56.06,87.96 56.25,87.77 56.25,87.6 56.38,87.47 56.68,87.47 56.81,87.6 56.81,88.64 56.99,88.82 MEM4.E7
DQMA5: length 36.8
  TOP w0.102: GPU1.D12 73.1,96.4 72.9,96.6 72.72,96.73 72.57,96.73 72.53,96.72 72.33,96.68 72.31,96.67 72.05,96.67 71.82,96.81 71.37,96.81 71.09,96.53
  TOP w0.127: 71.09,96.53 71.09,96.53 70.83,96.27 69.8,96.27 68.89,95.36 66.27,95.36 65.69,95.93 65.69,97.93 64.9,98.72 64.33,98.72 64.2,98.59 64.2,97.76 64.08,97.63 63.82,97.63 63.7,97.76 63.7,98.59 63.57,98.72 63.31,98.72 63.19,98.59 63.19,97.76 63.06,97.63 62.81,97.63 62.68,97.76 62.68,98.59 62.55,98.72 62.3,98.72 62.17,98.59 62.17,97.76 62.04,97.63 61.79,97.63 61.66,97.76 61.66,98.59 61.54,98.72 v1(61.19,98.72) 60.52,98.72 59.28,97.48 59.28,96.64 59.97,95.95 59.97,95.31 60.25,95.03 60.25,91.48 60.73,91 60.73,89.45 60.3,89.02 59.99,89.02 59.22,88.24 59.22,87.94 58.96,87.68 57.56,87.68 MEM2.D3
DQMA6: length 30.6
  TOP w0.127: v4(73.41,89.6) 73.8,89.99 GPU1.E3 ; v4(56.31,88.4) 56.32,88.41 56.69,88.41 56.85,88.25 56.85,88.1 56.59,87.84 56.06,87.84 55.88,88.02 55.22,88.02 54.64,87.44 54.48,87.44 54.28,87.64 54.28,87.77 54.58,88.06 54.58,88.23 54.47,88.33 54.47,88.57 54.23,88.82 MEM2.E7
  L3 w0.165: v4(73.41,89.6) 72.94,89.13 72.12,89.13 72.11,89.13 69.61,89.13 69.45,88.96 69.45,88.55 69.28,88.38 68.95,88.38 68.79,88.55 68.79,88.96 68.62,89.13 68.23,89.13 68.06,88.96 68.06,87.84 67,86.77 66.38,86.77 66.21,86.61 66.21,86.42 66.05,86.25 65.72,86.25 65.55,86.42 65.55,86.61 65.39,86.77 65.05,86.77 64.89,86.61 64.89,86.42 64.72,86.25 64.39,86.25 64.23,86.42 64.23,86.61 64.06,86.77 63.73,86.77 63.57,86.61 63.57,86.42 63.4,86.25 63.07,86.25 62.91,86.42 62.91,86.61 62.74,86.77 62.36,86.77 62.13,86.54 62.13,86.37 61.97,86.2 60.05,86.2 59.99,86.14 59.62,86.14 59.37,86.4 59.37,86.67 58.54,87.5 56.92,87.5 56.31,88.12 v4(56.31,88.4)
  BOTTOM w0.127: v4(73.41,89.6) 72.43,89.6 v2(72.42,89.6)
DQMA7: length 31.9
  TOP w0.127: v4(74.55,88.88) 74.23,89.21 74.23,90.08 74.54,90.4 GPU1.F4
  BOTTOM w0.127: v4(74.55,88.88) 74.98,89.3 76.32,89.3 76.69,88.94 76.69,88.52 76.32,88.15 76.32,87.9 74.51,86.09 68.05,86.09 66.1,84.14 62.69,84.14 v2(62.49,83.94) 62.25,83.7 60.25,83.7 59.75,84.21 56.89,84.21 55.08,86.01 55.08,86.66 54.26,87.48 54.26,87.77 MEM4.D3
DRAM_RST: length 21.8
  TOP w0.102: v3(86.52,80.39) 86.08,79.95 C839.1 R1205.1 R80082.1 ; v4(79.48,95.05) 79.05,95.05 GPU1.L10
  BOTTOM w0.102: v4(79.48,95.05) 79.1,94.67 79.1,93.65 80.88,91.88 80.88,90.62 81.08,90.41 81.08,90.14 81.85,89.38 v2(81.85,88.19) 81.85,87.6 84.74,84.71 84.74,82.42 86.52,80.64 v3(86.52,80.39)
DRAM_RST_R: length 2.8
  TOP w0.102: R80082.2 C762.1 82.58,78.36 82.96,77.98 R1891.1
EAPD_DEPOP: length 36.9
  TOP w0.203: U6.14 160.79,72.55 159.98,71.73 v3(159.98,70.08)
  L3 w0.203: v3(152.18,45.21) 152.69,44.7 152.69,42.93 v3(152.18,42.42)
  BOTTOM w0.203: v3(152.18,42.42) 152.69,41.91 152.69,40.83 R393.1 ; v3(159.98,70.08) 158.78,68.88 158.78,67.46 157.31,65.99 157.31,65.5 155.48,63.67 155.48,49.07 154.63,48.22 154.63,47.66 v2(153.72,46.76) v3(152.18,45.21)
EAPD_DEPOP_1: length 8.2
  BOTTOM w0.102: R391.1 160.52,41.4 R394.1 159.05,39.93 154.92,39.93 v2(154.8,39.8) 154.48,39.8 R393.2
EAPD_DEPOP_2: length 3.8
  BOTTOM w0.254: R394.2 158.92,40.69 v2(158.3,40.69) 157.77,41.22 157.77,41.66 157.51,41.91 Q9622.5
EAPD_DEPOP_2_D: length 3.1
  BOTTOM w0.102: R79871.2 163.05,43.07 Q9627.6 162.65,42.05 162.24,42.47 v2(161.63,42.47)
EC_3P3_CTL: length 5.8
  BOTTOM w0.152: PR8521.2 102.71,67.69 101.32,67.69 C6724.2 99.82,67.37 v2(99.8,67.39) 99.28,67.91 Q9648.G
EC_3P3_CTL_2: length 8.8
  BOTTOM w0.152: C6725.1 92.43,65.91 R80229.2 91.54,65.98 90.2,64.64 v2(89.47,64.64) 89.06,64.64 86.62,62.2 Q9649.G
EC_3P3_CTL_3: length 5.2
  BOTTOM w0.152: R80229.1 92.43,66.93 R80228.1 93.44,67.63 93.89,68.07 v2(94.34,68.07) 95.28,68.07 95.85,67.5 Q9648.D
EC_HDMI_PD_N: length 32
  TOP w0.102: U109.105 146.25,53.77 146.41,53.93 146.89,53.93 147.48,53.34 149.16,53.34 149.28,53.21 149.65,53.21 150.5,52.36 v1(150.5,51.36) 150.3,51.16 150.3,47.73 150.38,47.66 150.38,44.98 150.5,44.86 150.5,41.89 148.62,40.01 148.48,40.01 148.12,39.64 148.12,35.6 145.51,33 R2091.2 144.15,32.51 Q1249.G
EC_LAN_DISABLE_N: length 123
  TOP w0.102: v3(42.83,11.18) 42.39,10.73 42.39,8.83 41.88,8.32 R1194.1 ; v3(126.91,52.83) 127.41,53.34 127.92,53.34 128.29,52.97 U109.58
  L4 w0.127: v3(124.37,35.56) 123.86,36.07 123.02,36.07 122.64,35.69 118.69,35.69 116.95,33.95 114.92,33.95 105.45,24.47 87.26,24.47 86.45,23.67 69.76,23.67 68.96,24.47 63.75,24.47 57.43,18.15 48,18.15 45.37,15.52 45.37,13.84 42.83,11.3 v3(42.83,11.18)
  BOTTOM w0.102: R79938.1 127.99,53.34 127.41,53.34 v3(126.91,52.83) 126.45,52.37 126.45,50 126.6,49.85 v2(126.6,48.44) 126.6,44.78 122.38,40.56 122.38,37.54 v3(124.37,35.56)
EC_PECI: length 236.8
  TOP w0.102: R79990.2 62.81,171.04 61.49,171.04 58.07,167.63 58.07,162.1 56.5,160.53 49.94,160.53 v3(49.82,160.4)
  L3 w0.127: v3(127.41,55.75) 127.41,55.99 130.7,59.28 131,59.28 136.77,65.06 136.77,67.15 141.13,71.51 141.13,78.99 142.65,80.52 142.65,88.28 143.48,89.11 143.48,104.68 138.27,109.89 126.82,109.89 124.9,107.98 118.85,107.98 117.62,109.21 107.36,109.21 v3(106.97,109.6)
  L4 w0.127: v3(40.42,129.29) 40.44,129.29 44.27,125.46 45.97,125.46 64.64,125.46 66.81,127.64 70.42,127.64 71.37,127.64 82.8,116.2 104.13,116.2 107.44,112.9 107.44,110.07 v3(106.97,109.6)
  BOTTOM w0.102: v3(40.42,129.29) 41.1,129.97 44.8,129.97 v2(44.93,130.1) 47.51,132.68 47.51,137.75 50.3,140.54 50.3,142.27 51.48,143.45 51.48,158.74 v3(49.82,160.4) ; v3(127.41,55.75) 127.41,55.82 R79739.2
EC_PROCHOT#: length 132.8
  TOP w0.102: v3(96.05,59.69) 96.21,59.86 U4101.14 ; Q9641.G R80166.2 R80154.1 147.42,70.17 146.49,69.24 144.18,69.24 143.6,68.67 142.95,68.67 140.62,66.34 140.62,65.66 140.21,65.25 U109.8 140.21,62.86 140.19,62.84 140.19,55.68 v3(140.24,55.63)
  L4 w0.127: v3(140.24,55.63) 139.77,56.1 137,56.1 136.72,55.82 136.72,53.22 133.45,49.95 130.34,49.95 130.16,50.13 122.98,50.13 122.54,49.7 102.75,49.7 97.15,55.3 97.15,58.59 v3(96.05,59.69) 96.05,60.17 95.25,60.97 91.98,60.97 91.65,60.64 88.51,60.64 88.11,60.24 87.18,60.24 82.8,55.85 82.8,51.01 80.24,48.45 61.31,48.45 v3(57.31,44.45)
  BOTTOM w0.102: v3(57.31,44.45) v2(56.09,45.67) 55.61,46.15 54.05,46.15 53.31,45.4 PQ4405.D
EC_PWREN: length 55.8
  TOP w0.102: U109.57 128.23,53.37 128.03,53.57 126.37,53.57 v1(126.3,53.49) 126.02,53.21 R321.1 R79936.2 125.64,52.2 v3(126.02,52.58)
  L3 w0.127: v3(97.57,61.59) 97.57,59.69 98.46,58.8 99.73,58.8 101.33,57.2 101.33,51.84 103.51,49.66 115.89,49.66 118.65,52.42 118.65,54.36 119.29,54.99 123.6,54.99 v3(126.02,52.58)
  BOTTOM w0.102: v3(97.57,61.59) 97.57,61.85 102.2,66.48 PR8521.1
EC_SCI: length 3.5
  TOP w0.102: U4101.15 99.06,60.26 v1(99.23,60.08) 99.24,60.07 99.6,60.07 100.43,59.25 R79709.1
EC_SCI#: length 122.9
  TOP w0.102: v3(96.81,61.59) 97.32,61.09 98.46,61.09 98.76,60.78 99.32,60.78 100.26,59.84 101.1,59.84 101.32,59.63 R79709.2 ; v4(79.13,149.68) 78.91,149.68 CPU1.N9
  L3 w0.127: v3(96.81,61.59) 93.63,64.77 v3(93.63,71.37)
  BOTTOM w0.102: v3(93.63,71.37) 97.34,71.37 v2(97.92,71.96) 98.43,72.47 98.43,80.05 97.77,80.71 97.77,86.82 102.67,91.72 102.67,112.57 101.91,113.33 98.45,113.33 93.14,118.64 83.81,118.64 77.22,125.23 77.22,125.88 75.95,127.15 75.95,128.95 75.01,129.89 75.01,134.89 76.03,135.9 76.03,138.42 R803.1 76.61,139 76.61,144.02 78.32,145.73 78.32,147.34 78.54,147.55 78.54,148.5 78.8,148.76 78.8,149.34 v4(79.13,149.68)
EC_SMB2_CLK: length 60.7
  TOP w0.102: R80209.1 121.02,49.78 120.28,50.53 120.28,51.33 v3(120.18,51.44) ; U4101.32 88.22,61.9 86.32,59.99 85.3,59.99 85.25,59.94 83.03,59.94 PR8519.2 81.76,59.5 v3(81.69,59.44)
  L3 w0.127: v3(81.69,59.44) 83.38,57.75 88.13,57.75 88.96,58.57 96.72,58.57 97.25,58.04 99.37,58.04 100.55,56.86 100.55,51.53 103.19,48.9 116.21,48.9 118.62,51.31 120.05,51.31 v3(120.18,51.44)
  BOTTOM w0.102: v3(81.69,59.44) v2(80.86,59.44)
EC_SMB2_DATA: length 52.6
  TOP w0.102: R80208.1 120.81,52.83 v3(120.18,52.2) ; U4101.33 87.61,60.66 86.39,59.44 v1(86.14,59.44) v3(84.49,59.44) 84.42,59.5 PR8520.2
  L3 w0.127: v3(120.18,52.2) 119.67,51.69 118.46,51.69 116.05,49.28 103.35,49.28 100.95,51.68 100.95,57 99.53,58.42 97.41,58.42 96.88,58.95 88.8,58.95 87.97,58.13 85.8,58.13 v3(84.49,59.44)
