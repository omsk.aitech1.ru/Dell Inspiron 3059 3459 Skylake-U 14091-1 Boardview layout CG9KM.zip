# Allegro board 14091-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R79705  10KR2F-2-GP  [R402H16]  84.49 56.9 0 top
R79706  10KR2F-2-GP  [R402H16]  86.52 56.9 180 top
R79709  0R2J-2-GP  [R402H16]  100.87 59.18 90 top
R79710  0R2J-2-GP  [R402H16]  100.87 58.17 270 top
R79711  0R2J-2-GP  [R402H16]  94.37 49.89 180 top
R79712  0R2J-2-GP  [R402H16]  91.35 64.72 90 top
R79713  0R2J-2-GP  [R402H16]  90.58 50.16 180 top
R79720  100KR2F-L1-GP  [R402H16]  88.12 50.55 90 top
R79721  47KR2F-GP  [R402H16]  88.12 49.53 270 top
R79722  100KR2F-L1-GP  [R402H16]  89.06 51.64 270 top
R79723  200KR2F-L-GP  [R402H16]  89.57 49.28 180 top
R79726  10KR5F-2-GP  [R805H24]  30.39 21.84 90 bottom
R79739  43D2R2F-GP  [R402H16]  128.3 56.26 0 bottom
R79755  100KR2J-1-GP  [R402H16]  78.14 51.56 0 top
R79756  100KR2J-1-GP  [R402H16]  77.12 49.66 0 top
R79759  10KR2J-3-GP  [R402H16]  106.97 131.32 180 bottom
R79760  10KR2J-3-GP  [R402H16]  106.97 129.41 180 bottom
R79761  10KR2J-3-GP  [R402H16]  106.46 137.41 90 bottom
R79762  10KR2J-3-GP  [R402H16]  106.46 136.4 90 bottom
R79763  10KR2J-3-GP  [R402H16]  106.46 135.38 90 bottom
R79764  10KR2J-3-GP  [R402H16]  109.13 140.46 90 bottom
R79777  0R0402-PAD-2-GP  [0R0402-PAD-1]  46.64 56.13 270 top
R79778  0R2J-2-GP  [R402H16]  46.64 55.12 270 top
R79789  0R2J-2-GP  [R402H16]  73.19 71.75 90 bottom
R79790  -  [0R0402-PAD]  60.1 75.82 180 bottom
R79791  -  [0R0402-PAD]  70.77 79.5 270 top
R79792  -  [0R0402-PAD]  66.84 80.64 270 top
R79797  10KR2J-3-GP  [R402H16]  72.42 69.34 0 top
R79798  10KR2J-3-GP  [R402H16]  73.57 69.34 180 top
R79799  10KR2J-3-GP  [R402H16]  74.96 72.77 0 top
R79800  10KR2J-3-GP  [R402H16]  73.57 71.25 0 top
R79801  10KR2J-3-GP  [R402H16]  72.42 71.25 180 top
R79802  10KR2J-3-GP  [R402H16]  75.98 72.77 180 top
R79806  10KR2J-3-GP  [R402H16]  52.61 79.88 270 bottom
R79809  0R2J-2-GP  [R402H16]  75.73 69.47 270 bottom
R79810  -  [0R0805-PAD]  59.22 66.04 180 bottom
R79812  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  153.83 62.2 90 top
R79813  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  163.23 63.12 270 top
R79814  -  [0R0402-PAD]  148.24 50.8 270 top
R79815  -  [0R0402-PAD]  148.24 51.82 270 top
R79816  -  [0R0402-PAD]  148.24 52.83 270 top
R79817  -  [0R0402-PAD]  77 72.77 180 top
R79818  -  [0R0402-PAD]  75.73 69.88 180 top
R79819  -  [0R0402-PAD]  76.77 69.88 180 top
R79820  10KR2J-3-GP  [R402H16]  141.51 70.61 180 top
R79824  0R0402-PAD-2-GP  [0R0402-PAD-1]  152.69 51.31 90 top
R79825  0R0402-PAD-2-GP  [0R0402-PAD-1]  155.48 55.63 90 top
R79832  0R2J-2-GP  [R402H16]  53.96 54.53 270 bottom
R79834  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  163.23 61.95 90 top
R79835  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  153.83 61.04 270 top
R79836  1KR2J-1-GP  [R402H16]  136.94 65.02 90 bottom
R79837  0R2J-2-GP  [R402H16]  132.44 47.57 90 bottom
R79838  10KR2J-3-GP  [R402H16]  80.3 49.15 90 top
R79840  6K2R2F-GP  [R402H16]  178.47 143.15 0 bottom
R79841  -  [0R0402-PAD]  174.02 135 270 bottom
R79842  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  175.29 153.16 90 bottom
R79843  -  [0R0402-PAD]  172.12 135 270 bottom
R79844  -  [0R0402-PAD]  169.07 138.94 90 bottom
R79845  -  [0R0402-PAD]  169.07 139.95 90 bottom
R79846  -  [0R0402-PAD]  170.09 141.48 180 bottom
R79847  -  [0R0402-PAD]  169.58 143.89 90 bottom
R79848  -  [0R0402-PAD]  169.58 144.91 90 bottom
R79849  -  [0R0402-PAD]  169.45 147.83 90 bottom
R79850  10KR2J-3-GP  [R402H16]  175.17 152.02 90 bottom
R79851  -  [0R0402-PAD]  177.33 150.5 0 bottom
R79855  0R2J-2-GP  [R402H16]  148.24 48.77 270 top
R79859  -  [0R0402-PAD]  148.24 53.85 270 top
R79860  -  [0R0402-PAD]  148.24 54.86 270 top
R79866  10KR2J-3-GP  [R402H16]  56.04 52.07 0 bottom
R79868  10KR2J-3-GP  [R402H16]  60.99 53.72 180 bottom
R79871  0R2J-2-GP  [R402H16]  162.97 43.43 270 bottom
R79872  0R2J-2-GP  [R402H16]  148.24 57.15 270 top
R79873  0R0402-PAD-2-GP  [0R0402-PAD-1]  148.24 58.17 270 top
R79919  0R2J-2-GP  [R402H16]  164.88 43.43 270 bottom
R79920  0R2J-2-GP  [R402H16]  161.2 39.88 270 bottom
R79921  1KR2J-1-GP  [R402H16]  102.01 113.03 270 top
R79922  1KR2J-1-GP  [R402H16]  168.82 92.2 180 top
R79923  -  [0R0402-PAD]  52.61 78.87 90 bottom
R79924  -  [0R0402-PAD]  52.61 78.74 270 top
R79925  1KR2J-1-GP  [R402H16]  58.96 51.18 0 top
R79926  100KR2J-1-GP  [R402H16]  57.95 51.18 180 top
R79927  10KR2F-2-GP  [R402H16]  75.73 70.48 270 bottom
R79928  0R2J-2-GP  [R402H16]  132.6 69.42 0 top
R79929  0R0402-PAD-2-GP  [0R0402-PAD-1]  123.22 48.01 0 top
R79930  100R2F-L1-GP-U  [R402H14]  130.84 49.02 0 bottom
R79931  10KR2J-3-GP  [R402H16]  149.64 66.17 0 top
R79932  1KR2J-1-GP  [R402H16]  136.94 64.01 90 bottom
R79933  10KR2J-3-GP  [R402H16]  134.4 64.52 0 bottom
R79934  4K7R2F-GP  [R402H16]  148.5 78.23 180 top
R79935  10KR2J-3-GP  [R402H16]  148.62 68.07 0 top
R79936  10KR2F-2-GP  [R402H16]  124.72 52.2 90 top
R79937  17K8R2F-GP  [R402H16]  140.75 42.8 90 top
R79938  10KR2J-3-GP  [R402H16]  129.07 52.7 270 bottom
R79939  10KR2F-2-GP  [R402H16]  140.75 45.77 90 top
R79940  10KR2J-3-GP  [R402H16]  134.78 55.5 180 bottom
R79942  -  [0R0402-PAD]  145.58 70.61 180 top
R79943  0R0402-PAD-2-GP  [0R0402-PAD-1]  122.08 62.1 90 top
R79944  100KR2J-1-GP  [R402H16]  128.43 58.93 0 bottom
R79945  -  [0R0402-PAD]  136.69 45.34 0 top
R79946  10KR2J-3-GP  [R402H16]  148.19 61.34 90 top
R79947  10KR2J-3-GP  [R402H16]  148.19 62.36 90 top
R79977  -  [0R0402-PAD]  61.63 131.7 270 top
R79978  -  [0R0402-PAD]  61.27 127.13 90 top
R79979  1KR2J-1-GP  [R402H16]  142.58 84.3 270 top
R79980  1KR2J-1-GP  [R402H16]  61.37 134.75 270 top
R79981  1KR2J-1-GP  [R402H16]  61.27 128.14 90 top
R79982  3D3R3F-GP  [R603H22]  153.32 36.58 270 top
R79983  3D3R3F-GP  [R603H22]  155.99 36.58 90 top
R79984  20KR2J-L2-GP  [R402H16]  161.07 44.45 270 bottom
R79985  3D3R3F-GP  [R603H22]  162.09 36.58 90 top
R79986  3D3R3F-GP  [R603H22]  159.42 36.58 270 top
R79987  3K9R2F-GP  [R402H16]  163.66 54.61 0 top
R79988  5K6R2F-2-GP  [R402H16]  159.6 54.58 0 top
R79989  20KR2J-L2-GP  [R402H16]  156.37 51.94 0 bottom
R79990  -  [0R0402-PAD]  64.17 171.96 270 top
R79991  1KR2J-1-GP  [R402H16]  153.07 121.03 270 top
R79996  51R2J-2-GP  [R402H16]  63.53 173.99 180 top
R79997  51R2J-2-GP  [R402H16]  65.69 177.8 180 top
R79998  51R2J-2-GP  [R402H16]  64.68 173.99 180 top
R79999  51R2J-2-GP  [R402H16]  66.33 175.77 270 top
R80000  51R2J-2-GP  [R402H16]  65.69 179.71 180 top
R80001  1KR2J-1-GP  [R402H16]  67.85 176.91 270 top
R80002  51R2J-2-GP  [R402H16]  66.33 174.5 270 top
R80003  51R2J-2-GP  [R402H16]  67.98 179.96 270 top
R80004  51R2J-2-GP  [R402H16]  70.52 178.44 0 bottom
R80005  51R2J-2-GP  [R402H16]  67.85 178.56 270 top
R80006  49D9R2F-GP  [R402H16]  96.68 154.81 0 bottom
R80007  49D9R2F-GP  [R402H16]  95.16 152.91 270 bottom
R80008  49D9R2F-GP  [R402H16]  72.55 180.34 90 bottom
R80009  49D9R2F-GP  [R402H16]  76.87 181.36 180 bottom
R80010  0R2J-2-GP  [R402H16]  81.31 196.85 180 bottom
R80011  100R2J-2-GP  [R402H14]  84.23 177.42 180 bottom
R80012  100R2J-2-GP  [R402H14]  83.35 179.71 270 bottom
R80013  100R2J-2-GP  [R402H14]  86.77 179.32 0 bottom
R80014  100R2J-2-GP  [R402H14]  85.25 177.42 180 bottom
R80015  100R2F-L1-GP-U  [R402H14]  71.92 164.47 270 bottom
R80016  100R2F-L1-GP-U  [R402H14]  76.87 190.5 0 top
R80017  100R2F-L1-GP-U  [R402H14]  71.92 163.45 270 bottom
R80018  100R2F-L1-GP-U  [R402H14]  77.76 188.98 90 top
R80019  100R2J-2-GP  [R402H14]  82.91 159.31 90 bottom
R80020  100R2J-2-GP  [R402H14]  87.41 159.89 180 bottom
R80021  100R2J-2-GP  [R402H14]  76.46 158.88 90 bottom
R80022  100R2J-2-GP  [R402H14]  73.44 159.77 180 bottom
R80023  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  40.8 141.6 180 bottom
R80024  0R3J-0-U-GP  [R603H22]  40.8 138.81 180 bottom
R80025  0R3J-0-U-GP  [R603H22]  42.07 141.6 180 bottom
R80026  -  [0R0402-PAD]  93.89 159.51 180 bottom
R80027  100R2F-L1-GP-U  [R402H14]  67.42 184.66 0 top
R80028  54D9R2F-L1-GP  [R402H16]  64.68 185.42 0 top
R80029  56R2J-4-GP  [R402H16]  67.42 182.63 180 top
R80030  220R2J-L2-GP  [R402H16]  68.44 182.63 180 top
R80031  0R0402-PAD-2-GP  [0R0402-PAD-1]  68.44 184.66 180 top
R80032  0R0402-PAD-2-GP  [0R0402-PAD-1]  65.69 184.53 0 top
R80033  10KR2J-3-GP  [R402H16]  66.96 139.45 90 top
R80034  10KR2J-3-GP  [R402H16]  106.46 150.11 90 bottom
R80035  20KR2J-L2-GP  [R402H16]  93.51 128.27 0 bottom
R80036  10KR2J-3-GP  [R402H16]  105.47 122.2 270 top
R80037  1KR2J-1-GP  [R402H16]  102.52 152.53 270 top
R80038  1MR2J-1-GP  [R402H16]  108.75 137.79 180 bottom
R80039  10KR2J-3-GP  [R402H16]  100.62 128.65 180 top
R80040  0R3J-0-U-GP  [R603H22]  106.13 119.76 180 top
R80041  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  104.94 119.76 180 top
R80042  10KR2J-3-GP  [R402H16]  71.79 189.87 180 top
R80043  1KR2J-1-GP  [R402H16]  70.26 192.15 90 top
R80044  60D4R2F-GP  [R402H16]  69.5 189.87 0 top
R80045  0R0402-PAD-2-GP  [0R0402-PAD-1]  109.63 122.3 180 top
R80046  3KR2J-2-GP  [R402H16]  70.65 141.43 270 top
R80047  0R2J-2-GP  [R402H16]  102.52 158.5 270 top
R80048  -  [0R0402-PAD]  100.36 152.15 90 top
R80049  10KR2J-3-GP  [R402H16]  105.47 123.22 270 top
R80051  100KR2J-1-GP  [R402H16]  106.33 125.91 270 bottom
R80052  -  [0R0402-PAD]  106.33 127.89 270 bottom
R80053  -  [0R0805-PAD]  54.39 140.72 0 top
R80054  10KR2J-3-GP  [R402H16]  108.49 124.08 0 top
R80055  0R2J-2-GP  [R402H16]  106.08 151.76 0 bottom
R80056  4K7R2J-2-GP  [R402H16]  107.6 153.16 270 bottom
R80057  20KR2F-L-GP  [R402H16]  109.13 151.64 180 bottom
R80058  4K7R2J-2-GP  [R402H16]  109.38 108.33 270 top
R80059  20KR2F-L-GP  [R402H16]  107.6 154.18 90 bottom
R80060  1MR2J-1-GP  [R402H16]  65.82 159.84 90 top
R80061  10MR2J-L-GP  [R402H16]  89.57 131.95 180 top
R80062  33R2J-2-GP  [R402H16]  102.06 154.25 90 top
R80063  2K7R2F-GP  [R402H16]  75.29 167.03 90 bottom
R80064  -  [0R0402-PAD]  106.46 140.46 270 bottom
R80065  -  [0R0402-PAD]  105.95 131.32 180 bottom
R80066  -  [0R0402-PAD]  105.95 129.41 180 bottom
R80067  8K2R2F-1-GP  [R402H16]  106.46 138.43 270 bottom
R80072  22R2J-2-GP  [R402H16]  103.03 136.78 180 top
R80073  22R2J-2-GP  [R402H16]  103.03 133.6 180 top
R80074  470R2F-GP  [R402H16]  106.46 149.1 90 bottom
R80075  0R2J-2-GP  [R402H16]  106.46 148.08 270 bottom
R80076  121R2F-GP  [R402H16]  93.51 156.21 270 bottom
R80077  100R2F-L1-GP-U  [R402H14]  95.16 153.92 270 bottom
R80078  80D6R2F-L-GP  [R402H16]  95.16 154.94 270 bottom
R80080  10KR2J-3-GP  [R402H16]  100.11 143.38 270 top
R80081  120R2F-GP  [R402H16]  79.79 110.11 180 bottom
R80082  10R2F-L-GP  [R402H14]  83.6 79.5 0 top
R80083  8K45R2F-2-GP  [R402H16]  99.22 96.77 0 top
R80084  2KR2F-3-GP  [R402H16]  98.2 96.77 0 top
R80085  2K2R2J-2-GP  [R402H16]  94.01 83.06 90 top
R80086  10KR2J-L-GP  [R402H15]  82.08 82.04 90 top
R80087  2K1R2F-GP  [R402H16]  49.31 96.14 180 top
R80088  2K1R2F-GP  [R402H16]  48.29 97.66 90 top
R80089  40D2R2F-GP  [R402H16]  48.67 112.27 270 top
R80090  40D2R2F-GP  [R402H16]  48.9 93.09 270 top
R80091  8K2R2J-3-GP  [R402H16]  168.44 93.73 90 top
R80092  100KR2J-1-GP  [R402H16]  167.8 92.2 180 top
R80100  -  [0R0402-PAD]  157.77 104.78 270 top
R80101  -  [0R0402-PAD]  157.77 103.76 270 top
R80102  15KR2F-GP  [R402H16]  91.35 21.34 180 top
R80103  10KR2J-3-GP  [R402H16]  90.84 19.81 270 top
R80104  1KR2J-1-GP  [R402H16]  95.54 6.48 180 top
R80107  20KR2F-L-GP  [R402H16]  160.56 99.69 180 bottom
R80108  0R2J-2-GP  [R402H16]  157.77 105.79 90 bottom
R80109  10KR2J-3-GP  [R402H16]  160.43 109.22 0 bottom
R80110  0R2J-2-GP  [R402H16]  163.74 109.22 0 bottom
R80111  0R2J-2-GP  [R402H16]  162.72 109.22 0 bottom
R80112  0R2J-2-GP  [R402H16]  161.58 109.22 0 bottom
R80113  0R2J-2-GP  [R402H16]  165.9 101.09 270 bottom
R80114  33KR2F-GP  [R402H16]  162.59 100.2 270 bottom
R80115  0R2J-2-GP  [R402H16]  157.77 104.78 90 bottom
R80116  0R2J-2-GP  [R402H16]  157.77 103.76 90 bottom
R80117  10KR2F-2-GP  [R402H16]  79.54 212.72 270 bottom
R80118  10KR2F-2-GP  [R402H16]  79.54 211.71 270 bottom
R80126  10KR2J-3-GP  [R402H16]  23.3 139.95 180 top
R80127  10KR2J-3-GP  [R402H16]  22.28 139.95 180 top
R80128  0R2J-2-GP  [R402H16]  85.25 179.68 90 bottom
R80129  0R2J-2-GP  [R402H16]  85.5 170.69 270 bottom
R80130  0R0402-PAD-2-GP  [0R0402-PAD-1]  129.07 60.58 270 bottom
R80131  -  [0R0402-PAD]  124.62 61.47 0 top
R80132  10KR2J-3-GP  [R402H16]  75.09 140.97 0 top
R80133  10KR2J-3-GP  [R402H16]  67.34 143.38 0 top
R80134  10KR2J-3-GP  [R402H16]  68.36 143.38 0 top
R80137  0R2J-2-GP  [R402H16]  45.75 105.79 180 top
R80140  10KR2J-3-GP  [R402H16]  12.35 181.23 180 top
R80141  10KR2J-3-GP  [R402H16]  13.37 184.15 0 top
R80144  -  [0R0402-PAD]  19.85 187.78 270 top
R80145  10KR2J-3-GP  [R402H16]  12.45 176.68 0 top
R80146  10KR2J-3-GP  [R402H16]  23.66 188.09 0 top
R80147  1KR2J-1-GP  [R402H16]  19.85 188.8 90 top
R80148  1KR2J-1-GP  [R402H16]  13.5 179.2 0 top
R80149  -  [0R0402-PAD]  150.53 74.04 180 top
R80150  0R0402-PAD-2-GP  [0R0402-PAD-1]  152.05 74.55 90 top
R80151  100KR2J-1-GP  [R402H16]  113.44 58.55 0 top
R80154  1KR2J-1-GP  [R402H16]  147.61 70.61 180 top
R80158  10KR2J-3-GP  [R402H16]  76.26 219.71 180 top
R80159  10KR2J-3-GP  [R402H16]  21.24 140.21 0 top
R80160  10KR2J-3-GP  [R402H16]  34.32 137.79 90 top
R80162  0R2J-2-GP  [R402H16]  80.81 207.39 90 top
R80163  1KR2J-1-GP  [R402H16]  70.77 189.1 180 top
R80165  100KR2J-1-GP  [R402H16]  144.56 70.61 180 top
R80166  0R2J-2-GP  [R402H16]  148.62 70.61 0 top
R80167  10KR2J-3-GP  [R402H16]  144.41 58.42 180 bottom
R80168  10KR2J-3-GP  [R402H16]  145.42 58.42 180 bottom
R80170  10KR2J-3-GP  [R402H16]  52.61 76.45 90 bottom
R80171  0R2J-2-GP  [R402H16]  123.6 20.19 180 bottom
R80172  0R2J-2-GP  [R402H16]  124.24 20.07 270 top
R80173  1KR2J-1-GP  [R402H16]  68.36 81.66 90 top
R80174  10KR2F-2-GP  [R402H16]  165.39 61.65 0 top
R80175  -  [0R0402-PAD]  158.15 59.66 180 top
R80177  10KR2J-3-GP  [R402H16]  88.17 140.16 180 top
R80178  10KR2J-3-GP  [R402H16]  80.93 124.84 315 bottom
R80179  10KR2J-3-GP  [R402H16]  77.76 125.73 90 top
R80180  10KR2J-3-GP  [R402H16]  66.58 133.48 180 top
R80181  10KR2J-3-GP  [R402H16]  67.6 133.48 0 top
R80183  -  [0R0402-PAD]  100.87 53.85 90 top
R80186  -  [0R0402-PAD]  75.22 127.76 270 top
R80187  -  [0R0402-PAD]  77.63 127.13 270 top
R80188  -  [0R0402-PAD]  77.88 139.19 270 top
R80189  -  [0R0402-PAD]  178.6 151.64 180 bottom
R80191  0R2J-2-GP  [R402H16]  101.63 129.54 180 top
R80192  -  [0R0402-PAD]  136.43 70.61 0 top
R80193  0R2J-2-GP  [R402H16]  144.56 50.55 270 bottom
R80194  2K2R2J-2-GP  [R402H16]  135.42 29.46 90 top
R80195  2K2R2J-2-GP  [R402H16]  135.42 30.99 90 top
R80196  100KR2J-1-GP  [R402H16]  127.92 41.02 0 top
R80197  100KR2J-1-GP  [R402H16]  113.44 23.62 270 top
R80200  10KR2J-3-GP  [R402H16]  12.35 184.15 0 top
R80201  4K7R2J-2-GP  [R402H16]  28.86 13.87 180 top
R80202  4K7R2J-2-GP  [R402H16]  27.85 13.87 180 top
R80203  0R2J-2-GP  [R402H16]  144.64 55.17 180 bottom
R80204  0R2J-2-GP  [R402H16]  145.65 55.17 180 bottom
R80205  0R2J-2-GP  [R402H16]  122.21 53.85 90 top
R80206  0R2J-2-GP  [R402H16]  143.09 56.64 0 bottom
R80207  0R2J-2-GP  [R402H16]  92.24 52.96 270 bottom
R80208  0R2J-2-GP  [R402H16]  122.21 52.83 90 top
R80209  0R2J-2-GP  [R402H16]  122.21 49.78 90 top
R80210  -  [0R0402-PAD]  148.24 49.78 270 top
R80211  10KR2J-3-GP  [R402H16]  89.31 56.52 90 bottom
R80212  22R2J-2-GP  [R402H16]  106.46 139.45 90 bottom
R80215  15KR2F-GP  [R402H16]  148.24 47.75 270 bottom
R80216  10KR2F-2-GP  [R402H16]  148.24 48.77 90 bottom
R80217  10KR2J-3-GP  [R402H16]  143.29 65.02 270 bottom
R80218  10KR2J-3-GP  [R402H16]  143.29 64.01 90 bottom
R80219  10KR2J-3-GP  [R402H16]  99.98 137.67 0 top
R80220  0R2J-2-GP  [R402H16]  87.54 53.34 0 bottom
R80221  0R2J-2-GP  [R402H16]  93.76 56.01 180 bottom
R80222  0R2J-2-GP  [R402H16]  94.78 56.01 180 bottom
R80223  100KR2J-1-GP  [R402H16]  34.7 42.55 0 top
R80224  10KR2J-3-GP  [R402H16]  89.31 55.5 270 bottom
R80225  10KR2J-3-GP  [R402H16]  91.09 58.29 180 bottom
R80226  10KR2J-3-GP  [R402H16]  92.11 58.29 180 bottom
R80227  0R0402-PAD-2-GP  [0R0402-PAD-1]  59.72 78.74 270 bottom
R80228  8K2R2J-3-GP  [R402H16]  93.89 66.93 270 bottom
R80229  39K2R2F-L-GP  [R402H16]  92.36 66.42 180 bottom
R80230  0R3J-0-U-GP  [R603H22]  89.7 61.98 180 bottom
R80231  10KR2J-3-GP  [R402H16]  94.65 62.36 90 bottom
R80232  1K8R2F-GP  [R402H16]  15.15 156.21 270 top
R80233  10KR2F-2-GP  [R402H16]  18.07 158.37 90 top
R80234  5K6R2F-2-GP  [R402H16]  15.15 155.19 90 top
R80235  10KR2F-2-GP  [R402H16]  18.07 159.38 90 top
R80236  -  [0R0402-PAD]  15.02 161.54 270 top
R80237  0R0402-PAD-2-GP  [0R0402-PAD-1]  164.5 37.47 0 top
R80238  100KR2F-L1-GP  [R402H16]  117.51 25.53 180 top
R80239  10KR2J-3-GP  [R402H16]  41.69 102.62 90 bottom
R80240  0R2J-2-GP  [R402H16]  57.06 51.18 180 bottom
R80241  1KR2F-3-GP  [R402H16]  38.26 10.34 90 top
R80242  1K5R2F-2-GP  [R402H16]  68.41 50.6 90 top
R80243  10KR2J-3-GP  [R402H16]  159.16 167.51 0 top
R80244  10KR2J-3-GP  [R402H16]  163.36 170.43 90 top
R80245  10KR2J-3-GP  [R402H16]  163.36 169.42 90 top
R80246  10KR2J-3-GP  [R402H16]  158.15 172.72 0 top
R80247  10KR2J-3-GP  [R402H16]  159.42 177.55 90 top
R80248  10KR2J-3-GP  [R402H16]  170.72 153.92 0 bottom
R80250  10KR2F-2-GP  [R402H16]  145.45 43.69 270 top
R80251  10KR2F-2-GP  [R402H16]  145.45 41.4 90 top
R80252  10KR2J-3-GP  [R402H16]  75.09 219.71 180 top
R80253  10KR2J-3-GP  [R402H16]  79.41 222.38 90 top
R80254  10KR2F-2-GP  [R402H16]  140.37 84.33 90 top
R80255  100KR2J-1-GP  [R402H16]  145.7 36.83 270 top
R80256  0R2J-2-GP  [R402H16]  82.2 221.62 270 top
R80257  100KR2J-1-GP  [R402H16]  138.21 30.61 90 top
RJ1  RJ45-8P-199-GP  [23-01120-2A03-A]  76.92 21.04 180 top
RN1  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  124.75 58.42 270 bottom
RN2  SRN33J-7-GP-U  [ARES8-CN24-UH20]  145.19 61.47 0 bottom
RN3  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  134.78 44.07 180 top
RN5  SRN10KJ-5-GP  [ARES2H18]  128.43 50.16 270 bottom
RN6  SRN10KJ-5-GP  [ARES2H18]  133.13 53.34 270 bottom
RN7  SRN10KJ-5-GP  [ARES2H18]  121.7 55.37 90 top
RN16  SRN2K2J-1-GP  [ARES2H16]  99.98 88.77 270 top
RN1807  SRN2K2J-4-GP  [ARES8-CN24-UH20]  81.82 140.97 0 top
RN4301  SRN33J-7-GP-U  [ARES8-CN24-UH20]  32.16 58.55 270 bottom
RN9503  SRN4K7J-10-GP  [ARES8-CN24H20]  58.96 71.25 270 bottom
RN9504  SRN10KJ-5-GP  [ARES2H18]  102.52 156.46 180 top
RT1  NTC-10K-19-GP-U  [NTC-402H22-U]  103.03 169.54 180 top
RT2  NTC-10K-19-GP-U  [NTC-402H22-U]  90.97 85.98 270 top
RT3  NTC-10K-19-GP-U  [NTC-402H22-U]  39.53 174.12 270 top
RV1  P4500SCLHLRP-GP  [TVS5436-1121H105]  65.06 18.16 0 top
SATAP1  CLX-CON5-18-GP-U  [CI2505P1H00-LF-U]  12 195 270 top
SCA1  RTD2586HD-CG-GP  [TQFP128H63]  61.37 65.15 270 top
SPK1  JWT-CON6-20-GP  [A1501WV0-6PS-5E]  155.8 32.38 180 top
SRCON1  SKT-SPI8P-GP-U1  [SKT-SOIC8-092117H235]  49.8 128.78 270 top
SSUSB1  SKT-USB11-112-GP-U  [SKT-USB11-138165-1]  176.12 116.84 90 top
SSUSB2  SKT-USB11-112-GP-U  [SKT-USB11-138165-1]  176.12 95.34 90 top
TC1  ST330U2D5VDM-9GP  [CT7343H75]  146.97 205.1 180 top
TC5  ST100U6D3VBM-7GP  [CT3528H79]  15.91 201.52 180 top
TC8  E100U16VM-108-GP-U  [ECAP-100D6D3H237]  167.04 125.48 0 top
TC23  E100U16VM-108-GP-U  [ECAP-100D6D3H237]  91.09 14.35 90 top
TOUCH1  ENT-CON5-GP  [3703K-Q05N-11L]  24.7 8.5 270 top
TP38  -  [TPAD28]  122.21 215.26 0 top
TP39  -  [TPAD28]  123.5 215.14 0 top
TP62  -  [TPAD28]  106.97 208.53 0 top
TP63  -  [TPAD28]  120.68 206.63 0 top
TP64  -  [TPAD28]  122.33 208.53 0 top
TP65  -  [TPAD28]  123.48 213.87 0 top
TP66  -  [TPAD28]  120.94 214 0 top
TP67  -  [TPAD28]  122.21 214 0 top
TP68  -  [TPAD28]  120.94 212.72 0 top
TP69  -  [TPAD28]  120.94 211.46 0 top
TP70  -  [TPAD28]  122.21 211.33 0 top
TP71  -  [TPAD28]  122.21 210.06 0 top
TP72  -  [TPAD28]  120.94 209.93 0 top
TP73  -  [TPAD28]  121.06 208.66 0 top
TP74  -  [TPAD28]  108.24 208.53 0 top
TP75  -  [TPAD28]  108.24 209.8 0 top
TP76  -  [TPAD28]  106.97 209.93 90 top
TP77  -  [TPAD28]  106.97 211.2 90 top
TP78  -  [TPAD28]  108.24 211.33 90 top
TP79  -  [TPAD28]  108.36 219.33 270 top
TP80  -  [TPAD28]  108.36 220.6 90 top
TP81  -  [TPAD28]  106.97 222 90 top
TP82  -  [TPAD28]  108.24 222 90 top
TP83  -  [TPAD28]  106.97 223.52 90 top
TP84  -  [TPAD28]  108.24 223.52 90 top
TP103  -  [TPAD28]  146.59 60.66 0 top
TP104  -  [TPAD28]  146.62 61.87 0 top
TP107  -  [TPAD28]  146.21 42.55 0 top
TP108  -  [TPAD28]  144.76 84.23 90 bottom
TP109  -  [TPAD28]  155.61 51.31 0 top
TP149  -  [TPAD28]  83.95 86.89 0 top
TP150  -  [TPAD28]  85.25 86.87 0 top
TP155  -  [TPAD28]  81.29 85.7 0 top
TP158  -  [TPAD28]  81.9 90.17 180 bottom
TP159  -  [TPAD28]  88.3 97.79 180 bottom
TP163  -  [TPAD28]  98.46 90.55 0 top
TP164  -  [TPAD28]  97.19 90.55 0 top
TP165  -  [TPAD28]  99.73 90.55 0 top
TP196  -  [TPAD28]  120.94 215.26 0 top
TP203  -  [TPAD28]  129.5 94.92 180 top
TP204  -  [TPAD28]  132.49 105.03 0 top
TP205  -  [TPAD28]  178.47 150.11 90 bottom
TP208  -  [TPAD28]  127.67 220.6 0 top
TP401  -  [TPAD28]  73.19 179.2 180 bottom
TP402  -  [TPAD28]  71.92 191.52 0 top
TP501  -  [TPAD28]  91.88 174.27 180 bottom
TP601  -  [TPAD28]  100.87 189.1 0 top
TP602  -  [TPAD28]  102.14 189.1 0 top
TP603  -  [TPAD28]  102.9 187.96 0 top
TP604  -  [TPAD28]  101.51 187.96 0 top
TP605  -  [TPAD28]  87.41 155.7 180 bottom
TP606  -  [TPAD28]  85.76 154.56 180 bottom
TP607  -  [TPAD28]  101.76 131.83 0 top
TP608  -  [TPAD28]  91.8 147.7 180 bottom
TP609  -  [TPAD28]  101.76 134.75 0 top
TP610  -  [TPAD28]  100.62 133.86 0 top
TP611  -  [TPAD28]  99.98 135 0 top
TP612  -  [TPAD28]  73.69 181.86 180 bottom
TP613  -  [TPAD28]  72.42 181.48 180 bottom
TP701  -  [TPAD28]  77.17 162.48 180 bottom
TP702  -  [TPAD28]  85.53 162.66 180 bottom
TP1704  -  [TPAD28]  93.66 152.4 180 bottom
TP1708  -  [TPAD28]  86.09 153.29 180 bottom
TP1804  -  [TPAD28]  81.44 138.94 0 top
TP1805  -  [TPAD28]  80.22 138.94 0 top
TP1901  -  [TPAD28]  96.5 148.46 0 top
TP1902  -  [TPAD28]  97.7 146.86 0 top
TP2011  -  [TPAD28]  89.06 146.81 180 bottom
TP2012  -  [TPAD28]  90.58 146.81 180 bottom
TP2016  -  [TPAD28]  80.68 144.91 180 bottom
TP2017  -  [TPAD28]  80.42 143.64 180 bottom
TP2101  -  [TPAD28]  86.75 149.17 180 bottom
TP2102  -  [TPAD28]  87.36 153.21 180 bottom
TP4124  -  [TPAD28]  93 64.64 90 top
TP4125  -  [TPAD28]  94.27 64.64 180 top
TP4126  -  [TPAD28]  101.38 61.47 180 top
TP4127  -  [TPAD28]  93 61.47 0 bottom
TP4128  -  [TPAD28]  91.73 61.47 0 bottom
TP4129  -  [TPAD28]  97.57 62.74 0 bottom
TP4130  -  [TPAD28]  96.3 62.87 0 bottom
TP9901  -  [TPAD28]  21.52 212.09 0 top
TP9902  -  [TPAD28]  69.5 173.61 0 top
TP9903  -  [TPAD28]  69.5 175.13 0 top
TP9904  -  [TPAD28]  80.68 146.18 180 bottom
TP9905  -  [TPAD28]  82.2 150.62 180 bottom
TP9908  -  [TPAD28]  89.49 171.4 180 bottom
TP9910  -  [TPAD28]  171.48 151.38 180 bottom
TP9911  -  [TPAD28]  171.48 150.11 180 bottom
TP9912  -  [TPAD28]  167.93 148.59 180 bottom
TP9913  -  [TPAD28]  168.84 149.58 180 bottom
TP9914  -  [TPAD28]  166.91 106.81 0 bottom
TP9915  -  [TPAD28]  98.33 154.05 0 top
TP9916  -  [TPAD28]  87.07 154.46 180 bottom
TP9917  -  [TPAD28]  135.03 49.4 180 bottom
TP9918  -  [TPAD28]  99.86 144.53 0 top
TP9919  -  [TPAD28]  78.9 145.67 180 bottom
TR1  FILTER-4P-184-GP  [L125100-4P-4H28]  164.5 191.9 90 top
TR3  FILTER-4P-184-GP  [L125100-4P-4H28]  167.93 107.06 0 top
TR4  FILTER-4P-184-GP  [L125100-4P-4H28]  167.93 104.78 0 bottom
TR5  FILTER-4P-184-GP  [L125100-4P-4H28]  107.6 36.2 270 top
TR7  FILTER-4P-184-GP  [L125100-4P-4H28]  105.44 36.2 270 top
TR9  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  31.66 13.21 90 top
TR12  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  109.13 199.64 270 top
TR16  FILTER-4P-120-GP  [L125100-4P-1H28]  126.78 32.27 0 top
TR17  FILTER-4P-120-GP  [L125100-4P-1H28]  126.78 34.43 0 top
TR18  FILTER-4P-120-GP  [L125100-4P-1H28]  126.78 36.71 0 top
TR19  FILTER-4P-120-GP  [L125100-4P-1H28]  126.78 38.87 0 top
TR5201  DLM11SN900HY2L-GP  [L125100-4P-4H24]  105.57 8.89 270 top
TR5202  DLM11SN900HY2L-GP  [L125100-4P-4H24]  105.57 18.67 270 top
TR5203  DLM11SN900HY2L-GP  [L125100-4P-4H24]  107.73 8.89 270 top
TR5204  DLM11SN900HY2L-GP  [L125100-4P-4H24]  107.73 18.67 270 top
TR5205  FILTER-4P-184-GP  [L125100-4P-4H28]  167.93 104.78 0 top
U1  AO6402A-GP  [SOT-6-1H50]  38.39 110.36 90 bottom
U3  AZ1045-04F-R7G-GP  [DFN10G2510H26]  167.93 115.19 270 top
U5  AZ1045-04F-R7G-GP  [DFN10G2510H26]  167.8 96.14 270 top
U6  ALC3661-CG-GP  [QFN48J6-G465H40]  162.59 76.45 90 top
U9  ISL62882CHRTZ-T-GP  [QFN40-G3D5H32]  130.08 100.33 0 top
U10  AZ1215-04S-R7G-GP  [SOT-6H58]  47.58 11.94 270 top
U11  AZ1215-04S-R7G-GP  [SOT-6H58]  47.58 11.94 270 bottom
U12  AZ1215-04S-R7G-GP  [SOT-6H58]  78.01 28.83 90 top
U14  RTS5250S-GR-GP-U  [QFN32J4-G2D85H36]  174.79 145.54 90 bottom
U16  RTL8111G-CGT-1-GP-U2  [QFN32J4-G2D85H36]  37.88 14.86 270 top
U28  AZ1045-04F-R7G-GP  [DFN10G2510H26]  123.48 33.78 270 top
U29  AZ1045-04F-R7G-GP  [DFN10G2510H26]  123.48 40.89 270 top
U49  PM25LD010C-SCE-1-GP  [SOIC8H69]  89.19 90.81 90 bottom
U52  AP22966DC8-7-GP  [SON14J3020-G2610H32]  127.03 7.37 270 top
U54  AP22966DC8-7-GP  [SON14J3020-G2610H32]  147.35 8.51 270 bottom
U105  AO6402A-GP  [SOT-6-1H50]  83.22 199.9 270 bottom
U109  IT8739E-GP  [LQFP128H63]  136.81 56.77 0 top
U110  AO4407AL-GP  [SOIC8H69]  64.93 30.2 0 top
U118  PS8407ATQFN40GTR2-A1-GP  [QFN40J5-G3D65H32]  132.75 35.56 270 top
U119  AZ1117CR-ADJTRG1-GP-U  [SOT-89-4541-3PH63]  138.84 33.78 180 bottom
U120  OZ554ALN-B-0-TR-GP  [QFN20-G2D1H32]  36.23 26.42 90 bottom
U501  74AUP1G07GW-GP  [SC70-5H44]  82.46 219.33 270 top
U704  AOZ1334DI-01-GP  [DFN8F3-G2517H32]  39.02 139.57 0 top
U706  AOZ1334DI-01-GP  [DFN8F3-G2517H32]  49.56 141.48 0 top
U4101  NPCE948LA0DX-GP  [LQFP64H63]  93.12 57.66 270 top
U5201  M24C02-WMN6TP-1-GP  [SOIC8H69]  124.87 24.26 180 top
U5202  AZ23C6V2-1-GP  [SOT-23-9H44]  111.03 26.16 180 top
U5203  AZ23C6V2-1-GP  [SOT-23-9H44]  117.23 16 270 bottom
U6701  KXCNL-1010-GP  [LGA16G3-1H40]  86.01 65.46 0 top
U6706  AZ1045-04F-R7G-GP  [DFN10G2510H26]  123.48 37.36 90 top
U9501  PM25LD020C-SCE-GP  [SOIC8H69]  77.76 60.83 180 top
U9502  M24C16-WMN6TP-1-GP  [SOIC8H69]  66.33 71.12 270 bottom
U9601  LD1117AG-12-AA3-A-R-GP  [SOT-223H71]  59.47 60.33 90 bottom
U9602  MX25L5121EMC-20G-GP  [SOIC8H69]  138.97 56.13 180 bottom
U9615  TS5A22364DGSR-1-GP  [MSOP10H44]  158.53 62.74 270 top
U9624  W25Q128FVSIQ-GP  [SOIC8-1H86]  49.82 128.78 90 top
U9625  TPA3131D2RHBR-GP-U  [QFN32-G3D55H40]  159.8 48.9 0 top
U9626  74LVC1G07GW-GP  [SC70-5H44]  66.45 190.12 90 top
U9628  TPS2546RTER-GP  [QFN16-G1D8-UH32]  162.34 104.27 270 bottom
UHS1  AUDIO-JK500-GP  [2SJ3082-038111F]  176.5 75.29 90 top
UR5  330R2F-GP  [R402H16]  82.56 26.29 0 top
UR6  330R2F-GP  [R402H16]  70.9 27.43 0 top
UR7  330R2F-GP  [R402H16]  72.42 27.3 270 top
USB3  SKT-USB6-174-GP  [SKT-USB6-135063]  98.35 37.03 90 top
USB4  SKT-USB6-174-GP  [SKT-USB6-135063]  98.38 14.03 90 top
WEBCM1  JWT-CON8-4-GP  [A1251WR0-8PS-5E]  160.12 201.1 180 top
X4  XTAL-25MHZ-181-GP  [OSC-3225-4P-4H36]  36.74 6.73 0 top
X9502  XTAL-14D31818MHZ-37-GP  [OSC-3225-4P-3H36]  72.47 51.44 90 top
X9503  XTAL-24MHZ-126-GP  [OSC-3225-4P-4H36]  62.14 157.99 270 top
X9504  XTAL-32D768KHZ-67-GP  [SMD49-6914-0403H56]  95.54 131.95 0 top
X9505  XTAL-27MHZ-85-GP-U  [OSC-3225-4P-4H30]  100.87 110.11 90 top
XDP1  STC-CONN60A-GP-U1  [QSH-030-01-FDAK]  27.08 217.93 0 top
XF1  XFORM-12P-48-GP  [XFORM12A127097H91]  56.29 11.94 90 top
XF2  XFORM-12P-48-GP  [XFORM12A127097H91]  56.29 11.94 270 bottom

## Library data of the parts
AFTP1 TP38 TP39 TP62-TP84 TP103 TP104 TP107-TP109 TP149 TP150 TP155 TP158 TP159 TP163-TP165 TP196 TP203-TP205 TP208 TP401 TP402 TP501 TP601-TP613 TP701 TP702 TP1704 TP1708 TP1804 TP1805 TP1901 TP1902 TP2011 TP2012 TP2016 TP2017 TP2101 TP2102 TP4124-TP4130 TP9901-TP9905 TP9908 TP9910-TP9919 = TPAD28: tolerance: ZZ.PAD28.XXX
BAT2 = 50290-0100N-001: tolerance: 20.F2196.010
BT1 = AAA-BAT-034-K01: tolerance: 62.70010.031
BTRST1 MEJ1 PSWD1 = A2541WV0-1EX2PA-6T: tolerance: 21.60909.102
C1 C84 C87 C88 C106 C131 C145 C147 C163 C179 C181-C186 C191 C194 C204 C211 C213 C214 C216 C231 C238 C271 C312 C316 C329 C419 C483 C486 C489 C495 C500 C501 C514 C516 C529 C540 C557 C559 C570 C572 C574 C580 C582-C585 C587 C595 C612 C616 C623 C627 C763 C764 C774 C781 C789-C792 C820 C821 C826 C829 C836 C1201-C1204 C1206 C1217 C1218 C1301 C1302 C1306 C1308-C1311 C1617 C1701 C1742 C1753 C1760 C1769 C1806 C1832 C1834 C1851-C1854 C1856 C1857 C1859-C1861 C1868 C1869 C1926 C2110 C2112 C2118 C2119 C2121 C3366 C3453 C3454 C6701 C6702 C6711 C6717 C6718 C9504 C9518 C9901-C9905 C11359 C12155 C12158 C12160 C12162 C12170 C12172 C12183 C12184 C12186-C12188 C12191 C12194-C12197 C12199 C12200 C12202 C12204 C12206 C12249 C12250 C12351 C12362 C12365 C12369 C12370 C12375 C12382 C12383 C12385 C12386 PC4501 PC4511 PC5209 PC5229 PC12172 PC12185 PC12187 PC12191 = C402H22: tolerance: 78.10421.2FLDL
C4 C20 = C603H36: tolerance: 78.47523.5BLDL
C5 = C603H36: tolerance: 78.47422.5BLDL
C8 C1756 C1836 C1837 C1928 C1929 C12333 C12363 PC7 PC4403 PC4609 PC4620 PC4623 PC4625 PC4628 PC4638 PC4702 PC4809 PC4810 PC5111 PC5205 PC5207 PC12180 = C402H22: tolerance: 78.10224.2FLDL
C10 C121 C132 C134 C157 C159 C160 C201 C243 C267 C268 C1780 C12377 PC4630 PC5226 = C402H22: tolerance: 78.10134.1FLDL
C14 C207 C262 C755 C1764 C1855 C1864 C3452 C3457 C3458 C12201 C12203 C12205 C12207 C12368 PC9 PC14 PC4401 PC4604 PC4629 PC12179 = C402H22: tolerance: 78.10324.2FLDL
C32 = C603H36: tolerance: 78.10492.4BLLL
C33 PC12189 = C402H22: tolerance: 78.27034.1FLDL
C35 = C603H36: tolerance: 78.33135.1BL
C36-C40 = C1206H75: tolerance: 078.10525.022D
C43 C130 C3455 C3456 C12335 PC4411 PC4417 PC4612 PC4622 PC4632 PC4635 PC4636 PC5310 PC8404 PC8409 = C402H22: tolerance: 78.10422.5FLDL
C48 C233 C248 C3459 C3460 PC4402 PC4406 PC4407 PC4414 PC4419 PC4507 PC4510 PC4515 PC4517 PC4725-PC4728 PC4801-PC4808 PC5002 PC5003 PC5101 PC5106 PC5107 PC5204 PC5299 PC5309 PC5311 = C805H58: tolerance: 78.10622.51LDL
C91 C111 C113 C324 C325 C1757 C1805 C1808 C12175 C12176 C12179-C12182 C12208-C12215 C12338 C12339 C12342 C12343 C12346 C12347 C12371-C12374 = C402H22: tolerance: 78.10421.2FLDL; signal model: 2pins
C104 C105 C112 C144 C146 C154 C155 C450 C592 C1770 C1771 C1833 C1835 C1925 C1927 C3367 C12131 C12174 C12245 C12246 C12361 C12364 PC5104 PC5113 PC5199 PC8501 PC8502 PC12186 PC12188 = C805H50: tolerance: 78.10623.51LDL
C109 C127 C129 C478 C485 C493 C509 C705-C710 C1207-C1209 C1228-C1232 C1241 C1245 C1246 C1312 C1313 C1316-C1318 C1743 C1744 C1858 C4254 C6703 C6710 C6716 C12185 C12244 PC5223 PC5225 PC5227 PC8406 PC8407 = C603H36: tolerance: 78.10610.5BLDL
C110 C250 C260 C1801 C12190 C12266 PC5224 PC12190 = C603H36: tolerance: 78.10522.5BLDL
C114 C115 C118 C119 C141 C142 C149 C151 = C402H22: tolerance: 78.10324.2FLDL; signal model: 2pins
C126 PC4 PC126 PC4502 PC4528 PC5228 PC5304 PC8401 = C402H22: tolerance: 78.22034.1FLDL
C138 C139 C202 C209 C311 C330 C747 C749 C771 C780 C784 C787 C788 C797 C804 C810 C811 C828 C830 C1803 C1804 C9516 C12157 C12163 C12169 C12189 PC4505 PC4516 = C603H36: tolerance: 78.47520.5BLDL
C140 C579 C1205 C1305 C1615 C1745 C1802 PC4616 PC5004 = C603H36: tolerance: 78.22523.5BLDL
C150 C170 C188 C190 C474 C591 C593 C715-C718 C720 C742-C745 C758-C761 C765-C770 C773 C775-C779 C782 C783 C785 C786 C793-C796 C798-C803 C805-C809 C813-C819 C823-C825 C827 C835 C863 C864 C1039-C1043 C1049-C1052 C1054 C1055 C1136-C1145 C1151-C1154 C1173-C1175 C1181 C1187 C1212-C1216 C1219-C1227 C1233-C1240 C1314 C1315 C1319-C1326 C1491 C1616 C1698 C1699 C1798 C1829 C1830 C1867 C2101-C2109 C2111 C2116 C2117 C2120 C4101 C11358 C12152 C12156 C12159 C12161 C12192 C12193 C12251 C12261 C12331 C12332 C12353 C12354 C12384 PC1 PC140 PC4416 PC4503 PC5103 PC5115 PC5202 PC5308 PC8408 PC12439-PC12442 = C402H22: tolerance: 78.10523.5FLDL
C180 = C402H22: tolerance: 78.10413.5FLDL
C187 C195 C772 C1247 C1303 PC8403 PC8405 PC12370-PC12378 PC12383-PC12433 = C805H54: tolerance: 78.22610.51LDL
C189 C197 C12216 C12217 = C402H22: tolerance: 78.10491.4FLDL
C232 C246 C247 C249 C258 C597 C862 C12171 PC12 PC20 PC4302 PC4404 PC4405 PC4408 PC4410 PC4413 PC4415 PC4506 PC4508 PC4509 PC4514 PC4518 PC5105 PC5114 PC5206 PC12181 PC12434-PC12438 = C603H35: tolerance: 78.10424.2BLDL
C235 C239 C242 C244 C865 PC5 PC16 PC19 PC60 PC4601 PC4617 PC4634 PC5020 PC5301 = C603H36: tolerance: 78.22422.2BLDL
C236 C240 C241 C12263 = C603H36: tolerance: 78.27324.2BLDL
C245 C1796 C1797 = C603H36: tolerance: 78.10521.5BLDL
C252 C257 C12262 C12264 = C603H36: tolerance: 078.68421.02BD
C253 C254 C259 C12334 = C603H36: tolerance: 78.10234.1BLDL
C255 C256 C261 C12265 = C603H36: tolerance: 78.10324.2BLDL
C524 PC4303 PC4624 PC4631 = C402H22: tolerance: 78.22224.2FLDL
C719 C750 C1179 C12352 PC1025-PC1032 PC1034 PC1035 PC1038 PC1076 PC1126-PC1130 PC1132-PC1135 PC1139 PC1155-PC1160 PC1183 PC1188-PC1193 PC1198 PC1199 = C402-TO0D2H28: tolerance: 078.10610.05FD
C752 PC4615 = C402H22: tolerance: 78.47034.1FLDL
C753 C1846 = C402H22: tolerance: 78.10423.2FLDL
C756 C757 C12355 C12356 = C402H22: tolerance: 78.12034.1FLDL
C762 = C402H22: tolerance: 78.12134.1FLDL
C812 C822 C1044-C1048 C1053 C1148-C1150 C1184-C1186 PC701-PC703 PC1033 PC1036 PC1037 PC5303 PC5305-PC5307 PC12379-PC12382 = C603H40: tolerance: 78.22610.5BLDL
C839 = C402H22: tolerance: 78.68034.1FLDL
C1182 = C603H40: tolerance: 078.4761T.05BN
C1256 C1257 C1328 = C402H22: tolerance: 78.22321.2FLDL
C1700 C1831 = C402H22: tolerance: 78.10520.5FLDL
C1773 C1774 PC4301 PC4305 = C402H22: tolerance: 78.10034.1FLDL
C1799 C1800 C9520 C9522 PC4512 PC4513 PC5112 PC5203 = C402H22: tolerance: 78.18034.1FLDL
C1807 = C603H36: tolerance: 78.10422.2BLDL
C1838-C1845 C12336 C12337 C12340 C12341 C12344 C12345 C12348 C12349 = C402H22: tolerance: 078.22423.05FD; signal model: 2pins
C1847 C1849 C1850 = C402H22: tolerance: 078.82321.02FD
C1848 = C603H38: tolerance: 078.68421.05BD
C2113-C2115 = C805H54: tolerance: 78.47610.51LDL
C3131 = C1808H87: tolerance: 078.1013N.014D
C6724 PC4619 = C402H22: tolerance: 78.10322.2FLDL
C6725 = C402H20: tolerance: 78.10423.5FL
C12126 = C603H35: tolerance: 78.47034.1BLDL
C12151 = C402H22: tolerance: 78.22510.5FLDL
C12218 C12219 C12378-C12381 PC8 = C402H22: tolerance: 78.33034.1FLDL
C12350 PC4412 PC4614 = C402H22: tolerance: 78.22124.2FLDL
C12357 C12358 = C402H22: tolerance: 78.3R374.1FLDL
C12376 = C402H22: tolerance: 78.6R874.1FLDL
CN3 = 88459-047N: tolerance: 20.F1897.004
CONVT1 = CI1410M1HRL-NH: tolerance: 20.F2266.010
CPU1 = BGA1356M4224H54: tolerance: 071.SKYLA.000U
D1 D5205 = SOD323AKH38: tolerance: 83.00355.D1F
D2 = SOT-23-9H44: tolerance: 75.00040.07D
D3 = SOD323AKH38: tolerance: 83.R5003.H8H
D4 D24 = SOT-6H58: tolerance: 075.02304.007C
D7 D34 = SOT23-2D4-312H44: tolerance: 75.00054.I7D
D16 = DO214AAAK-1121H97: tolerance: 83.P6SMB.KAG
D19 = SOT23-2D4-312H48: tolerance: 75.00099.F7D
D21 = SOD523AKH28: tolerance: 83.02015.0AF
D32 = D4724AKH44: tolerance: 83.3R010.C8M
D5201 = SOT-23-9H44: tolerance: 75.00054.A7D
D5202 = SOT-23-9H44: tolerance: 83.6R803.E31
D5203 D5204 = SLP2510P8-1H22: tolerance: 83.03010.0A0
D5206 = SOD323AKH40: tolerance: 83.00355.F1F
D5207 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
D5212 = SOT23-2D4-312H44: tolerance: 75.00054.T7D
DB1 = 210-41-02GB01: tolerance: 21.62874.102
DCIN1 = 2DC3115-000111F: tolerance: 022.10015.0311
DCIN2 = 88314-077N: tolerance: 20.F1498.007
DIMM1 = AS0A621-J4R6-7H-U: tolerance: 62.10024.S21
DIMM2 = AS0A626-J8R6-7H: tolerance: 62.10024.G01
F1 F3 F7 F15 = POLYSW-2114H30: tolerance: 069.50001.0031
F2 F5 F14 F17 = POLYSW-2114H30: tolerance: 069.50003.0001
F16 = FUSE-1608H22: tolerance: 69.43001.441
FANC3 = HF1804H: tolerance: 021.D0086.0104
G1 = CON2C-U: tolerance: ZZ.CON2C.XXX
GPU1 = BGA631M23H82: tolerance: 71.SUNM2.M02
H1-H5 = HOLE237R158: tolerance: ZZ.0HOLE.011
H6 H9 = GEN8D5X8R5X4D5-8-F-A: tolerance: ZZ.00PAD.BV1
H7 = GEN315R138-8-F-A-1: tolerance: ZZ.00PAD.BU1
H10 = GEN315R178-8-F-A-1: tolerance: ZZ.00PAD.BR1
H11 = GEN315R138-8-F-A-2-S: tolerance: ZZ.00PAD.HK1
HDD1 ODD1 = 15-02070-5A61-A: tolerance: 020.80244.0007
HDMI1 HDMI2 = SKT-HDMI22-150077: tolerance: 062.10012.0121
HDMI3 HDMI4 = LVDFH-02004-TP00: tolerance: 20.F2139.020
HS6 = STF256R109H99: tolerance: 34.3NH01.001
L1 = L20125H42: tolerance: 68.00216.121
L4 L5 L56 L57 = L125100-4P-1H36: tolerance: 68.12105.201; signal model: 4pins1
L6 L52 L53 = L603H38: tolerance: 68.00335.141
L7 L8 L10 L11 = L20125H42: tolerance: 68.00216.111
L15 = L402H22: tolerance: 68.00084.541
L19 = L603H38: tolerance: 68.00230.231
L20 L21 L47-L51 L54 L62 = L402H24: tolerance: 68.00213.031
L25 PG8402-PG8405 PR4502 PR4528-PR4532 PR4701-PR4706 PR4801-PR4803 PR4805-PR4812 PR5001 PR5002 PR5004 PR5108 PR5112 PR5116 PR5121 PR5122 PR5125 PR5127 PR5204 PR5215 PR5221 PR5258 PR5307-PR5311 PR8506 PR8507 R101 R183 R185 R9901 R79810 R80053 = 0R0805-PAD: tolerance: ZZ.R0805.ZZZ
L61 = L8080-6020H158: tolerance: 068.33010.1061
L601-L604 = L125100-4P-1H24: tolerance: 68.11500.201; signal model: 4pins1
L9502-L9505 L9523-L9525 = L603H38: tolerance: 68.00335.081
L9526 = L402H22: tolerance: 68.00084.I21
LED2 = LED1608AKH30: tolerance: 83.01608.Q70
LOUT1 = JAC331-0140A8B-9H: tolerance: 22.10277.2M1
LPC1 = HL5507F: tolerance: 21.60964.207
LVDS1 = 50524-0300N-001: tolerance: 020.K0005.0030
MEM1-MEM4 = BGA96D075130H48: tolerance: 72.51G63.R0U
MEMCD1 = 156-5101902601: tolerance: 062.10002.0161
NGFF1 = 2199230-7: tolerance: 62.10043.K51
OSC2 = SMD-OSC8H52: tolerance: 82.20013.151
P5479-P5482 R14 R618 R1622 R80115 R80116 = R402H16: tolerance: 63.R0034.1DL; signal model: 2pins
PC6 = C402H22: tolerance: 78.15134.1FLDL
PC11 PC8402 = C402H22: tolerance: 78.68124.2FLDL
PC13 PC12176 = C402H22: tolerance: 78.33124.2FLDL
PC15 PC4613 = C402H22: tolerance: 078.33322.02FD
PC17 PC18 PC58 PC5109 = C603H36: tolerance: 78.10521.2BLDL
PC24 PC61 PC12177 PC12178 = C1206H71: tolerance: 78.10622.22LDL
PC59 = C603H36: tolerance: 78.10421.2BLDL
PC4304 PC4409 PC4602 PC4611 PC4621 PC4633 PC4637 PC4639 = C402H22: tolerance: 78.47124.2FLDL
PC4418 = C805H58: tolerance: 078.10522.021D
PC4426 = C603H36: tolerance: 78.10522.5BL
PC4504 PC5110 PC5302 PC5312 PC12175 PC12184 = C603H36: tolerance: 78.15224.2BLDL
PC4603 = C402H22: tolerance: 78.15224.2FLDL
PC4605 PC4608 = C402H22: tolerance: 78.15322.2FLDL
PC4606 PC4618 = C402H22: tolerance: 78.15034.1FLDL
PC4607 = C603H36: tolerance: 78.15322.2BLDL
PC4626 = C402H22: tolerance: 78.68222.2FLDL
PC4627 = C805H54: tolerance: 78.10524.21LDL
PC5102 = C603H36: tolerance: 78.33322.2BLDL
PD4401 = D1608-035030AKH28: tolerance: 83.1R003.N8F
PD4405 = SOD323AKH42: tolerance: 83.04148.D1H
PG3 PG4 = CON2C: tolerance: ZZ.CON2C.XX1
PG4401-PG4404 PG4501 PG4506 PG4532 PG4601-PG4604 PG4606 PG4607 PG4701 PG4702 PG4804 PG4805 PG4819 PG4822 PG5001 PG5002 PG5202 PG5301 PG5302 PG8401 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PL1 = L115100-2H158: tolerance: 68.R3610.10M
PL4301-PL4303 = L402H24: tolerance: 69.80007.021
PL4401 = L7066-1830-UH119: tolerance: 68.5R610.10X
PL4501 PL4502 = L686647-127318H119: tolerance: 68.2R21B.10J
PL4701 PL4801 PL4802 = L112100-2030H158: tolerance: 068.R1510.1011
PL5001 = L686647-127318H119: tolerance: 68.R4710.10V
PL5101 PL5201 = L115100-2030H158: tolerance: 68.1R01B.10J
PL5301 = L686647-127318H119: tolerance: 68.1R01B.10K
PL8401 = L2520-D620H48: tolerance: 68.1R050.10R
PQ4204 = SOT323CBE2D2H44: tolerance: 84.00124.H1K
PQ4205 = SOT323CBE2D2H44: tolerance: 84.00124.K1K
PQ4206 PQ4405 Q1229 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ4401 PQ5008 Q6701 Q9501-Q9503 Q9614 Q9620 Q9627 Q9646 = SOT-363H44: tolerance: 84.2N702.A3F
PQ4402 PQ4403 PQ4406 Q1 Q3 Q5 Q12 Q47 Q56 Q68 Q76 Q1212 Q1249 Q5008 Q6705 Q9626 Q9634 Q9636 Q9638 Q9643 Q9648 Q9651 Q9652 = SOT23DGS2D4H48: tolerance: 84.2N702.E31
PQ4404 PQ5007 = SOT-363H44: tolerance: 84.00512.03F
PQ4409 Q9644 = SOT23CBE2D4H44: tolerance: 84.T3906.A11
PR1 PR12 PR4455 PR4458 PR4462 PR4609 PR5217 PR5312 PR5313 PR8509 PR8512 PR8513 PR8515 PR8517 PR8518 PR8521 PR8527 R131 R306 R307 R333 R342 R354 R413 R504 R702 R729 R1111 R1128 R1129 R1154 R1155 R1180 R1620 R1621 R1710 R1717 R1761 R1810 R1920 R1925 R1931 R1950 R6706 R9908 R9921 R9922 R9931 R79647 R79648 R79657 R79658 R79697-R79704 R79709-R79713 R79778 R79789 R79809 R79832 R79837 R79855 R79871 R79872 R79919 R79920 R79928 R80010 R80047 R80055 R80075 R80108 R80110-R80113 R80128 R80129 R80137 R80162 R80166 R80171 R80172 R80191 R80193 R80203-R80209 R80220-R80222 R80240 R80256 = R402H16: tolerance: 63.R0034.1DL
PR2 PR28 PR29 PR44 PR101 PR4410 PR4431 PR4665 PR4666 PR5245 PR8505 R15 R51 R53 R56 R59 R222 R256 R291 R341 R348 R351 R379 R420 R602 R606 R703 R707-R709 R723 R744 R1108 R1109 R1112 R1114-R1116 R1120-R1127 R1130-R1134 R1136-R1138 R1160 R1201 R1202 R1209 R1217 R1301 R1689 R1709 R1801 R1878 R1948 R1949 R1951 R1980 R1984 R1985 R2107 R5217 R9509 R9536 R9546 R9556 R9910 R9914-R9917 R9919 R9920 R9925 R9926 R9928 R9933 R79618 R79633 R79634 R79790-R79792 R79814-R79819 R79841 R79843 R79851 R79859 R79860 R79923 R79924 R79942 R79945 R79978 R79990 R80026 R80048 R80052 R80064-R80066 R80100 R80101 R80131 R80144 R80149 R80175 R80183 R80186-R80189 R80192 R80210 R80236 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
PR3 PR4 PR7 PR15 PR26 PR31 PR33 PR40 PR96 PR102 PR103 PR4210 PR5257 PR5478-PR5480 PR5482 PR5485 PR5486 PR5490 R124 R143 R153 R225 R251 R286 R287 R303 R314 R335 R337 R338 R340 R343 R377 R393 R401 R406 R419 R542 R604 R605 R627 R1179 R1729 R1730 R1732 R1822-R1827 R1832 R1834 R1836-R1838 R1993 R2006 R2007 R2012 R5215 R5218 R8515 R9605 R9902-R9904 R9907 R9927 R9930 R79836 R79921 R79922 R79925 R79932 R79979-R79981 R79991 R80001 R80037 R80043 R80104 R80147 R80148 R80154 R80163 R80173 = R402H16: tolerance: 63.10234.1DL
PR5 = R402H16: tolerance: 64.40215.6DL
PR6 = R402H16: tolerance: 64.19115.6DL
PR8 PR9 PR4409 R208 R210 R329 R1896 R79721 = R402H16: tolerance: 64.47025.6DL
PR11 PR4511 PR4660 PR5306 PR8510 PR8511 R74 R207 R295 R297 R332 R334 R336 R381 R399 R400 R458 R651 R1165 R1166 R1718 R1719 R9553 R9555 R79777 R79824 R79825 R79873 R79929 R79943 R80031 R80032 R80045 R80130 R80150 R80227 R80237 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11
PR13 = R402H16: tolerance: 64.80615.6DL
PR16 = R402H16: tolerance: 64.12115.6DL
PR19 PR4422 PR4433 PR4450 PR4503 PR4519 PR4615 PR5106 PR5208 PR5242 PR5302 PR5304 PR8503 PR8514 PR8516 R82 R252 R259 R260 R266 R280 R290 R308-R313 R321 R397 R398 R404 R658 R1760 R79621 R79625 R79705 R79706 R79927 R79936 R79939 R80117 R80118 R80174 R80216 R80233 R80235 R80250 R80251 R80254 = R402H16: tolerance: 64.10025.6DL
PR20 = R402H16: tolerance: 64.56205.6DL
PR21 = R402H16: tolerance: 64.18715.6DL
PR34 = R402H16: tolerance: 64.82R55.6DL
PR42 PR4606 = R402H16: tolerance: 64.26115.6DL
PR43 PR4601 PR4639 PR4646 PR5103 PR5210 = R603H22: tolerance: 64.2R205.55L
PR45 = R603H22: tolerance: 64.36515.55L
PR51 = NTC-402H24-U: tolerance: 69.60013.131
PR60 = NTC-402H24-U: tolerance: 69.60013.141
PR1689 PR4655 = R402H16: tolerance: 64.12425.6DL
PR4214 = R1206H28: tolerance: 63.33232.11L
PR4401 R2040 R2041 = R402H16: tolerance: 64.49925.6DL
PR4402 PR4404 PR4407 PR4413 PR4427 PR4434 PR4509 PR4599 PR5297 PR8404 PR8523 R1 R26 R30 R33 R132 R144 R288 R388 R396 R603 R732 R733 R1780 R1781 R1852 R1894 R6703-R6705 R8514 R8516 R9603 R9929 R79668 R79755 R79756 R79926 R79944 R80051 R80092 R80151 R80165 R80196 R80197 R80223 R80255 R80257 = R402H16: tolerance: 63.10434.1DL
PR4403 = R805H24: tolerance: 64.20R05.16L
PR4405 = R402H16: tolerance: 64.10235.6DL
PR4406 PR4656 PR4657 PR4668 PR8502 R5 R220 R284 R80082 = R402H14: tolerance: 64.10R05.6DL
PR4408 = R402H16: tolerance: 64.11035.6DL
PR4411 = R402H16: tolerance: 64.56225.6DL
PR4412 PR4414 PR4418 PR4419 PR4421 PR4429 R65 R741 R1708 = R805H24: tolerance: 63.R0031.16L
PR4415 PR4430 = R3720H40: tolerance: 64.R0105.7FL
PR4416 PR8403 R80114 = R402H16: tolerance: 64.33025.6DL
PR4417 = R402H16: tolerance: 63.47434.1DL
PR4420 = R402H16: tolerance: 63.33534.1DL
PR4423 = R402H16: tolerance: 64.7R505.6DL
PR4424 = R402H16: tolerance: 64.30935.6DL
PR4425 = R402H16: tolerance: 64.1R505.6DL
PR4426 PR4432 PR8519 PR8520 = R402H16: tolerance: 63.33234.1DL
PR4428 = R402H16: tolerance: 64.10735.6DL
PR4435 PR4707 PR4813 PR4814 PR5114 PR5214 PR5492 PR5498 = R805H24: tolerance: 63.2R231.16L
PR4451 = R402H16: tolerance: 64.68035.6DL
PR4501 PR4513 = R402H16: tolerance: 63.2R234.1DL
PR4504 = R402H16: tolerance: 64.66515.6DL
PR4506 = R402H16: tolerance: 64.53625.6DL
PR4508 PR8401 = R402H16: tolerance: 64.56025.6DL
PR4515 = R402H16: tolerance: 64.71525.6DL
PR4518 R718 R1727 R1817 R1853 R80102 R80215 = R402H16: tolerance: 64.15025.6DL
PR4535 PR4621 = R402H16: tolerance: 64.14035.6DL
PR4602 R1593 R1594 R1596 R1598 R2085-R2090 R79934 = R402H16: tolerance: 64.47015.6DL
PR4603 PR4605 PR4624 PR4638 PR4652 PR4664 R61 R742 R1158 R1162 R1897 R79690 R80241 = R402H16: tolerance: 64.10015.6DL
PR4608 PR4625 = R402H16: tolerance: 64.13725.6DL
PR4610 PR4632 PR4644 PR4649 = NTC-402H22-U: tolerance: 69.60011.221
PR4612 PR5305 R268 R80057 R80059 R80107 = R402H16: tolerance: 64.20025.6DL
PR4613 = R402H16: tolerance: 64.32425.6DL
PR4614 = R402H16: tolerance: 64.84525.6DL
PR4616 PR4663 R45 R68 R1501 R1604 R1888 R1889 R79656 R79930 R80015-R80018 R80027 R80077 = R402H14: tolerance: 64.10005.6DL
PR4617 = R402H16: tolerance: 64.24315.6DL
PR4618 = R402H16: tolerance: 64.45R35.6DL
PR4620 = R402H16: tolerance: 64.51025.6DL
PR4622 PR8522 R319 R79628 R79720 R79722 R80238 = R402H16: tolerance: 64.10035.6DL
PR4623 PR4627 = R603H22: tolerance: 64.75015.55L
PR4626 = R402H16: tolerance: 64.30925.6DL
PR4628 PR4662 R601 R80006-R80009 = R402H16: tolerance: 64.49R95.6DL
PR4629 = R402H16: tolerance: 64.59025.6DL
PR4630 = R402H16: tolerance: 64.14725.6DL
PR4631 PR4635 = R402H16: tolerance: 64.12415.6DL
PR4633 = R402H16: tolerance: 64.22035.6DL
PR4636 PR4642 = R603H22: tolerance: 64.11035.55L
PR4637 = R402H16: tolerance: 64.52335.6DL
PR4640 PR4647 = R402H16: tolerance: 64.90905.6DL
PR4641 R1205 R2082 = R402H16: tolerance: 64.49915.6DL
PR4645 PR4648 = R402H16: tolerance: 64.12725.6DL
PR4650 = R402H16: tolerance: 64.22625.6DL
PR4651 = NTC-402H22-U: tolerance: 69.60011.081
PR4653 PR4658 = R402H16: tolerance: 64.35715.6DL
PR4654 = R402H16: tolerance: 64.14025.6DL
PR4661 PR4669 R940 R948 R1816 R80084 = R402H16: tolerance: 64.20015.6DL
PR4667 = R603H24: tolerance: 64.2R205.L0L
PR5005 PR8402 = R402H16: tolerance: 64.2R205.6DL
PR5101 = R402H16: tolerance: 64.62035.6DL
PR5102 R13 R776 R1195 R80229 = R402H16: tolerance: 64.39225.6DL
PR5105 = R402H16: tolerance: 64.5R105.6DL
PR5110 = R402H16: tolerance: 64.48725.6DL
PR5111 = R402H16: tolerance: 64.75015.6DLDL
PR5118 R305 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
PR5202 R20 R1777 R1778 = R402H16: tolerance: 64.47035.6DL
PR5207 = R402H16: tolerance: 64.23725.6DL
PR5212 PR5218 PR5246 PR5431 PR8501 R12 R41 R42 R134 R138 R151 R213 R221 R249 R257 R264 R265 R277 R279 R281-R283 R296 R316 R317 R324 R392 R394 R517 R523 R524 R530 R531 R533 R764 R774 R802 R803 R1167 R1178 R1183 R1194 R1302 R1610 R1611 R1615 R1617 R1659-R1663 R1684 R1685 R1687 R1688 R1700 R1707 R1716 R1728 R1731 R1733 R1734 R1753 R1754 R1757 R1759 R1783 R1785 R1819 R1833 R1849 R1880-R1882 R1885-R1887 R1932 R2021 R2032 R2091 R5201-R5209 R5216 R6702 R8511 R8513 R9505 R9507 R9508 R9510 R9532 R9533 R9542-R9545 R9554 R9557 R9563 R79188 R79205 R79236 R79237 R79687 R79689 R79691 R79759-R79764 R79797-R79802 R79806 R79820 R79838 R79850 R79866 R79868 R79931 R79933 R79935 R79938 R79940 R79946 R79947 R80033 R80034 R80036 R80039 R80042 R80049 R80054 R80080 R80103 R80109 R80126 R80127 R80132-R80134 R80140 R80141 R80145 R80146 R80158-R80160 R80167 R80168 R80170 R80177-R80181 R80200 R80211 R80217-R80219 R80224-R80226 R80231 R80239 R80243-R80248 R80252 R80253 = R402H16: tolerance: 63.10334.1DL
PR5219 = R402H16: tolerance: 64.40225.6DL
PR5298 = R402H16: tolerance: 64.12035.6DL
PR5301 R380 = R603H22: tolerance: 63.10033.15L
PR5303 = R1206H28: tolerance: 63.2R232.11L
PR5481 PR5489 = R402H16: tolerance: 64.1R005.6DL
PR5487 R215 R300 R301 R382-R384 R387 R705 R1101 R1102 R1106 R1135 R1193 R2106 R9905 R9924 R79812 R79813 R79834 R79835 R79842 R80023 R80041 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21
PR5488 = R402H16: tolerance: 64.93115.6DL
PR5491 = R402H16: tolerance: 64.11025.6DL
PR8405 = R402H16: tolerance: 64.18025.6DL
PR8504 = R402H16: tolerance: 64.69815.6DL
PR8524 R19 R722 R1779 R9547 R79171 R79172 R80038 R80060 = R402H16: tolerance: 63.10534.1DL
PT1 PT3 PT4 = ECAP-100D6D3H355: tolerance: 09.8271N.A4L
PT2 = SE361416H237: tolerance: 79.47612.A0L
PT4501 PT4502 = SE3116H241: tolerance: 79.22710.30L
PT4503 PT4504 PT4704 PT4803 PT4804 PT5103 PT5201 = SE361414H241: tolerance: 79.47612.3GL
PT4701 PT4703 PT4801 PT5001 PT5202 PT5203 PT8501 = ECAP-100D6D3H375: tolerance: 09.8271V.08L
PT4802 = ECAP-100D6D3H375: tolerance: 09.56710.A8L
PT5101 PT5102 = CT7343H83: tolerance: 79.33719.L01
PU1 PU2 = PPAK-5PH45: tolerance: 84.A14DP.037
PU3 PU5409 = PPAK-5PH45: tolerance: 84.SRA04.037
PU4401 PU4402 = PPAK-8P-2H45: tolerance: 84.00412.037
PU4403 PU4405 U110 = SOIC8H69: tolerance: 84.04407.G37
PU4404 = QFN20G3D5-G2D15H40: tolerance: 74.24727.A73
PU4501 = QFN20-G1D75H32: tolerance: 74.08243.073
PU4502 PU4504 PU5002 = PPAK-8P-3232H36: tolerance: 84.07506.037
PU4503 PU4505 PU5001 = PPAK-8P-3232H36: tolerance: 84.07410.A37
PU4601 = LFQFN52J6-G4D8-1H40: tolerance: 074.81206.0073
PU4701 PU4704 PU4801 PU4804 PU5103 PU5202 = PPAK-8P-5262H40: tolerance: 84.06520.037
PU4702 PU4703 PU4802 PU4803 PU4805 PU4807 PU5102 PU5203 = PPAK-8P-5262H40: tolerance: 084.06510.0037
PU5003 = LFDFN8G2-G1309H40: tolerance: 074.81253.00E3
PU5104 = QFN20-G1D75H32: tolerance: 074.08207.0073
PU5201 = DFN10G3-G265175H32: tolerance: 74.08237.B73
PU5301 = QFN16J3H24: tolerance: 074.06220.0043
PU5302 = SOIC8-G3530H63: tolerance: 74.05930.B3D
PU8401 = DFN10G3-G265175H32: tolerance: 74.08068.A43
PU8501 = SOIC8-G3530H63: tolerance: 74.05912.03D
PWRCN1 = 51530-01041-W01: tolerance: 20.K0642.010
Q2 Q10 Q22 Q31 Q45 Q48 Q100-Q102 Q128 Q1214 Q9642 = SOT23CBE2D4H44: tolerance: 84.T3904.C11
Q4 Q9628 = SOT23DGS2D4H48: tolerance: 84.05067.031
Q6 = SOT-363H44: tolerance: 75.27002.D7C
Q8 Q9629 Q9641 = SOT23DGS2D4H44: tolerance: 84.27002.Z31
