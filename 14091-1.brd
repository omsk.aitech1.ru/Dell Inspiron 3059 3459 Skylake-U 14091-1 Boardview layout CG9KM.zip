# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_5V: length 107.4
  TOP w0.305: HDMI2.18 118.41,18.32 118.64,18.55 118.64,19.44 118.02,20.07 ; R9510.1 v3(60.74,80.64)
  TOP w0.508: v3(115.1,26.29) 114.97,26.16 D5202.3 117.43,25.16 R80238.1 117.59,25.16 D5201.1 119.1,24.7 119.6,24.19 C12216.1 R5218.1 118.59,22.99 118.06,22.46 117.45,22.46 116.97,21.97 116.97,20.47 117.37,20.07 118.02,20.07
  L3 w0.305: v3(60.74,80.64) 63.25,78.13 67.6,78.13 70.75,74.98 70.75,73.71 72.85,71.61 72.85,71.59 74.34,70.1 75.38,70.1 78.05,67.44 78.05,66.02 78.87,65.19 78.87,57.94 82.29,54.52 82.29,53.59 85.38,50.51 89.94,50.51 96.3,44.15 96.3,36.03 101.47,30.86 101.47,29.6 103.26,27.81 113.57,27.81 v3(115.1,26.29)
  BOTTOM w0.508: v3(60.74,80.64) 60.74,80.38 v2(60.23,79.87)
HDMI_DET1: length 3.5
  TOP w0.102: R9510.2 60.88,78.8 v1(61.76,79.68) 62.21,80.14 62.96,80.14 R9511.1
HDMI_DET_SIO: length 7.6
  TOP w0.102: Q5008.D 149.77,55.24 v1(149.64,55.37) 149.59,55.42 149.14,55.42 R8514.2 148.23,56.34 146.53,56.34 145.6,55.4 145.6,55.19 145.38,54.97 U109.108
HDMI_HDCP_READY: length 81.7
  TOP w0.102: 112.96,25.37 111.98,26.36 U5202.1 ; 112.96,25.37 113.95,24.38 115.92,24.38 R5219.1 R5218.2 ; 112.96,25.37 112.2,24.61 v3(112.2,23.29) ; v3(61.88,52.96) 61.53,52.61 v1(61.09,52.61) 60.62,53.08 SCA1.114
  L3 w0.127: v3(95.66,23.88) 89.9,29.64 89.9,37.32 86.28,40.94 86.28,43.32 85.29,44.31 70.4,44.31 61.88,52.83 v3(61.88,52.96)
  L4 w0.127: v3(95.66,23.88) 111.62,23.88 v3(112.2,23.29)
HDMI_HPDET: length 11.1
  TOP w0.102: R5219.2 115.07,23.62 v3(114.82,23.37) 114.56,23.62 R80197.1 ; HDMI2.19 117.36,19.12 v3(116.95,19.53)
  BOTTOM w0.102: v3(114.82,23.37) 118.17,23.37 v2(118.65,22.89) 118.65,21.23 v3(116.95,19.53)
HDMI_IN_DET#_R: length 2.8
  TOP w0.102: Q5008.S 152.88,56.67 v1(152.12,57.43) 151.98,57.57 R8515.1
HDMI_LANE0_DN: length 11.4
  TOP w0.102: HDMI1.3 118.32,33.82 118.71,33.43 118.99,33.43 119.41,33.01 119.41,32.37 119.92,31.86 121.41,31.86 121.57,32.02 121.57,32.71 121.99,33.13 122.31,33.13 122.44,33.26 U28.9 U28.2 124.24,33.26 124.37,33.13 124.58,33.13 125.34,32.38 125.76,32.38 126,32.61 TR16.2
HDMI_LANE0_DP: length 11.4
  TOP w0.102: HDMI1.1 118.32,32.82 118.71,33.21 118.91,33.21 119.2,32.92 119.2,32.28 119.83,31.65 121.5,31.65 121.79,31.93 121.79,32.62 122.08,32.91 122.31,32.91 122.44,32.78 U28.10 U28.1 124.23,32.78 124.37,32.91 124.49,32.91 125.25,32.16 125.76,32.16 126,31.93 TR16.3
HDMI_LANE0_IC_DN: length 4.3
  TOP w0.102: TR16.1 127.93,32.61 128.17,32.38 128.27,32.38 128.56,32.67 128.56,33.78 128.85,34.08 129.48,34.08 129.56,34.16 U118.29
HDMI_LANE0_IC_DP: length 4.3
  TOP w0.102: U118.30 129.58,33.76 129.48,33.86 128.94,33.86 128.77,33.69 128.77,32.58 128.36,32.16 128.17,32.16 127.93,31.93 TR16.4
HDMI_LANE1_DN: length 9.3
  TOP w0.102: TR17.2 126,34.77 125.76,34.53 124.95,34.53 124.84,34.65 124.37,34.65 124.23,34.78 U28.5 U28.6 122.44,34.78 122.31,34.65 121.83,34.65 121.55,34.93 118.71,34.93 118.32,35.32 HDMI1.6
HDMI_LANE1_DP: length 9.3
  TOP w0.102: TR17.3 125.94,34.09 125.7,34.32 124.86,34.32 124.75,34.43 124.37,34.43 124.23,34.3 U28.4 U28.7 122.44,34.3 122.31,34.43 121.74,34.43 121.46,34.71 118.71,34.71 118.32,34.32 HDMI1.4
HDMI_LANE1_IC_DN: length 3.3
  TOP w0.102: U118.26 129.56,35.36 129.48,35.28 128.95,35.28 128.43,34.76 128.43,34.67 128.29,34.53 128.17,34.53 127.93,34.77 TR17.1
HDMI_LANE1_IC_DP: length 3.3
  TOP w0.102: TR17.4 127.93,34.09 128.17,34.32 128.38,34.32 128.65,34.58 128.65,34.67 129.04,35.06 129.48,35.06 129.58,34.96 U118.27
HDMI_LANE2_DN: length 10.1
  TOP w0.102: HDMI1.9 118.32,36.82 118.71,36.43 119.25,36.43 119.92,35.76 121.52,35.76 121.83,36.07 121.83,36.41 122.12,36.71 122.31,36.71 122.44,36.84 U6706.4 U6706.7 124.51,36.84 124.64,36.71 125,36.71 125.12,36.82 125.39,36.82 125.62,37.05 TR18.2
HDMI_LANE2_DP: length 10.1
  TOP w0.102: HDMI1.7 118.32,35.82 118.71,36.21 119.16,36.21 119.83,35.55 121.61,35.55 122.04,35.98 122.04,36.32 122.21,36.49 122.31,36.49 122.44,36.36 U6706.5 U6706.6 124.51,36.36 124.64,36.49 125.09,36.49 125.21,36.6 125.39,36.6 125.62,36.37 TR18.3
HDMI_LANE2_IC_DN: length 3.4
  TOP w0.102: TR18.1 127.93,37.05 128.17,36.82 128.36,36.82 128.65,36.53 128.65,36.28 128.85,36.08 129.48,36.08 129.56,36.16 U118.24
HDMI_LANE2_IC_DP: length 3.4
  TOP w0.102: TR18.4 127.93,36.37 128.17,36.6 128.27,36.6 128.43,36.44 128.43,36.2 128.76,35.86 129.48,35.86 129.58,35.76 U118.25
HDMI_LANE3_DN: length 9.9
  TOP w0.102: HDMI1.12 118.32,38.32 118.71,37.93 119.16,37.93 119.83,38.59 121.84,38.59 122.21,38.23 122.31,38.23 122.44,38.36 U6706.1 U6706.10 124.24,38.36 124.37,38.23 124.49,38.23 125.25,38.98 125.75,38.98 125.99,39.21 TR19.2
HDMI_LANE3_DP: length 9.9
  TOP w0.102: TR19.3 126,38.53 125.76,38.76 125.34,38.76 124.58,38.01 124.37,38.01 124.23,37.88 U6706.9 U6706.2 122.44,37.88 122.31,38.01 122.12,38.01 121.75,38.38 119.92,38.38 119.25,37.71 118.71,37.71 118.32,37.32 HDMI1.10
HDMI_LANE3_IC_DN: length 4.2
  TOP w0.102: TR19.1 127.93,39.21 128.17,38.98 128.36,38.98 128.77,38.56 128.77,37.55 129.05,37.28 129.48,37.28 129.56,37.36 U118.21
HDMI_LANE3_IC_DP: length 4.3
  TOP w0.102: TR19.4 127.93,38.53 128.17,38.76 128.27,38.76 128.56,38.47 128.56,37.47 128.96,37.06 129.48,37.06 129.58,36.96 U118.22
HDMI_OUT_DDC_VCC: length 9.2
  TOP w0.254: D5205.K 126.04,30.1 125.03,29.08 v1(125.03,28.65) 126.92,28.65 C12370.1 R2083.1 R2084.1
HDMI_SCL_IN: length 8.7
  TOP w0.102: HDMI2.15 118.9,16.82 v3(119.79,15.93) 119.84,15.88 R5210.1 122.65,16.57 v1(122.39,16.84)
  BOTTOM w0.102: v3(119.79,15.93) 118.77,16.95 U5203.1
HDMI_SCL_IN_C: length 7.5
  TOP w0.102: 124.24,21.72 124.24,20.51 R80172.1 C12219.1 124.68,18.71 v1(123.51,17.53) 123.54,17.5 R5210.2 R5213.2
HDMI_SDA_IN: length 10.3
  TOP w0.102: v3(118.91,17.78) 118.91,17.65 118.57,17.32 HDMI2.16
  BOTTOM w0.102: U5203.2 117.51,15.77 117.51,17.4 117.89,17.78 v3(118.91,17.78) 118.91,19.18 v2(119.29,19.56) 121.38,19.56 R5211.1
HDMI_SDA_IN_C: length 7.1
  TOP w0.102: 122.97,21.72 122.97,20.57 v3(122.72,20.32)
  BOTTOM w0.102: v2(120.63,21.49) 120.68,21.49 121.53,20.64 R5211.2 122.4,20.64 v3(122.72,20.32) 123.03,20.64 R80171.1 C12218.1 R5214.2
HM_VCCP: length 2.4
  BOTTOM w0.381: G1.2 144.34,47.56 R260.1
  BOTTOM w0.508: R260.1 v2(143.8,46.33)
HM_VCCP_R: length 5
  TOP w0.203: U109.95 142.61,50.08 v3(142.27,50.42)
  BOTTOM w0.508: R260.2 C184.1 142.78,49.15 143.08,49.45 v2(143.08,49.63) 143.08,49.63 143.06,49.63 v3(142.27,50.42)
HP_MUTE: length 166.7
  TOP w0.102: SCA1.64 53.96,75.77 v3(53.88,75.69)
  L4 w0.127: v3(53.88,75.69) 53.88,74.5 56.85,71.53 61.42,71.53 65.08,67.87 86.72,67.87 89.19,65.41 96.54,65.41 100.03,61.91 100.73,61.91 102.57,60.07 108.94,60.07 109.58,59.44 111.19,59.44 112.45,58.17 112.45,58 113.93,56.52 121.34,56.52 123.15,58.33 127.2,58.33 127.5,58.64 140.79,58.64 141.45,57.98 145,57.98 145.66,57.32 146.88,57.32 147.86,58.3 147.86,59.88 152.33,64.35 154,64.35 155.37,62.98 158.36,62.98 159.48,64.1 159.48,66.87 159.29,67.06 v3(159.29,67.82)
  BOTTOM w0.102: R79920.1 160.75,39.56 161.63,38.68 162.92,38.68 163.84,39.6 164.8,39.6 167.11,41.92 167.11,57.33 163.43,61.01 v2(163.43,63.73) 163.43,65.98 161.59,67.82 v3(159.29,67.82) ; R80170.2 52.17,76.3 52.78,75.69 v3(53.88,75.69)
HP_MUTE_D: length 5.7
  BOTTOM w0.152: Q9627.3 164.26,40.75 163.99,41.02 163.99,42.42 164.18,42.61 164.5,42.61 R79919.2 165.32,43.65 166.05,44.37 v2(166.28,44.37)
HP_MUTE_L: length 3
  BOTTOM w0.152: Q9627.4 163.05,39.55 v2(162.85,39.34) 162.8,39.29 162.22,39.29 R79920.2
HPOL_CON: length 13.8
  TOP w0.203: C134.1 171.61,82.87 R220.2 R225.2 R223.2 ; C134.1 R221.1 ; C134.1 172.63,84.11 Q57.1 174.25,83.31 174.25,80.39 173.4,79.54 UHS1.1
  BOTTOM w0.203: UHS1.1 172.54,79.09 v2(172.09,78.64)
HPOR_CON: length 37.2
  TOP w0.203: v3(174.09,84.2) 174.4,84.52 Q57.2 175.01,83.08 174.73,82.8 174.73,74.09 175.55,73.28 179.31,73.28 UHS1.2 ; R627.2 R284.2 R262.2 169.58,73.85 R281.1 C159.1 171.67,73.85 v3(171.86,74.04)
  L3 w0.203: v3(174.09,84.2) 173.77,84.2 170.85,81.28 170.85,75.06 v3(171.86,74.04)
  BOTTOM w0.203: v3(174.09,84.2) v2(173.26,84.2)
HPOUT-JD: length 5.9
  TOP w0.203: R267.1 171.48,71.06 171.92,71.49 UHS1.6
  BOTTOM w0.203: UHS1.6 v2(170.14,71.49)
HPOUT-L: length 19
  TOP w0.203: v3(169.04,71.64) 168.9,71.78 167.77,71.78 166.66,72.9 166.66,74.19 166.2,74.65 U6.26 ; R220.1 v3(169.83,82.93)
  L3 w0.203: v3(169.83,82.93) 170.26,82.5 170.26,74.47 169.07,73.28 169.07,71.67 v3(169.04,71.64)
  BOTTOM w0.203: v3(169.83,82.93) v2(169.83,82.12)
HPOUT-R: length 3.1
  TOP w0.203: U6.27 166.32,75.05 166.95,74.42 167.25,74.42 167.99,73.68 R284.1
HSI_C_DN8: length 6.8
  BOTTOM w0.102: v2(179.08,141.63) 179.31,141.86 ; 179.31,141.86 179.57,141.6 179.57,141.26 179.41,141.1 179.08,141.1 178.98,141 C325.1 ; 179.31,141.86 179.15,142.01 179.15,143.92 178.84,144.23 177.55,144.23 177.46,144.14 U14.8
HSI_C_DP8: length 6.7
  BOTTOM w0.102: C324.1 179.79,140.61 179.79,141.69 179.37,142.1 179.37,143.38 ; v2(179.66,143.38) 179.37,143.38 ; 179.37,143.38 179.37,144.01 178.93,144.45 177.55,144.45 177.46,144.54 U14.7
HSI_LAN_DN1_R: length 5.5
  TOP w0.102: 32.16,15.77 33.08,15.77 33.26,15.95 35.11,15.95 35.2,15.86 U16.18 ; 32.16,15.77 31.36,15.77 C1808.1 ; 32.16,15.77 v1(32.16,15.37)
HSI_LAN_DP1_R: length 5.5
  TOP w0.102: U16.17 35.2,16.26 35.11,16.17 33.82,16.17 ; 33.82,16.17 33.17,16.17 32.99,15.99 31.35,15.99 C1805.1 ; 33.82,16.17 v1(33.82,16.51)
ICH_RSMRST_N_R: length 4.3
  TOP w0.102: U109.82 137.41,50.26 v3(137.27,50.4)
  BOTTOM w0.102: v3(137.27,50.4) 137.55,50.12 137.55,49.35 v2(137.37,49.17) 136.72,49.17 R291.2
IMS: length 73
  TOP w0.102: v3(44.86,105.54) 45.56,105.54 R80137.1 45.44,105.03 44.71,105.03 43.24,106.5 LVDS1.4
  L3 w0.127: v3(35.34,87.88) 35.34,86.23 44.91,76.66 44.91,69.14 54.77,59.28 54.77,56.77 v3(55.28,56.26)
  BOTTOM w0.102: v3(35.34,87.88) v2(35.34,94.23) 35.09,94.49 35.09,103 37.63,105.54 v3(44.86,105.54) ; v3(55.28,56.26) 55.28,55.41 R79832.2
INIT_3V: length 6.2
  TOP w0.102: v1(104.43,59.44) 104.49,59.37 R1699.2 105.57,58.17 105.03,57.63 LPC1.2
IO_SMI_N: length 19.4
  TOP w0.102: R79928.2 132.42,68.8 132.42,67.74 131.25,66.57 129.17,66.57 v1(129.04,66.45) 129.04,66.22 129.54,65.72 v3(130.02,65.72) ; U109.9 139.81,65.74 v3(139.99,65.91)
  L4 w0.127: v3(130.02,65.72) 130.02,66.05 131.15,67.18 136.94,67.18 137.7,66.42 139.48,66.42 v3(139.99,65.91)
ISEN1: length 15.8
  TOP w0.254: R51.2 32.67,41.27 v1(33,40.94) 33,39.45 32.72,39.17 32.72,30.95 33.32,30.35 34.2,30.35 v3(34.83,29.72)
  BOTTOM w0.254: v3(34.83,29.72) 34.96,29.72 35.73,28.95 U120.17
ISEN2: length 16.3
  TOP w0.254: v1(35.21,28.83) 34.83,28.83 v3(33.94,29.72) ; R53.2 v3(32.42,40.13)
  L4 w0.254: v3(32.42,40.13) 32.42,30.1 32.8,29.72 v3(33.94,29.72)
  BOTTOM w0.254: U120.16 34.78,28.37 33.94,29.21 v3(33.94,29.72)
ISEN3: length 8.5
  BOTTOM w0.254: R56.2 32.04,33.59 32.04,31.33 32.6,30.77 32.6,30.45 v2(32.67,30.37) 32.67,27.87 33.63,26.92 U120.14
ISEN4: length 9.6
  BOTTOM w0.254: U120.13 33.41,26.42 32.09,27.74 32.09,30.56 31.53,31.11 31.53,32.49 v2(31.36,32.66) 31.35,32.67 31.35,33.26 R59.2
ISET: length 5.2
  TOP w0.102: v3(132.24,31.75) 132.15,31.84 U118.34
  BOTTOM w0.102: R2086.1 131.41,32.58 v3(132.24,31.75) 131.54,31.05 R1596.2 130.45,30.86 v2(130.27,30.68)
ISP_CLK1: length 6.3
  TOP w0.102: R9540.2 80.16,55.8 v3(82.28,55.8) 82.28,56.06 82.71,56.49 v1(83.01,56.49) 83.42,56.49 84.16,55.75 Q9502.6
  BOTTOM w0.102: Q9501.6 v3(82.28,55.8)
ISP_DAT1: length 7.5
  TOP w0.102: v3(81.19,53.71) 82.25,53.71 Q9502.3
  BOTTOM w0.102: R9541.2 80.98,55.75 v2(81.01,55.73) 81.19,55.55 v3(81.19,53.71) 81.68,53.21 83.47,53.21 83.96,53.71 Q9501.3
ISW: length 6.9
  TOP w0.254: v3(36.61,29.72) 37.14,30.25 37.73,30.25 v1(38.39,29.59) 38.01,29.21 37.75,29.21 37.43,28.89 C10.1
  BOTTOM w0.254: U120.19 36.73,29.6 v3(36.61,29.72) 36.53,29.79 R79630.2
ISW_1: length 5
  BOTTOM w0.254: Q1250.3 41.31,34.67 38.46,31.83 R79630.1
  vias: v2(42.37,38.49)
ITP_PMODE: length 177.3
  TOP w0.102: v4(74.73,149.63) 74.41,149.31 CPU1.E8 ; v3(41.18,131.83) 41.82,132.46 43.09,132.46 44.71,134.09 54.75,134.09 59.23,138.56 67.76,138.56 68.52,139.32 v3(68.52,139.72)
  L3 w0.127: v3(41.18,131.83) 38.36,134.65 23.56,134.65 15.65,142.55 15.65,142.87 15.65,149.61 11.15,154.11 11.15,186.18 13.72,188.75 13.72,200.26 11.59,202.39 11.59,202.7 11.59,219.49 16.84,224.74 v3(27.38,224.74)
  BOTTOM w0.102: R9932.2 27.26,224.85 v3(27.38,224.74) 27.49,224.85 R9933.2 ; v3(68.52,139.72) 68.03,140.21 68.03,146.37 69.97,148.31 71.21,148.31 71.57,148.67 v2(72.7,148.67) 73.77,148.67 v4(74.73,149.63)
JACK_PSID: length 21.8
  TOP w0.102: DCIN2.11 55.64,31.22 v3(55.53,31.11) ; v3(55.53,39.24) 55.64,39.14 DCIN2.4
  L3 w0.127: DCIN1.3 52.12,30.5 52.74,31.11 v3(55.53,31.11)
  BOTTOM w0.102: v3(55.53,31.11) 56.19,31.78 v2(56.19,32.66) 56.19,33.82 L15.1 56.1,35.75 55.28,36.58 55.28,38.99 v3(55.53,39.24)
JDREF: length 3.2
  TOP w0.203: 166.58,78.69 166.15,78.25 U6.35
  TOP w0.254: R268.1 167.03,79.44 v3(166.58,78.99) 166.58,78.69
  BOTTOM w0.254: v3(166.58,78.99) v2(167.39,78.99)
JENK#: length 4.1
  TOP w0.102: U4101.28 91.72,62.61 93.75,64.64 TP4125.1
JTAG_TCK_VGA: length 9.9
  TOP w0.102: R963.1 81.06,83.06 v3(80.81,82.8) 78.93,84.68 78.93,89.27 GPU1.L3
  BOTTOM w0.102: v2(80.93,81.92) 80.93,82.68 v3(80.81,82.8)
JTAG_TDI_VGA: length 9.3
  TOP w0.102: GPU1.L5 78.98,90.42 78.98,89.65 79.13,89.32 79.13,85.75 v3(80.81,84.07) R1892.1
  BOTTOM w0.102: v2(80.17,84.71) v3(80.81,84.07)
JTAG_TDO_VGA: length 12.8
  TOP w0.102: GPU1.K4 78.26,89.94 78.26,89.12 78.27,89.11 78.27,89.06 78.48,88.86 78.48,87.59 77.88,87 v3(77.88,85.72) 77.88,85.5 78.01,85.37 78.01,83.95 80.93,81.03 R1895.1
  BOTTOM w0.102: v3(77.88,85.72) 77.5,85.34 v2(77.12,85.34)
JTAG_TMS_VGA: length 10
  TOP w0.102: GPU1.L1 78.68,89.12 78.68,84.04 v3(79.92,82.8) 80.68,82.04 R80086.1
  BOTTOM w0.102: v2(79.66,81.92) 79.66,82.55 v3(79.92,82.8)
JTAG_TRST#_VGA: length 8
  TOP w0.102: v4(78.07,91.11) 78.11,91.11 GPU1.L6
  BOTTOM w0.102: R1893.1 78.2,84.52 78.52,84.84 78.52,88.72 78.07,89.17 v2(78.07,89.23) v4(78.07,91.11)
KBCLK: length 5
  TOP w0.102: U109.78 135.81,48.07 135.06,47.32 135.06,47.02 v1(134.86,46.82) 134.86,46.81 134.53,46.49 RN3.3
KBRST_N: length 5.2
  TOP w0.102: U109.42 130.04,59.37 130.36,59.69 v3(130.36,60.07)
  BOTTOM w0.102: v3(130.36,60.07) 130.51,60.22 130.51,61.52 v2(130.39,61.65) 129.88,61.65 129.51,61.28 R80130.2
KDAT: length 5.1
  TOP w0.102: U109.77 135.41,48.31 134.3,47.19 134.3,47.05 134.3,47.05 134.3,46.53 133.92,46.15 v1(133.92,45.71) 133.88,45.67 RN3.4
L_AD0: length 179.5
  TOP w0.089: CPU1.AY13 93.09,152 93.35,152.27 93.74,152.27 93.76,152.26 93.88,152.23 94.12,152.23 94.21,152.27 94.91,152.27 95.83,151.35
  TOP w0.102: v3(127.03,60.96) 127.04,60.97 U109.38 ; LPC1.5 104.18,47.75 v1(103.41,47.75) 103.03,47.37 101.25,47.37 100.62,48.01 R79703.2 ; 95.83,151.35 96.34,150.84 98.96,150.84 101.25,148.54 101.25,145.86 105.57,141.54 105.57,126.42 104.15,125 104.15,118.78 105.43,117.5 126.59,117.5 130.17,113.92 135.96,113.92 143.21,106.67 143.21,95.94 v3(140.88,93.6)
  L3 w0.127: v3(140.88,93.6) 140.22,92.94 140.22,81.92 139.12,80.83 139.12,75.31 138.34,74.52 138.34,71.68 135.21,68.55 130.89,68.55 127.03,64.7 v3(127.03,60.96) 126.94,60.96 126.47,60.49 126.41,60.49 123.86,57.94 123.86,57.37 122.87,56.39 111.61,56.39 110.02,54.79 110.02,53.59 LPC1.5
  BOTTOM w0.102: v3(127.03,60.96) 126.58,60.5 125.74,60.5 125.23,60 RN1.1
L_AD1: length 179.8
  TOP w0.102: LPC1.7 110.19,53.44 108.68,53.44 107.98,52.74 107.98,52.19 104.18,48.39 102.78,48.39 102.4,48.01 v1(101.63,48.01) 100.62,49.02 R79702.2 ; v3(126.14,59.56) 126.78,60.2 127.54,60.2 127.91,60.57 U109.39 ; v3(140.88,94.36) 140.42,94.82 140.42,95.31 140.74,95.63 141.01,95.63 142.65,97.27 142.65,106.44 135.73,113.36 129.94,113.36 126.36,116.94 105.2,116.94 103.59,118.55 103.59,125.23 105.01,126.65 105.01,141.31 100.69,145.63 100.69,148.48 98.73,150.44 96.17,150.44 94.97,151.65 94.24,151.65 93.88,152 CPU1.BA13
  L3 w0.127: v3(140.88,94.36) 141.35,93.89 141.35,90.36 140.52,89.53 140.52,81.79 139.43,80.7 139.43,75.13 138.72,74.42 138.72,71.63 135.34,68.25 131.02,68.25 127.5,64.74 127.5,60.77 127.19,60.45 127.03,60.45 v3(126.14,59.56) 124.24,57.66 124.24,57.32 122.82,55.91 113.13,55.91 112.17,54.95 112.17,53.75 LPC1.7
  BOTTOM w0.102: v3(126.14,59.56) 126.14,59.18 125.63,58.67 RN1.2
L_AD2: length 178.6
  TOP w0.102: R79701.2 101.65,51.23 102.45,51.23 v3(102.9,51.69) ; CPU1.BB13 94.46,151.86 95.04,151.86 96.25,150.65 98.8,150.65 100.97,148.47 100.97,145.75 105.29,141.43 105.29,126.54 103.87,125.11 103.87,118.67 105.31,117.22 126.47,117.22 130.06,113.64 135.85,113.64 142.93,106.55 142.93,97.15 140.9,95.12 v3(140.88,95.12) ; v3(126.91,59.56) 127.29,59.56 127.89,60.17 U109.40
  L3 w0.127: v3(102.9,51.69) 106.97,51.69 108.07,50.58 112.88,50.58 113.28,50.99 113.28,52.36 LPC1.9 114.08,53.65 114.08,54.86 114.82,55.6 122.95,55.6 124.62,57.27 124.62,57.28 v3(126.91,59.56) 128.05,60.71 128.05,64.85 131.14,67.94 135.7,67.94 139.73,71.98 139.73,80.58 140.83,81.67 140.83,89.4 141.65,90.23 141.65,94.35 v3(140.88,95.12)
  BOTTOM w0.102: RN1.3 126.27,58.17 v2(126.27,58.17) 126.4,58.29 126.4,59.05 v3(126.91,59.56)
L_AD3: length 181.8
  TOP w0.089: CPU1.AY12 92.97,151.72 93.53,151.72 93.8,151.45
  TOP w0.102: v3(102.14,51.69) 101.32,52.51 R79700.2 ; U109.41 127.87,59.77 v3(126.91,58.8) ; v3(140.88,96.14) 142.37,97.64 142.37,106.32 135.62,113.08 129.82,113.08 126.24,116.66 105.08,116.66 103.31,118.43 103.31,125.35 104.73,126.77 104.73,141.2 100.41,145.51 100.41,148.46 98.62,150.25 96.09,150.25 94.9,151.45 93.8,151.45
  L3 w0.127: v3(140.88,96.14) 141.96,95.06 141.96,90.1 141.13,89.28 141.13,81.54 140.11,80.53 140.11,71.93 135.5,67.31 130.94,67.31 128.35,64.72 128.35,60.25 v3(126.91,58.8) 123.4,55.3 119.16,55.3 118.35,54.48 118.35,52.72 117.38,51.76 115.88,51.76 LPC1.11 115.03,52.17 112.96,50.1 103.73,50.1 v3(102.14,51.69)
  BOTTOM w0.102: v2(125.26,56.39) 125.23,56.41 RN1.4 126.36,57.52 126.91,58.06 v3(126.91,58.8)
L_BKLTCTL: length 144.9
  TOP w0.165: v3(75.14,128.6) 74.94,128.8 65.39,128.8 62.87,126.28 38.09,126.28 v3(36.61,127.76) ; R79777.2 46.2,57.62 v1(46.13,57.68) 46.13,58.85 44.76,60.22 44.76,63.99 v3(44.61,64.14) ; CPU1.R11 79.49,150.67 v4(79.16,151)
  L3 w0.165: v3(36.61,127.76) 36.61,127.25 33.26,123.91 33.26,86.73 43.75,76.25 43.75,66.4 44.61,65.53 v3(44.61,64.14)
  BOTTOM w0.165: v3(75.14,128.6) 74.14,129.6 74.14,136.26 73.33,137.06 73.33,140.13 v2(73.88,140.68) 75.72,142.51 75.72,143.71 77.68,145.67 77.68,147.96 78.57,148.85 78.57,150.42 79.15,151 v4(79.16,151)
L_FRAME_N: length 161.8
  TOP w0.102: v3(140.88,96.9) 142.1,98.12 142.1,106.21 135.5,112.8 129.71,112.8 126.13,116.38 104.97,116.38 103.03,118.32 103.03,125.46 104.45,126.88 104.45,139.04 102.52,140.97 R1801.1 ; R79698.2 102.01,55.88 v3(102.14,56.01) ; v3(112.81,51.18) 115.61,51.18 LPC1.13 117.91,53.49 117.91,55.27 119.84,57.2 120.67,57.2 R327.1 R324.2 124.3,59.82 v1(125,59.82) 125.13,59.82 v3(126.27,60.96) 126.73,61.42 127.72,61.42 127.77,61.37 U109.37
  L3 w0.127: v3(140.88,96.9) 139.91,95.94 139.91,82.05 138.72,80.85 138.72,79.25 138.72,75.34 138.01,74.63 138.01,71.78 135.09,68.86 130.76,68.86 126.65,64.75 126.65,61.67 126.27,61.29 v3(126.27,60.96) ; v3(112.81,51.18) 112.3,51.69 108.74,51.69 107.98,52.45 107.98,55.24 107.6,55.63 104.3,55.63 103.41,54.74 101.93,54.74 101.63,55.03 101.63,55.5 v3(102.14,56.01)
L_FRAME_N_R: length 15.1
  TOP w0.089: CPU1.BA12 93.52,151.26 94.82,151.26
  TOP w0.102: R1801.2 102.52,142.49 v1(101.63,143.38) 101.63,143.66 100.13,145.16 100.13,148.47 98.57,150.04 96.04,150.04 94.82,151.26
LAD0_FWH0_EC: length 8.3
  TOP w0.102: R79703.1 98.92,48.01 v1(98.31,48.62) 98.03,48.9 96.74,48.9 96.25,49.39 96.25,51.78 95.32,52.7 U4101.62
LAD1_FWH1_EC: length 7.3
  TOP w0.102: U4101.63 95.72,52.7 96.81,51.61 v1(96.81,50.93) 96.81,49.56 97.19,49.17 99.39,49.17 R79702.1
LAD2_FWH2_EC: length 6.1
  TOP w0.102: R79701.1 99.66,50.8 v1(98.61,50.8) 96.78,52.63 96.78,53.31 96.68,53.42 U4101.64
LAD3_FWH3_EC: length 4.7
  TOP w0.102: U4101.1 97.37,53.47 98.41,52.43 v1(99.3,52.43) 100.27,52.43 R79700.1
LAN_DISABLE_N: length 271
  TOP w0.089: 95.83,153.58 95.44,153.97 93.96,153.97 93.77,154.17 92.86,154.17 92.6,154.43 CPU1.AW17
  TOP w0.102: 95.83,153.58 96.15,153.26 100.38,153.26 100.66,153.54 104.14,153.54 110.93,146.76 110.93,134.7 111.26,134.37 111.26,127.29 R80054.1 109,124.02 109,121.46 111.16,119.3 v3(111.16,118.75)
  L3 w0.127: v3(43.34,129.29) 42.71,129.92 38.33,129.92 37.95,130.3 36.19,130.3 35.97,130.52 35.4,130.52 31.85,126.97 31.85,42.59 31.66,42.4 31.66,42.04 28.01,38.39 28.01,30.7 30.13,28.57 30.13,23.62 34.45,19.3 40.55,19.3 42.71,17.14 v3(42.71,12.12)
  L4 w0.127: v3(43.34,129.29) 45.49,127.14 63.74,127.14 65.91,129.31 72.09,129.31 83.52,117.88 110.29,117.88 v3(111.16,118.75)
  BOTTOM w0.102: R774.1 v2(44.23,9.96) 44.23,10.31 43.41,11.13 43.41,11.41 v3(42.71,12.12)
LAN_DISABLE_N_1: length 8
  BOTTOM w0.254: Q102.B 44.66,7.94 R774.2 C591.1 ; Q102.B 46.41,7.06 48.15,7.06 R1180.1 ; Q102.B 45.53,8.79 v2(46.08,9.35)
LAN_DISABLE_N_2: length 8.7
  TOP w0.254: v3(46.01,4.83) 46.55,5.37 Q101.B
  BOTTOM w0.254: R764.1 R1180.2 48.7,5.42 48.7,4.37 v2(48.52,4.19) 48.5,4.17 47.56,4.17 46.52,5.21 Q102.C 46.35,6.03 46.01,5.69 v3(46.01,4.83)
LAN_DISABLE_N_3: length 8.9
  TOP w0.102: R775.2 47.72,9.65 48.53,9.65 v1(48.78,9.4) 48.78,9.4 48.78,9.18 Q101.C 46.96,7.37 46.2,7.37 R776.1 44.86,7.94 Q100.C
LAN_DISABLE_N_4: length 12.5
  TOP w0.102: v3(43.82,4.72) 43.24,5.31 43.24,6.41 43.61,6.78 44.88,6.78 C593.1 R776.2
  BOTTOM w0.102: PC140.2 39.53,5.4 39.53,4.45 39.96,4.01 v2(42.92,4.01) 43.11,4.01 v3(43.82,4.72) 42.96,5.59 42.96,5.74
LAN_DISABLE_V3: length 5.6
  TOP w0.102: v1(40.95,4.34) 41.26,4.65 41.26,5.31 Q100.B 41.59,6.41 R1183.1 ; C863.1 R1183.1 ; R1183.1 R1194.2
LAN_LEDACT_R#: length 6.2
  TOP w0.254: UR5.2 v3(82.56,25.04) 82.56,22.32 RJ1.10
  BOTTOM w0.254: v2(81.72,25.04) v3(82.56,25.04)
LAN_MDI0_C_DN: length 28
  TOP w0.089: XF1.2 61.42,8.76 61.88,8.3 62.19,8.3 62.48,8.01 62.48,7.67 62.57,7.58 62.86,7.58 v3(63.03,7.75) ; RJ1.2 v3(80.1,10.4)
  L4 w0.102: v3(80.1,10.4) 80.76,10.4 80.89,10.27 80.89,8 79.87,6.99 64.34,6.99 63.8,7.53 63.24,7.53 v3(63.03,7.75)
  BOTTOM w0.089: v2(80.1,11.21) v3(80.1,10.4)
LAN_MDI0_C_DP: length 27.9
  TOP w0.089: RJ1.1 v3(81.37,10.4) ; XF1.1 61.37,7.49 61.84,7.96 62.05,7.96 62.14,7.87 62.14,7.53 62.43,7.24 62.77,7.24 v3(63.03,6.99)
  L4 w0.102: v3(81.37,10.4) 81.34,10.4 81.22,10.27 81.22,7.86 80.01,6.65 64.21,6.65 63.66,7.2 63.24,7.2 v3(63.03,6.99)
  BOTTOM w0.089: v2(81.37,9.58) v3(81.37,10.4)
LAN_MDI0_DN: length 16.4
  TOP w0.089: 43.51,12.48 45,10.99 U10.3 46.43,10.99 46.77,11.33 47.91,11.33 48.03,11.45 49.54,11.45 49.78,11.21 49.78,8.78 50.26,8.3 50.71,8.3 51.17,8.76 XF1.11 ; 43.51,12.48 42.54,13.45 40.79,13.45 40.38,13.86 U16.2 ; 43.51,12.48 v1(43.8,12.78)
LAN_MDI0_DP: length 16.4
  TOP w0.089: 44.53,10.97 42.4,13.11 40.65,13.11 40.3,13.46 U16.1 ; 44.53,10.97 44.86,10.64 45.37,10.64 45.6,10.41 46.9,10.41 47.02,10.54 47.02,10.92 47.09,10.99 U10.4 49.13,10.99 49.44,10.68 49.44,8.64 50.12,7.96 50.71,7.96 51.17,7.49 XF1.12 ; 44.53,10.97 v1(44.25,10.69)
LAN_MDI1_C_DN: length 29.8
  TOP w0.089: RJ1.6 v3(75.02,10.4) ; XF1.6 61.42,16.38 61.88,15.92 62.19,15.92 62.48,15.63 62.48,15.29 62.57,15.2 62.86,15.2 v3(63.03,15.37)
  L4 w0.102: v3(75.02,10.4) 75.02,9.85 75.22,9.65 76.74,9.65 76.87,9.53 76.87,8.51 76.61,8.26 65.57,8.26 64.55,9.27 64.55,14.5 63.9,15.15 63.24,15.15 v3(63.03,15.37)
  BOTTOM w0.089: v2(75.02,11.21) v3(75.02,10.4)
LAN_MDI1_C_DP: length 29.8
  TOP w0.089: XF1.5 61.37,15.11 61.84,15.58 62.05,15.58 62.14,15.49 62.14,15.15 62.43,14.86 62.77,14.86 v3(63.03,14.61) ; RJ1.3 v3(78.83,10.4)
  L4 w0.102: v3(78.83,10.4) 78.08,9.65 77.39,9.65 77.2,9.46 77.2,8.37 76.75,7.92 65.43,7.92 64.22,9.13 64.22,14.37 63.77,14.82 63.24,14.82 v3(63.03,14.61)
  BOTTOM w0.089: v2(78.83,9.58) v3(78.83,10.4)
LAN_MDI1_DN: length 15.2
  TOP w0.089: U16.5 40.54,15.06 40.6,15 42.84,15 44.95,12.89 U10.1 46.83,12.89 47.02,13.08 47.91,13.08 48.29,13.46 49.18,13.46 49.35,13.63 49.35,14.5 ; XF1.7 51.21,16.38 50.75,15.92 50.31,15.92 49.35,14.96 49.35,14.5 ; v1(48.93,14.5) 49.35,14.5
LAN_MDI1_DP: length 15.2
  TOP w0.089: XF1.8 51.21,15.11 50.75,15.58 50.45,15.58 49.69,14.81 49.69,13.48 49.1,12.89 U10.6 48.21,12.89 48.05,12.74 47.19,12.74 46.88,12.43 45.49,12.43 45.37,12.55 44.81,12.55 42.7,14.66 41.94,14.66 ; U16.4 41.94,14.66 ; 41.94,14.66 v1(41.94,14.25)
LAN_MDI2_C_DN: length 23.8
  TOP w0.089: RJ1.5 v3(76.29,10.4)
  L3 w0.102: v3(63.03,9.27) 63.24,9.06 63.96,9.06 65.29,7.73 76.23,7.73 77.02,8.51 77.02,10.27 76.89,10.4 v3(76.29,10.4)
  BOTTOM w0.089: v3(63.03,9.27) 62.77,9.02 62.39,9.02 62.08,8.71 62.08,8.39 61.99,8.3 61.88,8.3 61.42,8.76 XF2.5 ; v2(76.28,9.58) 76.28,10.39 v3(76.29,10.4)
LAN_MDI2_C_DP: length 23.7
  TOP w0.089: RJ1.4 v3(77.56,10.4)
  L3 w0.102: v3(63.03,8.51) 63.24,8.72 63.83,8.72 65.15,7.4 76.37,7.4 77.35,8.37 77.35,10.19 v3(77.56,10.4)
  BOTTOM w0.089: v3(63.03,8.51) 62.86,8.67 62.53,8.67 62.43,8.57 62.43,8.25 62.14,7.96 61.88,7.96 61.42,7.49 XF2.6 ; v2(77.56,11.23) v3(77.56,10.4)
LAN_MDI2_DN: length 16.7
  TOP w0.089: P5480.2 44.1,16.76 v3(44.23,16.64)
  BOTTOM w0.089: 44.86,14.4 44.86,13.46 44.61,13.21 44.61,11.68 44.84,11.45 47.02,11.45 47.49,10.99 U11.3 49.12,10.99 49.78,10.33 49.78,8.78 50.26,8.3 50.73,8.3 51.19,8.76 XF2.8 ; 44.86,14.4 44.86,14.73 45.37,15.24 45.37,16 44.99,16.38 44.48,16.38 v3(44.23,16.64) ; 44.86,14.4 v2(45.19,14.4)
LAN_MDI2_DN_R: length 3.3
  TOP w0.089: v1(41.51,16.59) 41.77,16.33 ; 41.77,16.33 41.23,15.8 40.42,15.8 40.36,15.86 U16.7 ; 41.77,16.33 41.82,16.38 42.13,16.38 P5480.1
LAN_MDI2_DP: length 16.7
  TOP w0.089: P5479.2 44.1,15.75 v3(44.23,15.88)
  BOTTOM w0.089: 44.27,12.78 44.27,11.54 44.7,11.11 46.11,11.11 U11.4 47,10.99 47.34,10.64 48.19,10.64 48.42,10.41 49.2,10.41 49.44,10.18 49.44,8.64 50.12,7.96 50.71,7.96 51.17,7.49 XF2.7 ; 44.27,12.78 v2(43.92,12.78) ; 44.27,12.78 44.27,13.35 44.52,13.6 44.52,14.87 45.03,15.38 45.03,15.86 44.85,16.04 44.39,16.04 v3(44.23,15.88)
LAN_MDI2_DP_R: length 2.9
  TOP w0.089: P5479.1 42.22,16.04 41.96,16.04 41.38,15.46 U16.6
LAN_MDI3_C_DN: length 24.9
  TOP w0.089: RJ1.8 v3(72.48,10.4)
  L3 w0.102: v3(63.03,16.89) 63.24,16.68 64.05,16.68 64.75,15.97 64.75,10.3 66.08,8.97 72.93,8.97 73.11,9.14 73.11,10.29 73,10.4 v3(72.48,10.4)
  BOTTOM w0.089: v2(72.48,11.21) v3(72.48,10.4) ; XF2.1 61.42,16.38 61.88,15.92 61.99,15.92 62.08,16.01 62.08,16.33 62.39,16.64 62.77,16.64 v3(63.03,16.89)
LAN_MDI3_C_DP: length 24.9
  TOP w0.089: RJ1.7 v3(73.75,10.4)
  L3 w0.102: v3(63.03,16.13) 63.24,16.34 63.91,16.34 64.42,15.84 64.42,10.16 65.95,8.64 73.07,8.64 73.44,9.01 73.44,10.09 v3(73.75,10.4)
  BOTTOM w0.089: v3(63.03,16.13) 62.86,16.29 62.53,16.29 62.43,16.19 62.43,15.87 62.14,15.58 61.88,15.58 61.42,15.11 XF2.2 ; v3(73.75,10.4) 73.74,10.4 v2(73.74,9.58)
LAN_MDI3_DN: length 16.8
  TOP w0.089: v3(44.23,18.92) 43.98,19.18 P5482.2
  BOTTOM w0.089: XF2.12 51.21,16.38 50.75,15.92 50.31,15.92 49.35,14.96 49.35,13.1 49.14,12.89 U11.1 48.54,12.89 48.42,12.77 47.14,12.77 47.02,12.89 47.02,13.34 46.9,13.46 46.22,13.46 46.13,13.55 46.13,14.25 46.6,14.72 46.6,15.95 ; 46.6,15.95 46.6,17.2 45.13,18.67 44.48,18.67 v3(44.23,18.92) ; 46.6,15.95 v2(46.95,15.95)
LAN_MDI3_DN_R: length 5.2
  TOP w0.089: U16.10 38.88,17.36 39.64,18.12 39.99,18.12 ; v1(39.99,18.54) 39.99,18.12 ; 39.99,18.12 40.51,18.12 41.56,19.18 P5482.1
LAN_MDI3_DP: length 16.8
  TOP w0.089: P5481.2 v3(44.23,18.16)
  BOTTOM w0.089: XF2.11 51.21,15.11 50.75,15.58 50.45,15.58 49.69,14.81 49.69,12.55 49.56,12.43 46.92,12.43 46.45,12.89 U11.6 46.07,12.89 45.79,13.17 45.79,14.39 46.26,14.86 46.26,17.06 45.54,17.77 ; 45.54,17.77 44.99,18.33 44.39,18.33 v3(44.23,18.16) ; 45.54,17.77 v2(45.3,17.53)
LAN_MDI3_DP_R: length 5.2
  TOP w0.089: 41.14,18.27 41.7,18.83 41.91,18.83 42.03,18.71 42.03,18.22 42.1,18.16 P5481.1 ; 41.14,18.27 40.65,17.78 39.78,17.78 39.28,17.28 U16.9 ; 41.14,18.27 v1(41.44,17.98)
LAN_RSET: length 4.5
  TOP w0.102: U16.31 38.88,12.77 38.88,11.06 39.58,10.36 v1(40.04,10.36) 40.99,9.41 R412.2
LAN_XTALI: length 9.7
  TOP w0.102: X4.1 36.74,7.15 v3(36.74,8.31) 36.74,8.33 35.97,9.09 R407.2 36.16,9.33 C1800.1 36.67,10.79 37.45,10.79 37.74,11.08 37.74,12.21 37.68,12.26 U16.28
  BOTTOM w0.102: v3(36.74,8.31) 36.36,8.31 v2(36,8.66)
LAN_XTALO: length 5.5
  TOP w0.102: v3(37.02,10.29) 37.07,10.34 R80241.1 ; R80241.1 37.82,9.46 R407.1 ; R80241.1 37.96,10.49 37.96,12.15 38.08,12.26 U16.29
  BOTTOM w0.102: v2(37.02,9.47) v3(37.02,10.29)
LAN_XTALO_C: length 4
  TOP w0.102: X4.3 37.91,8.08 v3(38.39,8.56) 38.7,8.88 C1799.1 R80241.2
  BOTTOM w0.102: v2(38.39,9.37) v3(38.39,8.56)
LANCLK_REQ_N: length 232.5
  TOP w0.102: R413.2 36.99,19.46 36.43,18.9 31.61,18.9 v3(31.28,18.57)
  L3 w0.127: v3(31.28,18.57) 32.12,19.42 32.12,21.19 29.75,23.56 29.75,28.42 27.76,30.41 27.76,38.5 31.4,42.14 31.4,42.5 31.59,42.69 31.59,127.07 35.53,131.01 35.8,131.01 v3(36.36,131.57)
  L4 w0.127: v3(106.97,110.36) 105.44,110.36 100.93,114.87 82.51,114.87 70.89,126.49 67.28,126.49 65.11,124.32 43.61,124.32 v3(36.36,131.57)
  BOTTOM w0.102: R80065.2 R79759.2 108.57,130.87 109.33,130.11 v2(109.33,129.62) 109.33,125.68 105.24,121.59 105.24,112.85 106.51,111.58 106.51,110.82 v3(106.97,110.36)
LANCLK_REQ_U_N: length 2.9
  TOP w0.102: R413.1 37.8,18.88 v1(37.8,18.47) 37.8,17.94 38.08,17.66 U16.12
LDR: length 6
  BOTTOM w0.305: U120.1 38.88,27.42 39.15,27.69
  BOTTOM w0.508: 39.15,27.69 39.15,28.47 39.89,29.21 v2(39.94,29.21) 39.94,29.25 42.02,31.34 R65.2
LDR_1: length 5
  BOTTOM w0.508: v2(43.61,33.4) Q1250.4 41.05,33.4 40.09,32.44 R65.1
LDRQ#: length 9.6
  TOP w0.102: U109.2 142.61,65.68 142.58,65.71 142.58,66.86 144.47,68.76 145.19,68.76 v1(145.37,68.58) 146.6,68.58 146.98,68.96 148.18,68.96 R79935.1
LDRQ#_EC: length 3.3
  TOP w0.102: R79704.1 95.56,50.64 v1(95.56,51.67) 95.54,51.69 95.54,51.69 94.92,52.3 U4101.61
LED_5VSB: length 2.6
  TOP w0.254: v1(139.91,40.13) R1767.2 LED2.A
LEDC_ISET: length 4.8
  BOTTOM w0.102: U120.12 33.26,25.92 32.41,26.77 32.02,26.77 v2(31.56,27.22) 30.64,28.15 R82.1
LFRAMEJ_FW4_EC: length 3.3
  TOP w0.102: U4101.3 99.24,55.46 v1(99.28,55.42) 99.97,55.42 R79698.1
LINE2-VREFO: length 9.6
  TOP w0.203: R261.1 169.37,74.87 168.9,75.34 168.79,75.34 v3(168.77,75.36) ; R272.1 169.77,78.11 v3(169.07,78.11) ; U6.29 167,75.85 v3(167.17,75.69)
  L3 w0.203: v3(169.07,78.11) 168.77,77.8 v3(168.77,75.36) 168.21,75.92 167.39,75.92 v3(167.17,75.69)
  BOTTOM w0.203: v2(169.88,78.11) v3(169.07,78.11)
LINEOUT-JD: length 181.7
  TOP w0.203: LOUT1.Q 83.54,33.76 v1(84.67,32.64) 85.05,32.64 86.82,30.86 86.82,3.46 88.45,1.83 152.3,1.83 153.37,2.9 153.37,14.72 155.36,16.71 158.35,16.71 159.55,17.91 159.55,22.33 168.03,30.81 168.03,60.1 166.96,61.16 166.96,67.62 169.96,70.61 R266.1
LINEOUT-L: length 181.9
  TOP w0.203: R429.1 87.28,31.05 87.28,3.65 88.64,2.29 152.11,2.29 152.92,3.09 152.92,14.91 155.17,17.17 158.16,17.17 159.09,18.1 159.09,22.52 167.57,31 167.57,59.61 v1(167.11,60.07) 166.51,60.68 166.51,66.33 165.25,67.59 163.12,67.59 161.6,69.11 161.6,71.5 162.79,72.69 U6.19
LINEOUT-R: length 180
  TOP w0.203: U6.18 162.39,72.83 161.15,71.58 161.15,68.68 v1(161.83,68) 162.69,67.13 164.63,67.13 166.05,65.71 166.05,60.27 167.11,59.21 167.11,31.19 158.63,22.71 158.63,18.29 157.97,17.63 155.36,17.63 154.98,17.63 152.46,15.1 152.46,3.28 151.93,2.74 88.83,2.74 87.74,3.84 87.74,31.24 84.49,34.49 R428.1
LINEOUT_C-L: length 3.3
  TOP w0.203: L62.1 82.82,36.89 v3(82.33,36.4) 82.85,35.88 R429.2
  BOTTOM w0.203: v2(83.14,36.4) v3(82.33,36.4)
LINEOUT_C-R: length 2.8
  TOP w0.203: L20.1 85.21,36.89 85.61,36.5 v1(85.61,36.32) 85.61,36.27 85.21,35.88 R428.2
LINEOUT_CON-L: length 14.3
  TOP w0.203: LOUT1.4 83.13,42.66 Q46.1 83.15,41.72 v3(83.09,41.66) ; L62.2 83.41,37.85 C268.1 83.41,39.31 v3(83.09,39.62)
  L3 w0.203: v3(83.09,41.66) v3(83.09,39.62)
  BOTTOM w0.203: v2(83.98,41.66) v3(83.09,41.66)
LINEOUT_CON-R: length 21
  TOP w0.203: L20.2 84.55,37.85 C267.1 84.55,39.15 v3(84.06,39.65) 84.06,39.77 Q46.2 81.66,42.16 78.39,42.16 76.61,40.39 76.61,34.49 LOUT1.1
  BOTTOM w0.203: v2(84.06,38.48) v3(84.06,39.65)
LINK_ACTIVITY_N: length 88.7
  TOP w0.203: U16.27 v3(37.28,11.28)
  TOP w0.254: v3(53.25,4.83) 53.76,4.31 53.77,4.31 54.14,3.94 54.14,3.93 54.41,3.66 83.78,3.66 84.19,4.08 84.19,13.56 85.17,14.54 85.17,27.61 84.87,27.91 84.62,27.91 v1(84.58,27.95) 84.56,27.94 83.76,27.94 UR5.1 81.12,26.73 v3(80.93,26.92) ; v3(76.87,30.73) 76.66,30.53 U12.4
  L3 w0.254: v3(76.87,30.73) 80.68,26.92 v3(80.93,26.92)
  L4 w0.254: v3(53.25,4.83) 52.71,4.29 51.24,4.29 50.07,5.46 45.88,5.46 41.44,9.91 41.44,10.74 40.34,11.84 37.84,11.84 v3(37.28,11.28)
LINK_PWR: length 5.7
  TOP w0.254: RJ1.9 83.57,21.05 v3(83.57,25.04) R79618.1
  BOTTOM w0.254: v2(84.44,25.04) v3(83.57,25.04)
LPC_CLK0: length 144.8
  TOP w0.102: v3(140.88,99.19) 141.33,99.64 141.33,105.89 135.73,111.5 v1(134.07,111.5) 134.07,111.5 133.56,112.01 129.42,112.01 125.81,115.62 104.65,115.62 102.27,118 102.27,125.89 103.67,127.29 103.67,135.7 R80072.1 ; v3(102.14,55.24) 101.76,54.86 R79699.2 R80183.2
  L3 w0.127: v3(102.14,55.24) 102.65,55.24 104.68,57.28 121.47,57.28 125,60.8 125,61.17 125.84,62.01 125.84,65.14 130.42,69.72 134.7,69.72 136.13,71.16 136.13,74.25 137.9,76.02 137.9,78.91 137.9,81.19 139.1,82.38 139.1,97.41 v3(140.88,99.19)
LPC_CLK0_R: length 20
  TOP w0.089: CPU1.AW9 92.59,149.58 92.99,149.98 94.07,149.98 94.18,150.02 94.54,150.02 95.06,149.5 95.06,149.4
  TOP w0.102: 95.06,149.4 95.46,149 96.78,149 97.06,148.72 97.06,147.73 97.39,147.4 97.92,147.4 98.31,147.01 98.31,146.04 97.96,145.7 97.96,144.4 98.5,143.87 98.5,142.46 v1(99.73,141.22) 103.03,137.92 R80072.2
LPC_CLK1: length 117.5
  TOP w0.102: v3(131.12,60.07) 131.12,59.64 130.05,58.57 U109.44 ; v3(140.88,99.95) 140.42,100.41 140.42,106.12 136.43,110.11 134.53,110.11 133.54,111.1 131.45,111.1 v1(131.1,111.46) 129.29,111.46 125.61,115.14 104.45,115.14 101.79,117.8 101.79,118.2 101.79,126.09 103.03,127.33 R80073.1
  L3 w0.127: v3(140.88,99.95) 142.46,98.36 142.46,89.81 141.64,88.98 141.64,81.33 140.62,80.31 140.62,71.72 135.71,66.8 131.33,66.8 130.61,66.09 130.61,64.67 129.85,63.91 129.85,61.34 v3(131.12,60.07)
LPC_CLK1_R: length 20
  TOP w0.089: 95.67,147.45 93.89,149.23 93.6,149.23 93.25,149.58 CPU1.AY9
  TOP w0.102: R80073.2 v1(103.03,135) 102.01,136.02 102.01,138.15 97.78,142.38 97.78,144.06 95.89,145.95 95.89,147.23 95.67,147.45
LPC_CLK_D: length 6.4
  TOP w0.102: R80183.1 100.43,53.45 100.67,53.21 101.89,53.21 v3(102.14,53.47)
  L3 w0.127: v3(102.14,53.47) 103,52.61 LPC1.1
  BOTTOM w0.102: v2(102.14,52.58) v3(102.14,53.47)
LPC_CLKRUN#_CPU: length 21
  TOP w0.102: v4(91.81,150.78) 91.81,150.78 91.83,150.78 91.89,150.84 92.06,150.84 92.08,150.86 CPU1.AW11
  BOTTOM w0.102: R80067.1 R80212.2 105.23,140.23 102.35,140.23 95.66,146.92 v2(95.66,147.35) 95.66,147.82 92.71,150.78 v4(91.81,150.78)
LPC_PME#: length 4.7
  TOP w0.102: v3(132.49,50.42) 132.61,50.3 U109.70
  BOTTOM w0.102: R79837.1 132.47,47.99 v2(132.47,48.62) 132.47,49.19 R253.2 132.81,50.1 v3(132.49,50.42)
LPC_PME_N: length 238
  TOP w0.102: v4(90.87,150.55) 91.2,150.87 CPU1.AU11 ; R79838.2 80.74,49.52 v3(80.27,49.99)
  L3 w0.127: v3(122.21,60.96) 122.21,62.05 121.09,63.16 114.05,63.16 113.19,62.3 113.19,60.3 112.32,59.43 99.73,59.43 v3(99.6,59.3)
  L4 w0.127: v3(140.37,118.67) 140.07,118.67 136.87,115.47 136.79,115.47 128.17,115.47 111.54,132.09 110.9,132.09 110.13,132.09 108.24,133.99 107.18,133.99 94.39,146.77 94.39,147.75 91.84,150.3 91.66,150.3 91.42,150.55 v4(90.87,150.55) ; 99.6,59.3 99.38,59.3 98.02,60.67 96.27,60.67 95.46,61.48 92.34,61.48 91.77,61.48 91.44,61.15 88.3,61.15 87.9,60.74 86.97,60.74 85.19,58.97 84.65,58.97 80.72,55.03 80.72,50.44 v3(80.27,49.99) ; 99.6,59.3 99.6,58.17 98.62,57.19 98.62,54.54 102.96,50.2 122.33,50.2 122.93,50.8 130.97,50.8 v3(131.35,51.18) ; 99.6,59.3 v3(99.6,59.3)
  BOTTOM w0.102: v3(131.35,51.18) 131.33,51.21 130.38,51.21 130.08,50.91 130.08,50.49 130.08,48.6 131.11,47.57 R79837.2 ; v3(122.21,60.96) 122.21,63.09 132.02,72.9 137.78,72.9 v2(137.85,72.97) 138.77,73.89 138.77,74.23 139.68,75.14 139.68,117.98 v3(140.37,118.67) ; R79838.2 80.74,49.52 v3(80.27,49.99)
LPF: length 4.2
  BOTTOM w0.102: U120.9 35.73,23.37 36.59,22.51 v2(36.59,21.88) 36.59,21.6 36.58,21.6 C3455.1
LPSS_UART2_RXD: length 20.1
  TOP w0.089: CPU1.AD1 84.48,143.52 84.62,143.38
  TOP w0.102: 84.62,143.38 84.62,140.46 v4(84.74,140.34) R2040.1
  BOTTOM w0.102: v4(84.74,140.34) 85.17,139.9 85.17,139.46 85.48,139.16 85.48,130.4 v2(84.84,129.77) 84.49,129.41 84.49,126.93 CN3.3
LPSS_UART2_TXD: length 22
  TOP w0.089: CPU1.AD2 84.26,145.12 84.22,145.01 84.22,142.71 84.26,142.62
  TOP w0.102: R2041.1 85,139.32 v4(84.74,139.57) 84.53,139.79 84.53,139.98 84.34,140.17 84.34,140.5 84.34,140.51 84.34,142.54 84.26,142.62
  BOTTOM w0.102: CN3.2 83.6,126.69 v2(83.6,127.69) 83.6,129.32 85.25,130.97 85.25,139.06 v4(84.74,139.57)
LVDS_BL_ADJ: length 5.9
  TOP w0.165: R1984.1 45.12,23.9 v1(45.14,23.88) 44.95,23.69 R133.1 43.59,23.61 43.59,22.8 R131.1 R134.2 R132.1
LVDS_DET_A*: length 135.3
  TOP w0.102: U109.116 145.53,58.17 146.29,58.93 v3(146.59,58.93) ; LVDS1.17 41.21,93.5 v3(41.18,93.47)
  L4 w0.127: v3(41.18,93.47) 41.94,92.71 41.94,86.18 47.7,80.43 51.89,80.43 56.22,76.1 60.19,76.1 64.8,71.49 64.8,70 65.94,68.86 88.48,68.86 90.94,66.4 96.95,66.4 100.44,62.9 101.14,62.9 102.74,61.3 112.09,61.3 113.44,59.94 113.44,58.41 114.35,57.51 120.92,57.51 123.03,59.61 123.03,60.26 124.62,61.85 127.37,61.85 127.83,61.38 135.98,61.38 137.51,59.86 141.77,59.86 141.82,59.91 143.2,59.91 144.18,58.93 v3(146.59,58.93)
  BOTTOM w0.102: R79689.2 41.7,94.28 v2(41.31,94.28) 41.18,94.16 v3(41.18,93.47)
LVDS_DET_B*: length 157.3
  TOP w0.102: v3(42.32,119.13) 42.64,119.44 R79691.2 43.78,119.44 v1(44.36,120.02) 44.99,120.65 Q6705.D ; U109.117 145.47,58.57 v3(146.59,59.69)
  L4 w0.127: v3(146.59,59.69) 143.78,59.69 143.31,60.16 140.46,60.16 138.01,62.61 133.38,62.61 132.66,61.89 127.71,61.89 127.49,62.1 122.44,62.1 121.37,63.17 112.25,63.17 111.14,62.06 102.33,62.06 101.24,63.16 100.54,63.16 97.05,66.65 91.05,66.65 88.58,69.11 66.05,69.11 65.06,70.1 65.06,71.59 60.28,76.37 56.35,76.37 55.22,77.5 54.92,77.8 54.92,77.98 51.54,81.37 47.57,81.37 42.86,86.08 42.86,118.59 v3(42.32,119.13)
LVDS_DET_B_C*: length 17.2
  TOP w0.102: C6718.1 48.39,119.67 Q6705.G 45.78,119.67 45.25,119.13 45.25,115.06 44.99,114.81 v1(44.99,113.54) 45.32,113.21 45.32,110.13 44.69,109.5 LVDS1.1
LVDS_PU_5: length 6.1
  TOP w0.102: R79690.2 44.5,104.33 43.33,105.5 LVDS1.5 41.75,105.5 v3(41.21,106.05)
  BOTTOM w0.102: v3(41.21,106.05) v2(40.39,106.05)
LVDS_PU_6: length 6.3
  TOP w0.102: v3(41.25,104.5) LVDS1.6 43.31,104.5 44.18,103.63 44.18,103.43 45.18,102.43 R79656.2
  BOTTOM w0.102: v2(40.42,104.5) v3(41.25,104.5)
LVDS_PU_6_1: length 10.1
  TOP w0.152: R79656.1 45.18,101.54 v3(44.1,102.62)
  BOTTOM w0.152: v3(44.1,102.62) 44.1,98.53 43.01,97.43 v2(42.5,97.43) 41.69,98.25 Q9647.D
LVDS_PU_24: length 3.7
  TOP w0.102: LVDS1.24 41.42,86.5 v3(41.18,86.74)
  BOTTOM w0.102: v3(41.18,86.74) 41.18,85.96 v2(41.24,85.9) 41.93,85.9 R79687.2
LX:
  vias: v2(34.15,30.61) v5(38.26,36.07) v5(38.26,34.92) v5(38.26,33.78)
M1_SMB_CLK: length 7.6
  TOP w0.102: NGFF1.60 119.99,219.5 120.53,220.04 v1(120.68,220.04) 122.03,220.04 122.99,219.07 R14.2
M1_SMB_DATA: length 5.6
  TOP w0.102: NGFF1.58 120.1,219 120.43,219.33 121.95,219.33 v1(121.95,219.33) 122.21,219.33 123.1,218.44 R1622.2
M_A_A0: length 55.2
  TOP w0.089: CPU1.AY50 93.22,172.92 93.67,172.47 94.56,172.47 94.76,172.67 97.03,172.67 97.08,172.72 97.97,173.61 99.54,173.61 v4(99.97,174.04)
  TOP w0.165: v4(137.9,159.29) 138.14,159.05 DIMM1.98
  L3 w0.089: v4(99.97,174.04) 100.51,173.5 101.49,173.5 102.09,172.9 104.05,172.9 104.27,172.67 104.99,172.67
  L3 w0.216: v4(137.9,159.29) 136.95,158.33 131.39,158.33 130.72,159 127.25,159 113.59,172.67 104.99,172.67
  BOTTOM w0.102: v2(137.65,158.45) 137.65,159.03 v4(137.9,159.29)
M_A_A1: length 56.1
  TOP w0.089: v4(99.01,174.04) 98.64,174.41 98.18,174.41 96.87,173.1 94.65,173.1 94.47,172.92 CPU1.BB50
  TOP w0.165: v4(133.96,160.69) 133.96,159.7 134.73,158.93 134.73,158.04 134.6,157.91 134.16,157.91 134.02,158.06 134.02,158.47 133.23,159.25 133.23,159.82 133.1,159.94 132.54,159.94 132.42,159.82 132.42,159.48 132.29,159.35 DIMM1.97
  L3 w0.089: v4(99.01,174.04) 99.41,174.44 101.13,174.44 101.31,174.26 105.32,174.26
  L3 w0.216: v4(133.96,160.69) 133.79,160.52 133.79,160.49 133.5,160.2 130.97,160.2 129.88,161.29 127.07,161.29 114.1,174.26 105.32,174.26
  BOTTOM w0.102: v4(133.96,160.69) 133.7,160.43 v2(133.7,159.85)
M_A_A2: length 58
  TOP w0.089: v4(100.68,174.04) 100.13,174.59 98.07,174.59 96.81,173.33 94.48,173.33 94.36,173.21 94.09,173.15 93.86,173.15 93.73,173.19 93.29,173.19 93.05,173.31 CPU1.AY51
  TOP w0.165: DIMM1.96 138.33,159.65 138.21,159.77 136.27,159.77 v4(135.81,159.3)
  L3 w0.089: 105.16,173.21 102.2,173.21 101.49,173.91 100.81,173.91 v4(100.68,174.04)
  L3 w0.216: v4(135.81,159.3) 135.81,159.64 135.68,159.77 135.01,159.77 134.89,159.64 134.89,158.86 134.67,158.65 134.24,158.65 134.02,158.86 134.02,159.3 133.81,159.51 133.38,159.51 133.16,159.3 133.16,158.86 132.94,158.65 132.51,158.65 132.3,158.86 132.3,159.3 132.08,159.51 127.85,159.51 127.44,159.51 113.74,173.21 105.16,173.21
  BOTTOM w0.102: v2(135.55,158.47) 135.55,159.05 v4(135.81,159.3)
M_A_A3: length 56.1
  TOP w0.089: v4(98.34,174.01) 98.1,174.01 97.74,173.66 96.93,172.85 94.67,172.85 94.47,172.65 93.92,172.65 93.66,172.9 CPU1.BA50
  TOP w0.165: v4(132.67,160.7) 131.92,159.95 DIMM1.95
  L3 w0.089: 105.29,174.75 97.49,174.75 97.08,175.17 97.08,176.43 96.95,176.56 96.2,176.56 96.07,176.43 96.07,175.06 97.12,174.01 v4(98.34,174.01)
  L3 w0.216: 105.29,174.75 105.29,174.75 114.3,174.75 127.26,161.8 130,161.8 130.93,160.87 132.5,160.87 v4(132.67,160.7)
  BOTTOM w0.102: v2(132.47,159.87) 132.47,160.5 v4(132.67,160.7)
M_A_A4: length 57.3
  TOP w0.089: v4(100.28,175.35) 99.72,175.91 98.04,175.91 96.4,174.27 96.4,174.25 CPU1.BB52
  TOP w0.165: DIMM1.92 138.21,160.85 137.9,161.16 136.81,161.16 v4(136.3,160.66)
  L3 w0.089: v4(100.28,175.35) 100.67,174.96 102.04,174.96 102.33,175.25 105.57,175.25
  L3 w0.216: 105.57,175.25 114.51,175.25 126.96,162.79 129.45,162.79 131.03,161.21 134.15,161.21 134.19,161.17 137.53,161.17 137.83,160.87 137.83,160.44 137.53,160.14 137.11,160.14 136.59,160.66 v4(136.3,160.66)
  BOTTOM w0.102: v4(136.3,160.66) 136.3,160.53 v2(136.84,159.99)
M_A_A5: length 57.6
  TOP w0.089: 98.33,174.88 98.1,174.88 96.78,173.55 94.43,173.55 94.25,173.37 94.07,173.32 93.89,173.32 93.77,173.37 93.62,173.37 CPU1.BA51
  TOP w0.165: v4(102.9,173.67) 103.82,173.67 103.94,173.79 103.94,174.75 103.82,174.88 98.33,174.88 ; DIMM1.91 132.28,161.15 132.6,161.47 134.74,161.47 135.29,160.92 v4(135.29,160.67)
  L3 w0.216: v4(135.29,160.67) 135.29,160.62 134.53,159.86 129.55,159.86 129.4,160.01 127.65,160.01 113.92,173.74 102.97,173.74 v4(102.9,173.67)
  BOTTOM w0.102: v2(135.04,159.83) 135.04,160.41 v4(135.29,160.67)
M_A_A6: length 57
  TOP w0.089: CPU1.BA52 93.94,174.52 96.4,174.52 97.97,176.09 100.22,176.09 v4(100.95,175.36)
  TOP w0.165: v4(135.8,162.31) 135.8,162.64 135.67,162.76 135.14,162.76 135.01,162.64 135.01,161.58 135.14,161.45 DIMM1.90
  L3 w0.089: v4(100.95,175.36) 101.72,176.12 105.8,176.12 105.87,176.2
  L3 w0.216: v4(135.8,162.31) 135.29,162.81 131.22,162.81 129.45,164.59 126.57,164.59 114.92,176.24 105.91,176.24 105.87,176.2
  BOTTOM w0.102: v4(135.8,162.31) 135.54,162.05 v2(135.54,161.47)
M_A_A7: length 58.9
  TOP w0.089: v4(98.97,175.38) 98.62,175.73 98.11,175.73 96.57,174.19 96.57,174.17 96.37,173.97 93.26,173.97 93.15,173.86 92.65,173.86 CPU1.AW52
  TOP w0.165: DIMM1.86 138.71,162.65 138.59,162.77 137.4,162.77 137.19,162.56 v4(137.19,162.31)
  L3 w0.089: 105.57,176.66 105.42,176.5 101.54,176.5 100.92,175.88 99.47,175.88 v4(98.97,175.38)
  L3 w0.216: 105.57,176.66 105.65,176.73 115.13,176.73 126.76,165.1 129.7,165.1 131.61,163.19 135.75,163.19 136.05,162.89 137.96,162.89 138.34,162.51 138.34,162.1 138.03,161.8 137.62,161.8 137.19,162.23 v4(137.19,162.31)
  BOTTOM w0.102: v4(137.19,162.31) 136.94,162.05 v2(136.94,161.47)
M_A_A8: length 57.6
  TOP w0.089: 100.54,176.28 100.34,176.28 100.32,176.3 97.88,176.3 97.75,176.17 97.75,176.15 96.41,174.81 93.73,174.81 93.38,174.46 93.33,174.46 CPU1.AY52
  TOP w0.165: DIMM1.89 133.43,161.75 133.56,161.88 133.56,162.26 v4(133.51,162.31) ; 100.54,176.28 101.6,176.28 101.73,176.4 101.73,177.95 101.85,178.08 102.65,178.08 102.78,177.95 102.78,175.67 102.51,175.4 v4(101.67,175.4)
  L3 w0.089: v4(101.67,175.4) 102.01,175.74 106.1,175.74
  L3 w0.216: 106.1,175.74 114.71,175.74 127.14,163.32 129.82,163.32 131.33,161.82 133.25,161.82 133.51,162.08 v4(133.51,162.31)
  BOTTOM w0.102: v2(134.32,162.33) 133.54,162.33 v4(133.51,162.31)
M_A_A9: length 55.4
  TOP w0.089: CPU1.BB54 96.36,175.28 97.74,176.65 99.76,176.65 v4(100.54,177.43)
  TOP w0.165: v4(132.88,163.7) 132.12,162.95 DIMM1.85
  L3 w0.089: 105.34,177.14 105.09,176.88 101.3,176.88 100.54,176.12 97.6,176.12 97.38,176.34 97.38,176.75 97.6,176.96 100.07,176.96 v4(100.54,177.43)
  L3 w0.216: 105.34,177.14 105.43,177.23 115.33,177.23 126.95,165.61 129.83,165.61 130.8,164.64 131.94,164.64 v4(132.88,163.7)
  BOTTOM w0.102: v2(132.88,164.49) v4(132.88,163.7)
M_A_A10: length 58.5
  TOP w0.165: DIMM1.107 133.14,156.35 v4(134.05,155.44) ; v4(90.84,172.51) 90.84,172.55 90.55,172.85 CPU1.AT50
  L3 w0.089: v4(90.84,172.51) 91.67,171.68 93.61,171.68 94.98,170.31 102.4,170.31 104.17,168.53
  L3 w0.216: v4(134.05,155.44) 134.05,155.41 134.51,154.95 134.78,154.95 134.91,154.82 134.91,154.16 134.56,153.81 131.86,153.81 131.61,154.05 126.53,154.05 117.41,163.17 112.05,168.53 104.17,168.53
  BOTTOM w0.102: v4(134.05,155.44) 134.05,154.93 134.37,154.61 v2(134.4,154.61)
M_A_A11: length 56.6
  TOP w0.089: v4(99.21,177.44) 98.61,176.83 97.61,176.83 96.31,175.54 94.23,175.54 94.13,175.51 93.82,175.44 CPU1.BA54
  TOP w0.165: v4(135.8,163.7) 135.82,163.7 135.95,163.83 135.95,164.06 135.82,164.19 135.37,164.19 135.24,164.06 135.24,163.49 135.67,163.07 138.46,163.07 138.64,163.25 DIMM1.84
  L3 w0.089: 104.73,177.95 104.43,177.65 101.54,177.65 101.36,177.83 99.6,177.83 v4(99.21,177.44)
  L3 w0.216: 104.73,177.95 105,178.22 115.74,178.22 127.16,166.8 130.19,166.8 131.35,165.63 133.87,165.63 v4(135.8,163.7)
  BOTTOM w0.102: v2(135.39,164.44) 135.39,164.11 v4(135.8,163.7)
M_A_A12: length 58.2
  TOP w0.089: v4(101.2,177.43) 100.24,176.48 97.81,176.48 96.35,175.02 93.49,175.02 93.44,175.07 92.79,175.07 92.49,175.38 CPU1.AW54
  TOP w0.165: v4(134.15,163.7) 134.15,164.69 134.27,164.82 134.75,164.82 134.88,164.95 134.88,165.66 134.75,165.79 133.48,165.79 133.36,165.66 133.36,164.29 133.23,164.17 132.68,164.17 132.07,163.55 DIMM1.83
  L3 w0.089: 105.04,177.55 104.78,177.28 101.34,177.28 v4(101.2,177.43)
  L3 w0.216: 105.04,177.55 105.21,177.72 115.54,177.72 126.96,166.3 129.74,166.3 130.91,165.13 133.41,165.13 134.15,164.4 v4(134.15,163.7)
  BOTTOM w0.102: v2(134.15,164.52) v4(134.15,163.7)
M_A_A13: length 60.2
  TOP w0.165: v4(91.61,170.6) 91.7,170.7 91.7,171.55 91.57,171.68 90.97,171.68 90.84,171.55 90.84,171.29 91.01,171.12 CPU1.AU46 ; v4(132.69,152.41) 132.35,152.75 DIMM1.119
  L3 w0.089: 104.3,167 101.89,169.42 101.58,169.42 101.49,169.33 101.49,168.75 101.4,168.66 101.22,168.66 101.13,168.75 101.13,169.33 101.04,169.42 94.74,169.42 94.6,169.56 94.48,169.56 93.77,168.85 93.62,168.85 93.51,168.95 93.51,169.1 94.23,169.81 94.23,169.93 94.1,170.06 93.97,170.06 93.31,169.4 93.17,169.4 93.06,169.5 93.06,169.65 93.72,170.31 93.72,170.44 93.56,170.6 v4(91.61,170.6)
  L3 w0.216: v4(132.69,152.41) 131.74,152.41 131.24,151.91 126.57,151.91 115.93,162.55 115.93,162.55 111.47,167 104.3,167
  BOTTOM w0.102: v4(132.69,152.41) 133.59,153.31 v2(133.69,153.31)
M_A_A14: length 57.1
  TOP w0.089: CPU1.AY54 93.23,175.6 93.73,175.6 93.76,175.6 93.84,175.68 94.07,175.68 94.21,175.71 96.21,175.71 97.54,177.04 98.15,177.04 v4(98.55,177.44)
  TOP w0.165: v4(137.19,163.7) 137.19,163.83 137.81,164.45 DIMM1.80
  L3 w0.089: v4(98.55,177.44) 98.55,178 98.69,178.14 104.21,178.14 104.43,178.36
  L3 w0.216: v4(137.19,163.7) 137.19,163.78 137.32,163.91 137.34,163.91 137.61,164.17 137.61,165.1 137.48,165.23 134.72,165.23 133.77,166.18 131.51,166.18 130.32,167.37 127.29,167.37 115.95,178.71 104.78,178.71 104.43,178.36
  BOTTOM w0.102: v4(137.19,163.7) 136.81,164.08 v2(136.81,164.52)
M_A_A15: length 56.3
  TOP w0.089: v4(101.33,178.72) 100.46,177.84 97.64,177.84 95.96,176.16 94.21,176.16 94.08,176.2 93.91,176.2 93.72,176.15 93.62,176.15 CPU1.BA55
  TOP w0.165: v4(136.02,165.79) 136.75,165.05 DIMM1.78
  L3 w0.216: v4(136.02,165.79) 136.07,165.79 136.2,165.91 136.2,167.28 135.98,167.5 135.39,167.5 135.17,167.28 135.17,166.8 135.05,166.67 131.71,166.67 130.52,167.86 127.5,167.86 116.15,179.21 104.57,179.21 104.07,178.72 v4(101.33,178.72)
  BOTTOM w0.102: v2(135.14,165.76) 135.16,165.79 v4(136.02,165.79)
M_A_BS0: length 56.5
  TOP w0.165: v4(90.89,173.4) 91.2,173.71 CPU1.AU52 ; DIMM1.109 132.34,155.75 v4(132.69,155.4)
  L3 w0.089: 104.17,169.53 103.92,169.53 102.03,171.42 97.21,171.42 95.68,172.95 95.34,172.95 95.26,172.87 95.26,172.32 95.17,172.23 94.99,172.23 94.9,172.32 94.9,172.87 94.81,172.95 94.62,172.95 94.53,172.87 94.53,172.38 94.44,172.29 94.26,172.29 94.18,172.38 94.18,172.87 94.09,172.95 93.91,172.95 93.82,172.87 93.82,172.38 93.73,172.29 93.55,172.29 93.46,172.38 93.46,172.87 93.38,172.95 91.01,172.95 90.89,173.08 v4(90.89,173.4)
  L3 w0.216: v4(132.69,155.4) 132.34,155.05 127.9,155.05 127.9,155.05 126.93,155.05 112.45,169.53 104.17,169.53
  BOTTOM w0.102: v2(132.93,156.34) 132.69,156.1 v4(132.69,155.4)
M_A_BS1: length 60.3
  TOP w0.165: v4(136.61,155.41) 136.61,155.63 137.03,156.05 DIMM1.108 ; v4(90.19,172.48) 90.55,172.12 CPU1.AT48
  L3 w0.089: 104.17,168.02 102.14,170.05 94.83,170.05 93.43,171.45 91.22,171.45 v4(90.19,172.48)
  L3 w0.216: v4(136.61,155.41) 134.51,153.31 131.9,153.31 131.24,153.3 130.83,152.9 126.98,152.9 116.92,162.96 111.86,168.02 104.17,168.02
  BOTTOM w0.102: v4(136.61,155.41) 136.43,155.23 v2(136.43,154.56)
