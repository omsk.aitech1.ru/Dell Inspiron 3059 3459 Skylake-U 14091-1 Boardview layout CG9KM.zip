# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3D3V_VCCPRIM: length 47
  TOP w0.127: v4(81.77,157.08) 81.77,155.86 CPU1.V19 ; CPU1.AJ21 86.34,157.45 85.2,158.58 84.96,158.58 84.77,158.77
  TOP w0.254: 84.77,158.77 84.69,158.85 82.68,158.85 v4(82.46,158.62) ; C2105.1 70.47,138.68 71.36,139.57 v3(71.41,139.57) 71.41,140.09 R1127.2 R80046.1
  L3 w0.254: v4(81.77,157.08) 81.86,156.99 81.86,146.63 80.99,145.75 80.99,142.69 81.19,142.49 81.19,135.9 80.26,134.98 79.82,134.98 79.67,135.13 75.93,135.13 71.49,139.57 v3(71.41,139.57)
  L4 w0.254: v4(82.46,158.62) 81.77,157.93 v4(81.77,157.08)
  BOTTOM w0.254: v3(71.41,139.57) v2(71.41,140.39)
3D3V_VCCPRTCPRIM: length 38.1
  TOP w0.127: v4(87.53,152.3) 87.53,152.35 87.56,152.38 87.56,153.74 CPU1.AK17
  TOP w0.254: C2110.1 C2109.1 99.35,129.9 v3(99.47,130.02) ; C2110.1 98.22,129.17 97.82,128.78 97.82,128.6 97.51,128.28 R1115.2 ; C2110.1 v1(98.48,130.2)
  L4 w0.254: v4(87.53,152.3) 87.06,151.83 87.06,147.59 87.34,147.31 92.12,147.31 92.15,147.33 92.55,147.33 98.97,140.91 98.97,138.1 100.42,136.65 100.42,130.74 99.7,130.02 v3(99.47,130.02)
3D3V_VGA_S0: length 253.1
  TOP w0.254: v3(108.75,69.09) 108.55,69.28 PR8501.1 ; v3(98.46,102.23) 98.71,102.49 98.71,104.58 R1883.1 98.27,105.16 R1159.2 ; PR8514.1 109,100.52 PR8404.1 108.62,99.69 v3(108.87,99.44) ; PR5304.1 v3(120.94,80.24)
  TOP w0.305: v4(86.88,100.9) 87.39,101.4 GPU1.AB18 ; v4(86.88,100.9) 86.4,100.41 GPU1.AA17 ; v4(86.88,100.9) 86.4,101.38 GPU1.AA18 ; v4(86.88,100.9) 87.38,100.4 GPU1.AB17 ; 101.51,88.34 101.4,88.45 RN16.3 ; RN16.4 101.42,89.1 101.51,89.18
  TOP w0.381: v3(78.39,82.8) 78.39,82.55 80.51,80.43 81.99,80.43 82.52,80.95 R1895.2 ; 87.03,81.11 82.61,81.11 R1895.2 ; R1895.2 R80086.2 83.47,82.04 83.94,82.51 83.94,83.48 83.35,84.07 R1892.2 ; v3(122.21,69.09) 122.4,69.28 PR8516.1
  TOP w0.406: 96.5,85.39 96.5,82.33 94.83,80.66 87.49,80.66 87.03,81.11 ; 96.5,85.39 96.55,85.34 Q123.2 Q123.5 ; 96.5,85.39 96.5,86.08 v3(96.32,86.26)
  TOP w0.508: v3(137.32,104.52) 136.81,105.03 PR6.1 ; Q77.D 155.89,93.32 155.48,93.73 v3(155.48,93.98) ; v3(98.97,91.82) 99.5,91.82 101.51,89.81 101.51,88.34 101.76,88.09 101.76,85.47 v3(100.11,83.82) ; v3(96.32,86.26) 95.98,85.92 R1885.1 ; v3(93.51,84.2) R1887.1
  L3 w0.254: v3(120.94,80.24) 122.33,78.84 122.33,69.22
  L3 w0.381: v3(108.75,69.09) 109.63,68.2 121.32,68.2 v3(122.21,69.09) 122.33,69.22
  L3 w0.508: v3(93.51,84.2) 93,84.71 93,86.87 ; 93,86.87 93.61,86.26 v3(96.32,86.26) ; 93,86.87 v3(91.85,88.01)
  L4 w0.508: v3(137.32,104.52) 137.7,104.14 139.12,104.14 147,96.27 153.2,96.27 v3(155.48,93.98) ; v3(100.11,83.82) 100.11,83.92 97.77,86.26 v3(96.32,86.26) ; v3(98.46,102.23) 105.48,102.23 107.39,100.33 108.36,100.33 108.87,99.82 v3(108.87,99.44) 110.18,100.75 115.39,100.75 116.98,102.34 117.76,102.34 v3(117.76,102.33)
  BOTTOM w0.254: 89.95,89.15 88.43,87.63 v2(86.65,87.63) 83.35,87.63 83.15,87.82 R1167.1
  BOTTOM w0.381: R302.2 79.09,85.22 R1893.2 79.09,83.5 v3(78.39,82.8) ; v3(108.75,69.09) v2(107.17,69.09) 103.59,69.09 102.1,70.57 102.1,79.03 99.98,81.15 99.98,83.69 v3(100.11,83.82)
  BOTTOM w0.508: C753.1 85.19,91.44 87.45,91.44 87.48,91.41 88.2,91.41 89.44,90.17 89.95,90.17 ; PR6.1 PR19.1 PR5485.1 PR96.1 PR5486.1 PR5480.1 PR102.1 PR103.1 PR5482.1 ; PR6.1 136.81,105.03 v3(137.32,104.52) ; PR6.1 PR4.1 136.37,106.87 v2(135.67,107.57) 133.46,109.78 124.67,109.78 121.98,107.09 121.98,104.35 119.97,102.33 v3(117.76,102.33) ; 89.95,90.17 89.95,89.15 90.2,88.9 U49.8 91.73,88.14 v3(91.85,88.01) ; 89.95,90.17 U49.7 ; 98.46,99.44 v2(97.09,99.44) 94.65,99.44 94.47,99.27 90.76,99.27 89.72,100.31 C784.1 89.48,100.42 C783.1 C782.1 87.36,100.42 v4(86.88,100.9) ; 98.46,99.44 98.98,99.44 99.98,98.43 99.98,92.84 v3(98.97,91.82) ; 98.46,99.44 v3(98.46,102.23)
3P3V_SPI: length 40.1
  TOP w0.254: v3(62.52,129.29) 61.84,129.29 R343.1 ; SRCON1.8 40.97,126.87 C12261.1 ; R79980.1 62.62,133.95 v3(62.64,133.95) ; v3(43.72,130.43) 43.21,129.92 40.2,129.92 R341.1 C12261.1 ; C12261.1 R342.2
  L4 w0.254: v3(62.52,129.29) 58.96,129.29 58.53,128.85 45.3,128.85 v3(43.72,130.43)
  BOTTOM w0.254: v3(62.52,129.29) 62.11,129.69 v2(62.11,132.11) 62.11,133.42 v3(62.64,133.95)
14MHZ_IN_SCALAR: length 7.8
  TOP w0.102: SCA1.128 68.05,54.53 68.71,53.87 v3(68.71,52.96) 68.71,51.75 R9547.2 69.77,51.61 C9520.1 70.04,51.63 70.23,51.82 70.96,51.82 71.65,52.51 X9502.3
  BOTTOM w0.102: v2(68.14,52.38) v3(68.71,52.96)
14MHZ_OUT_SCALAR: length 5.2
  TOP w0.102: R80242.1 R9547.1 67.97,52.08 67.12,52.92 v3(67.12,53.09) SCA1.127
  BOTTOM w0.102: v3(67.12,53.09) 67,53.21 v2(66.3,53.21)
14MHZ_OUT_SCALAR_C: length 6.1
  TOP w0.102: X9502.1 73.3,50.56 72.65,51.21 70.77,51.21 v3(70.62,51.05) 70.33,51.05 69.86,50.58 C9522.1 68.87,50.58 R80242.2
  BOTTOM w0.102: v2(69.81,51.05) v3(70.62,51.05)
1117 ADJ: length 8.1
  BOTTOM w0.102: U119.1 140.34,31.14 R2081.2 140.85,30.99 v2(141.87,32) 142.6,32.74 144.05,32.74 R1592.1
62882_COMP_R: length 2
  TOP w0.254: PR8.1 129.19,107.51 PC6.2 129.32,107.63 v1(129.32,108.56)
62882_FB_VSEN: length 2
  TOP w0.254: v1(127.08,108.56) 127.22,108.42 PC11.1 127.16,107.51 PR20.2
62882_NTC_R: length 51.4
  TOP w0.254: PR60.1 v3(125.06,75.56)
  L3 w0.254: v3(125.06,75.56) 125.92,74.71 133.92,74.71 136.51,77.31 136.51,82.04 137.32,82.85 137.32,94.11 136.61,94.82 136.61,103.71 135.57,104.75 129.22,104.75 v3(129.06,104.91)
  BOTTOM w0.254: v3(129.06,104.91) 128.4,104.25 v2(128.4,104.22) 128.4,103.78 129,103.19 PR5.2
62883AGND: length 34.7
  TOP w0.203: U9.40 132.85,102.13 133,102.29 v3(133,102.77)
  TOP w0.508: PC20.1 v3(122.33,101.98) ; PC5.1 126.07,108.25 v3(126.14,108.33) ; PR1.1 132.11,108.08 132.37,108.33 v3(132.88,108.33) 133.13,108.08 PR9.2 ; v3(121.83,96.01) 122.33,96.52 PC60.2 123.48,97.03 PC58.2
  L3 w0.508: v3(122.33,101.98) 122.49,101.83 122.49,96.67 v3(121.83,96.01)
  BOTTOM w0.508: 132.24,107.7 126.78,107.7 v3(126.14,108.33) 126.14,105.77 123.88,103.5 v2(123.88,103.48) 123.83,103.48 v3(122.33,101.98) ; 132.24,107.7 132.24,103 132.47,102.77 v3(133,102.77) ; 132.24,107.7 v3(132.88,108.33)
  vias: v2(131.35,99.16) v3(129.32,100.33) v3(130.08,101.09) v3(130.08,100.33) v3(130.08,99.57) v3(130.84,100.33)
+V_VREF_PATH1: length 3.2
  BOTTOM w0.152: R1214.1 130.46,196.44 130.26,196.65 v2(130,196.65) 129.88,196.65 129.45,196.22 C1256.2
+V_VREF_PATH2: length 3.1
  BOTTOM w0.152: C1328.2 143.8,196.3 v2(144.28,196.78) 144.52,196.78 144.94,196.37 R1306.1
+V_VREF_PATH3: length 2.3
  BOTTOM w0.152: R1221.1 145.13,150.75 C1257.2 144.88,150.88 v2(143.8,150.88)
+VGA_CORE_PHASE1: length 18.8
  TOP w0.254: PG3.1 v3(115.6,86.11) ; PR5489.2 117.7,100.01 v3(117.51,99.82)
  L3 w0.254: v3(117.51,99.82) 117.13,99.44 116.75,99.44 116.37,99.06 116.37,97.63 117.06,96.93 117.06,86.36 116.81,86.11 v3(115.6,86.11)
  BOTTOM w0.254: v3(115.6,86.11) v2(115.6,85.24)
A20GATE: length 4.7
  TOP w0.102: U109.43 127.81,58.97 127.19,58.34 126.65,58.34 126.27,58.72 v1(125.94,58.72) 125.7,58.48 R249.1
AC_IN: length 10.4
  TOP w0.102: PQ4406.D 50.83,42.29 v3(50.33,42.8) 49.75,42.23 PR4434.2
  BOTTOM w0.102: v3(50.33,42.8) 49.44,41.91 v2(49.44,41.78) 50.07,41.15 51.72,41.15 51.85,41.27 PQ4403.D 53.5,41.27 54.14,41.91 PQ4404.2
AC_IN_KBC#: length 3.4
  TOP w0.102: TP4124.1 93,64.27 91.56,62.84 91.55,62.84 91.32,62.61 U4101.29
AC_OK#: length 131.4
  TOP w0.102: v3(53.5,42.29) 53.31,42.1 PQ4406.G ; U4101.37 89.77,59.06 90.28,58.55 v3(90.28,58.1) ; PR4402.2 48.36,42.16 v3(46.13,42.16) ; R79855.1 v3(149.64,48.77)
  L4 w0.127: v3(149.64,48.77) 150.11,49.24 150.11,49.98 149.8,50.29 149.74,50.29 148.59,51.44 137.64,51.44 136.43,50.22 136.43,49.95 134.78,48.3 102.17,48.3 95.75,54.72 95.75,55.15 95.18,55.73 94.45,55.73 91.9,58.28 90.46,58.28 v3(90.28,58.1) 89.21,58.1 87.87,56.77 87.53,56.77 85.08,54.33 85.08,50.22 82.3,47.43 62.67,47.43 59.09,43.86 59.09,43.66 58.14,42.71 56.24,42.71 55.1,41.57 54.22,41.57 v3(53.5,42.29) 53.03,41.82 50.8,41.82 50.46,42.16 v3(46.13,42.16)
  BOTTOM w0.102: PU4404.5 44.44,44.21 v2(45.61,43.04) 46.13,42.52 v3(46.13,42.16)
AC_OK#_C: length 5.2
  TOP w0.102: U109.99 145.45,51.37 145.9,50.91 145.9,49.46 146.39,48.97 v1(146.85,48.97) 147.59,48.97 R79855.2
AC_PRESENT: length 39.9
  TOP w0.089: 96.45,151.03 95.04,152.44 94.17,152.44 94.08,152.41 93.91,152.41 93.81,152.43 93.64,152.61 93.64,152.83 93.18,153.29 CPU1.AY15
  TOP w0.102: R80036.2 104.48,122.75 104.48,124.93 105.85,126.31 105.85,141.66 101.53,145.98 101.53,148.62 100.34,149.81 100.34,150.29 v1(99.88,150.75) 99.6,151.03 98.88,151.03 96.45,151.03
AC_PROTECT: length 29.2
  L4 w0.127: v3(49.64,46.02) 49.08,45.47 45.37,45.47 44.99,45.09 44.99,43.05 44.74,42.8 40.8,42.8 v3(36.74,46.86)
  BOTTOM w0.102: PQ4405.G 50.61,43.85 PR4427.2 ; PU4404.3 v2(47.4,45.21) 48.23,45.21 PR4420.1 PR4427.2 ; PR4427.2 49.44,45.82 v3(49.64,46.02) ; v3(36.74,46.86) 35.91,46.86 PR5298.1 PR5297.2
AD+_2: length 29.7
  TOP w0.635: v3(68.61,26.67) 68.31,26.97 v1(68.31,27.56) ; v1(68.31,27.56) 69.63,27.56 R1850.1 69.76,29.08 C260.2 R1847.2 ; v1(68.31,27.56) 66.94,27.56 U110.4 ; PQ4205.C 89.57,27.43 v3(88.81,26.67)
  BOTTOM w0.635: v3(68.61,26.67) 70.39,28.45 87.03,28.45 v3(88.81,26.67)
AD+_G_1: length 7
  TOP w0.254: PR4401.2 60.49,41.66 v3(60.1,42.04)
  BOTTOM w0.254: PQ4404.5 58.33,41.91 58.45,42.04 v2(59.09,42.04) v3(60.1,42.04) 59.34,41.27 58.82,41.27 58.81,41.26 PQ4404.6
AD+_G_2: length 4.6
  TOP w0.254: PU4403.4 61.69,40.01 PR4413.2 PR4401.1 60.42,40.2 v1(59.09,41.53)
AD+_TO_SYS: length 1.4
  TOP w0.254: 62.77,41.4 62.14,41.4 61.82,41.08 PR4413.1
  vias: v2(66.05,41.78) v5(67.85,40.39) v5(68.59,41.4) v5(68.87,40.39) v5(69.5,41.4) v5(69.88,40.39) v5(70.9,40.39)
AD_IA: length 119.4
  L4 w0.127: v3(49.44,38.86) 50.62,37.68 58.83,37.68 64.9,43.75 70.58,43.75 71.79,44.96 83.05,44.96 87.59,49.49 v3(87.59,51.56) 88.11,51.04 98.08,51.04 101.59,47.54 101.86,47.54 135.43,47.54 135.8,47.9 135.82,47.9 136.05,48.13 137.73,48.13 140.52,50.93 145.2,50.93 146.27,49.86 v3(146.57,49.86)
  BOTTOM w0.102: R80216.1 148.69,49.21 148.3,49.6 146.82,49.6 v3(146.57,49.86) ; v3(49.44,38.86) 48.65,39.65 v2(48.29,39.65) 43.63,39.65 PR4431.2 ; R80220.1 87.54,51.61 v3(87.59,51.56)
AD_IA_EC: length 4.4
  TOP w0.102: v3(88.54,52.97) 88.88,53.31 U4101.48
  BOTTOM w0.102: R80220.2 87.88,54.13 88.63,54.13 v2(88.78,53.98) 88.78,53.21 v3(88.54,52.97)
AD_IA_HW1: length 118.3
  TOP w0.102: v3(149.64,53.72) 149.51,53.85 R79859.1 ; PQ4401.2 55.15,41.91 54.77,42.29 v3(54.77,43.31)
  L4 w0.127: v3(149.64,53.72) 147.99,52.07 137.56,52.07 135.83,50.34 135.83,50.07 134.57,48.81 102.38,48.81 96.26,54.93 96.26,55.66 93.89,58.04 v3(93.81,58.04) 93.02,58.83 89.21,58.83 87.66,57.28 87.31,57.28 83.89,53.85 83.89,51.39 80.45,47.94 61.95,47.94 57.95,43.94 55.41,43.94 v3(54.77,43.31)
  BOTTOM w0.102: v3(93.81,58.04) 93.81,56.5 R80221.1 93.57,56.26 v2(91.73,56.26) 91.49,56.26 90.84,56.91 90.84,57.59 R80225.2
AD_IA_HW1_C: length 3.4
  TOP w0.102: U109.106 147.48,54.17 R79859.2
AD_IA_HW1_EC: length 3.3
  TOP w0.102: v3(94.01,54.74) 94.12,54.63 U4101.59
  BOTTOM w0.102: v3(94.01,54.74) 93.76,54.99 R80221.2 v2(92.77,55.56)
AD_IA_HW2: length 116.8
  TOP w0.102: R79860.1 148.72,54.86 149.11,54.48 v3(149.64,54.48) ; PQ4401.5 57.95,41.91 58.2,42.16 58.2,43.18 v3(58.07,43.31)
  L4 w0.127: v3(58.07,43.31) 62.45,47.69 81.94,47.69 82.86,48.62 82.86,49.33 84.15,50.61 84.15,53.75 87.42,57.02 87.77,57.02 89.32,58.57 92.51,58.57 v3(93.05,58.04) 94.74,56.35 94.92,56.35 96.01,55.26 96.01,54.82 102.28,48.55 134.67,48.55 136.18,50.06 136.18,50.33 137.66,51.82 148.21,51.82 149.44,53.05 149.63,53.05 150.11,53.53 150.11,54.01 v3(149.64,54.48)
  BOTTOM w0.102: R80222.1 94.27,56.96 94.27,58.52 93.86,58.93 v2(93.76,58.93) 93.05,58.22 v3(93.05,58.04) 92.86,57.85 R80226.2
AD_IA_HW2_C: length 3.4
  TOP w0.102: R79860.2 v1(146.85,54.86) 146.58,54.86 146.29,54.57 U109.107
AD_IA_HW2_EC: length 3.2
  TOP w0.102: v3(94.78,54.75) 94.52,54.5 U4101.60
  BOTTOM w0.102: v2(94.39,53.98) 94.78,54.36 v3(94.78,54.75) R80222.2
AD_JK: length 35.8
  TOP w0.508: 54.71,25.56 DCIN1.1 ; DCIN1.1 56.28,26.63 ; DCIN1.1 54.71,27.7 ; PR4214.1 v3(88.93,30.86) 88.92,30.85 PQ4205.E
  L3 w0.508: DCIN1.1 56.28,26.63 ; DCIN1.1 54.71,25.56 ; DCIN1.1 54.71,27.7
  BOTTOM w0.508: DCIN1.1 54.71,27.7 ; DCIN1.1 56.28,26.63 ; DCIN1.1 54.71,25.56 ; v3(88.93,30.86) 88.07,30 69.91,30 68.74,28.83 68.11,28.83
  vias: v1(60.49,30.1) v1(61.37,27.3) v2(59.34,30.35) v2(62.01,23.62) v2(65.18,29.97) v5(57.44,28.7) v5(57.82,26.8) v5(59.09,28.7) v5(59.47,27.18) v5(60.74,28.7)
AD_OFF: length 120.3
  TOP w0.102: v3(90.97,54.74) 90.74,54.97 90.74,58.72 90.04,59.43 89.9,59.43 89.87,59.46 U4101.36
  L3 w0.127: v3(143.27,50.42) 143.27,49.85 138.63,45.21 137.32,45.21 132.88,40.77 128.68,40.77 127.58,39.66 121.67,39.66 118.95,42.38 118.95,42.91 115.89,45.97 101.86,45.97 94.74,53.09 92.62,53.09 v3(90.97,54.74)
  L4 w0.127: v3(53.65,40.01) 53.91,40.26 55.66,40.26 56.81,41.41 60.31,41.41 63.66,44.77 70.16,44.77 71.36,45.97 82.63,45.97 86.35,49.7 86.35,52.6 88,54.24 90.47,54.24 v3(90.97,54.74)
  BOTTOM w0.102: R80224.2 v2(90.66,55.5) 90.97,55.19 v3(90.97,54.74) ; v3(53.65,40.01) 53.02,40.64 51.75,40.64 PQ4403.G ; v3(143.27,50.42) 143.99,50.42 R80193.1
AD_OFF_C: length 3.2
  TOP w0.102: U109.97 144.56,50.16 v3(144.05,49.66)
  BOTTOM w0.102: v3(144.05,49.66) 144.18,49.53 145,49.53 v2(145.02,49.54) 145,49.55 R80193.2
AD_OFF_L: length 4.4
  TOP w0.152: PQ4205.B 90.22,29.99 v1(91.6,31.37) PQ4204.C
ADAPTOR_PSID: length 115.8
  TOP w0.102: v3(138.34,50.42) 138.34,50.8 142.48,54.94 142.48,56.69 141.49,57.68 141.49,59.4 141.98,59.89 143.14,59.89 143.66,59.37 U109.119
  L4 w0.127: v3(58.2,40.64) 58.2,40.64 58.33,40.64 58.85,41.16 60.41,41.16 63.77,44.51 70.26,44.51 71.47,45.72 82.74,45.72 86.61,49.59 86.61,52.42 88.16,53.98 90.97,53.98 v3(91.73,54.74) 92.21,55.22 94.97,55.22 95.24,54.94 95.24,54.51 101.96,47.79 103.12,47.79 135.33,47.79 135.92,48.39 136.3,48.39 v3(138.34,50.42)
  BOTTOM w0.102: D19.3 58.83,39.37 R1846.2 58.2,40 58.2,40.63 v3(58.2,40.64) 57.88,40.64 R1851.2 ; R80207.1 91.6,53.15 v2(91.6,53.87) 91.6,54.61 v3(91.73,54.74)
ADAPTOR_PSID_EC: length 11.5
  TOP w0.102: v3(95.03,59.44) 95.53,58.94 96.55,58.94 96.67,59.06 U4101.12
  BOTTOM w0.102: v3(95.03,59.44) 94.52,58.93 94.52,57.53 95.28,56.77 95.28,54.1 94.14,52.96 v2(93.63,52.96) R80207.2
ADAPTOR_PSID_R: length 2.7
  BOTTOM w0.102: R1851.1 v2(56.23,38.82) 56.23,38.23 56.01,38 Q47.S
ADC_1V2: length 16.9
  TOP w0.305: SCA1.23 67.82,66.9 67.22,66.29 v3(67.22,65.51)
  BOTTOM w0.508: v3(67.22,65.51) 68.3,64.43 C12188.1 v2(69.38,64.14) 69.76,64.14 71.28,62.61 71.28,61.09 72.04,60.33 C12189.1 L9523.2
ALL_SYS_PWRGD: length 388.4
  TOP w0.102: R80252.1 71.33,219.27 69.05,216.98 v3(68.84,216.98) ; v3(154.23,74.18) 154.18,74.18 153.82,74.55 R80150.2 ; R80147.1 R80144.2 19.38,187.76 18.63,187.76 17.94,187.07 15.97,187.07 15.59,186.69 Q9636.D 14.92,186.69 v3(14.29,186.06) 13.84,186.5 PR8512.2 12.29,186.5 11.54,185.75 11.54,178.04 R80145.1 ; U9626.2 v3(68.49,190.12)
  L3 w0.127: v3(14.29,186.06) 16.04,187.8 16.04,207.69 24.11,215.77 26.45,215.77 29.33,218.66 55.95,218.66 57.78,216.83 66.55,216.83 66.68,216.7 68.56,216.7 v3(68.84,216.98)
  L4 w0.127: v3(165.76,205.11) 165.13,205.74 163.49,205.74 163.18,205.44 107.88,205.44 107.6,205.16 88.51,205.16 84.52,201.17 83.62,201.17 80.99,198.54 79.38,198.54 79.06,198.22 77.35,198.22 69.25,190.12 v3(68.49,190.12) 68.49,193.8 68.7,194.02 68.7,216.82 68.84,216.95 v3(68.84,216.98)
  BOTTOM w0.102: v3(165.76,205.11) 165.76,203.41 166.02,203.15 166.02,150.41 163.51,147.9 v2(163.51,126.31) 163.51,120.92 159.73,117.14 151.53,117.14 149.04,114.65 149.04,109.87 153.98,104.93 153.98,101.2 154.47,100.72 154.47,87.35 153.63,86.51 153.63,74.74 154.18,74.18 v3(154.23,74.18)
AMD_RST#: length 5.4
  TOP w0.102: R1160.1 C752.1 96.33,107.1 v1(96.12,107.31) 95.04,108.4 GPU1.AL27
AMP_SPKR_L: length 6.2
  TOP w0.203: U9615.4 155.72,62.24 155.2,61.72 155.2,61.65 R79835.1 R385.1 R384.2 154.59,57.78 v1(154.95,57.43)
AMP_SPKR_R: length 8.1
  TOP w0.203: R383.2 164.9,58.55 165.26,58.9 v1(165.26,59.03) 164.52,59.77 R386.1 163.89,59.77 162.47,61.19 R79834.1 162.24,61.95 161.45,62.74 U9615.8
AMP_SWITCH_C_L: length 1.2
  TOP w0.203: R79835.2 R79812.1
AMP_SWITCH_C_R: length 1.2
  TOP w0.203: R79813.1 R79834.2
AUD_BEEP_C: length 3.1
  TOP w0.102: U6.2 158.94,78.25 v1(157.92,79.27) 157.88,79.31 C130.2
AUD_BEEP_R: length 4.9
  TOP w0.102: C130.1 R210.1 R207.2 155.23,81.22 154.9,81.55 v1(154.9,82.04) 154.9,83.2 R208.2
AUD_DMIC_CLK: length 166.9
  TOP w0.127: WEBCM1.4 160.75,199.2 160.94,199.39 165.01,199.39 165.72,198.68 v1(165.72,195.66) 165.72,195.02 v3(167.06,193.68) ; L54.2 C121.2 158.1,67.97 v3(158.1,67.97)
  BOTTOM w0.127: v3(158.1,67.97) 157.63,68.44 157.63,69.41 161.22,73 165.16,73 165.79,73.63 165.79,86.51 166.49,87.21 166.49,89.05 165.24,90.3 161.85,90.3 157.13,95.02 157.13,98.57 154.35,101.36 154.35,105.94 150.27,110.02 150.1,110.02 149.64,110.48 149.64,114.41 151.73,116.5 160.24,116.5 164.28,120.54 164.28,147.83 166.66,150.2 166.66,189.01 166.85,189.2 166.85,193.46 v3(167.06,193.68)
AUD_DMIC_CLK_R: length 5.6
  TOP w0.127: U6.12 159.57,72.92 158.78,72.14 158.36,72.14 v1(157.2,70.97) R212.1
AUD_DMIC_CLK_R_1: length 2.6
  TOP w0.127: L54.1 R212.2 156.31,71.06 v1(155.99,71.37)
AUD_DMIC_DATA: length 167.8
  TOP w0.127: v3(158.1,68.73) 158.15,68.78 C132.2 R222.1 ; v3(167.06,194.56) v1(167.06,197.08) 167.06,197.71 165.13,199.64 160.05,199.64 159.5,199.09 WEBCM1.5
  BOTTOM w0.127: v3(158.1,68.73) 158.1,69.52 161.32,72.75 165.26,72.75 166.05,73.53 166.05,86.41 166.75,87.11 166.75,89.15 165.35,90.55 161.96,90.55 157.39,95.12 157.39,98.68 154.6,101.46 154.6,106.04 150.37,110.27 150.21,110.27 149.93,110.55 149.93,110.58 149.89,110.62 149.89,114.3 151.84,116.24 160.35,116.24 164.54,120.43 164.54,147.72 166.91,150.1 166.91,183.54 167.53,184.16 167.53,194.09 v3(167.06,194.56)
AUD_DMIC_DATA_R: length 3.4
  TOP w0.127: U6.13 160.39,72.71 v1(159.34,71.65) 159.34,71.65 159.16,71.48 R222.2
AUD_GP3: length 5.3
  TOP w0.203: v1(154.9,79.4) 155.77,79.4 R213.2 156.56,78.61 158.02,78.61 158.78,77.85 U6.3
AUD_LINK_BCLK: length 120.9
  TOP w0.102: U6.5 156.72,77.05 C126.2 156.18,77.6 154.71,77.6 154.08,78.22 154.08,89.03 145.62,97.49 145.62,107.32 136.94,116 132.42,116 128.51,119.91 v1(125.23,119.91) 124.9,120.24 117.78,120.24 113.21,124.82 113.21,129.8 114.43,131.03 114.43,151.04 103.55,161.93 R1907.1
AUD_LINK_RST_N: length 125.1
  TOP w0.102: R314.1 152.62,76.39 v3(154.08,74.93) ; U6.6 158.84,76.65 158.78,76.71 157.26,76.71 157.13,76.58 155.1,76.58 v3(154.85,76.33) 154.59,76.58 153.95,76.58 153.58,76.95 153.58,88.77 145.16,97.19 145.16,107.1 136.72,115.54 131.68,115.54 v1(131.27,115.95) 128.1,119.13 118.25,119.13 112.68,124.7 112.68,129.92 113.98,131.22 113.98,150.85 104.93,159.89 R1911.1
  BOTTOM w0.102: v3(154.85,76.33) 154.85,75.69 v3(154.08,74.93)
AUD_LINK_RST_N_2: length 3.6
  BOTTOM w0.254: Q9622.3 153.87,42.56 153.45,42.14 v2(153.45,42.01) 153.53,42.01 154.28,41.26 Q9622.1
AUD_LINK_RST_N_R: length 5.3
  TOP w0.102: Q31.B 150.69,80.92 v1(151.31,80.29) 152.05,79.55 152.05,78.61 152.37,78.3 C170.1 R314.2
AUD_LINK_SDIN: length 129.5
  TOP w0.089: CPU1.BA21 93.66,156.28 94.03,155.91 94.47,155.91 94.95,155.43 95.51,155.43
  TOP w0.102: 95.51,155.43 99.25,155.43 101.38,157.56 101.38,158.48 102.23,159.33 105.17,159.33 113.75,150.75 113.75,131.62 112.45,130.33 112.45,124.6 118.03,119.03 118.16,118.9 127.46,118.9 v1(128.53,117.83) 131.04,115.32 136.62,115.32 144.93,107 144.93,97.09 153.32,88.7 153.32,76.88 153.88,76.33 154.2,76.33 154.66,75.87 155.6,75.87 R209.1
AUD_LINK_SDIN_1: length 3.1
  TOP w0.102: U6.8 158.95,75.85 158.78,75.69 158.02,75.69 v1(157.67,76.05) 157.64,76.07 R209.2
AUD_LINK_SDO: length 121.5
  TOP w0.102: R1912.1 102.97,162.83 114.66,151.13 114.66,130.93 113.44,129.7 113.44,124.91 117.88,120.47 128.27,120.47 132.51,116.23 137.03,116.23 145.85,107.41 145.85,97.77 154.34,89.28 154.34,78.61 v3(154.85,78.11) R618.2
  BOTTOM w0.102: v2(154.39,78.92) 154.39,78.56 v3(154.85,78.11) Q56.D C1780.2
AUD_LINK_SDO_1: length 4.7
  BOTTOM w0.102: Q56.G 157.96,79.38 C1780.1 157.02,80.47 157.61,80.47 v2(158.17,81.03) 158.15,81.05 158.15,81.13 157.87,81.41 R617.2
AUD_LINK_SDO_N: length 5.6
  TOP w0.102: U6.4 158.53,77.45 157.88,78.11 v3(157.64,78.11) R618.1
  BOTTOM w0.102: v3(157.64,78.11) 157.96,77.79 Q56.S v2(159.34,77.12)
AUD_LINK_SDO_R1: length 12.7
  BOTTOM w0.102: R153.1 107.35,122.3 106.18,121.13 106.18,115.61 v2(106.47,115.32) 106.47,113.9 107.48,112.9 108.75,112.9 MEJ1.2
AUD_LINK_SYNC: length 122.5
  TOP w0.102: R1908.1 104.24,160.91 114.21,150.94 114.21,131.12 112.98,129.89 112.98,124.73 118.02,119.68 v1(123.32,119.68) 123.65,119.35 128.66,119.35 132.24,115.77 136.81,115.77 145.39,107.19 145.39,106.73 145.39,97.34 153.83,88.9 153.83,77.34 v3(154.08,77.09) ; U6.9 157.16,75.45 157,75.62 154.16,75.62 v3(154.08,75.69)
  BOTTOM w0.102: v3(154.08,77.09) v3(154.08,75.69)
AUD_REGREF: length 3.1
  TOP w0.203: U6.10 158.53,75.05 158.4,74.93
  TOP w0.508: C129.1 156.75,74.8 157.84,74.8 157.89,74.75 v1(157.93,74.75) 157.95,74.75 158.12,74.93 158.4,74.93
BAT_ALERT: length 4.5
  TOP w0.102: v1(36.13,60.2) 36.02,60.1 35.3,60.1 R79648.2 34.58,60.39 BAT2.8B
BAT_IN#: length 161.1
  TOP w0.102: U4101.5 94.65,56.26 93.25,54.86 v3(93.25,54.74) ; v3(34.07,43.94) 34.07,43.62 R80223.1
  L3 w0.127: v3(93.25,54.74) 93.25,53.85 93.51,53.59 94.95,53.59 102.07,46.48 116.1,46.48 119.54,43.04 119.54,42.52 121.5,40.55 123.52,40.55 126.65,43.69 133.76,43.69 137.07,46.99 137.07,47 137.83,47.76 137.83,50.58 141.82,54.57 142.69,54.57 v3(143.16,54.1)
  L4 w0.127: v3(34.07,43.94) 37.88,43.94 41.82,40.01 50.16,40.01 52.23,37.93 57.92,37.93 63.99,44.01 70.47,44.01 71.68,45.21 82.95,45.21 87.12,49.38 87.12,52.21 88.37,53.47 91.98,53.47 v3(93.25,54.74)
  BOTTOM w0.102: v3(143.16,54.1) 144.32,55.26 144.32,55.3 R80203.1 ; v3(34.07,43.94) 33.61,44.4 33.61,50.65 v2(34.13,51.16) 35.03,52.07 35.03,58.93 34.77,59.19 33.55,59.19 33.15,58.8 RN4301.2
BAT_IN#_1: length 10.3
  TOP w0.102: BAT2.6B 33.93,63.39 v3(33.94,63.37)
  BOTTOM w0.102: v3(33.94,63.37) 33.5,62.93 PC4304.1 PL4301.1 30.9,62.93 30.69,62.71 v2(30.69,61.42) 30.69,59 30.9,58.8 RN4301.7
BAT_IN#_C: length 7
  TOP w0.102: v3(142.4,53.09) 142.4,51.94 143.37,50.97 U109.98
  BOTTOM w0.102: R80203.2 144.64,54.15 144.08,53.59 v2(143.8,53.59) 142.91,53.59 v3(142.4,53.09)
BATA_SCL_1: length 17.2
  TOP w0.102: BAT2.4B 32.96,66.39 33.69,65.66 v3(33.94,65.66)
  BOTTOM w0.102: v3(33.94,65.66) 32.86,66.74 PC4305.1 PL4302.1 30.2,66.74 v2(30.02,66.57) 29.65,66.19 29.65,58.65 30.65,57.65 RN4301.5
BATA_SDA_1: length 14.4
  TOP w0.102: BAT2.5B 33.94,64.89 v3(33.94,64.9)
  BOTTOM w0.102: RN4301.6 30.89,58.3 30.16,59.03 v2(30.16,63.96) 30.16,65.43 30.45,65.72 PL4303.1 PC4301.1 33.12,65.72 v3(33.94,64.9)
BATLOW#: length 17
  TOP w0.102: v4(90.87,152.38) 91.2,152.05 CPU1.AU13
  BOTTOM w0.102: R80034.2 105.89,149.99 v2(102.4,149.99) 94.75,149.99 92.08,152.65 91.22,152.65 90.94,152.38 v4(90.87,152.38)
BATT_AMBER_LED#: length 3.4
  TOP w0.203: 98.28,57.86 U4101.9
  TOP w0.254: R79710.2 100.15,58.45 v1(99.14,58.45) 99.14,58.39 98.61,57.86 98.28,57.86
BATT_AMBER_LED#_C: length 127.9
  TOP w0.254: v3(27.26,20.22) 27.3,20.25 PWRCN1.10 32.67,20.25 v1(32.88,20.04) ; R79710.1 101.89,58.17 103.74,56.31 103.74,52.02 104.42,51.34 104.78,51.34 105.15,50.96 105.15,50.52 104.43,49.8 v3(97.26,49.8)
  L4 w0.254: v3(27.26,20.22) 26.93,20.55 25.97,20.55 23.48,23.05 23.48,34.47 31.73,42.72 37.93,42.72 41.47,39.18 47.72,39.18 50.43,36.47 58.86,36.47 65.31,42.93 70.92,42.93 72.13,44.13 85.97,44.13 89.49,47.65 92.13,47.65 94.28,49.8 v3(97.26,49.8)
  BOTTOM w0.254: v3(27.26,20.22) 27.37,20.22 v2(27.95,19.63) 28.15,19.84 R389.2
BATT_WHITE_LED#: length 3.4
  TOP w0.203: 93.95,52.39 93.72,52.61 U4101.58
  TOP w0.254: R79711.2 94.37,51.6 v1(94.24,51.73) 94.24,52.1 93.95,52.39
BATT_WHITE_LED#_C: length 117.6
  TOP w0.254: R79711.1 94.37,49.12 v3(93.76,48.51) ; PWRCN1.8 26.98,21.25 26.38,21.84 v3(26.07,21.84) 26.07,21.87 24.95,22.99 24.95,29.16 v1(24.65,29.46)
  L4 w0.254: v3(93.76,48.51) 92.49,47.24 89.66,47.24 86.14,43.73 72.3,43.73 71.05,42.48 65.63,42.48 59.22,36.07 50.26,36.07 49.37,36.96 49.31,36.96 47.49,38.77 41.31,38.77 37.76,42.32 31.9,42.32 23.88,34.3 23.88,23.66 25.69,21.84 v3(26.07,21.84)
  BOTTOM w0.254: R79726.2 28.89,21.31 v2(27.41,21.31) 26.72,21.31 26.19,21.84 v3(26.07,21.84) 25.45,22.46 Q9631.3 25.45,23.89 25.94,24.38 Q1214.C ; v3(93.76,48.51) v2(92.82,48.51)
BIOS_REQ: length 170.5
  TOP w0.102: SCA1.105 56.12,55.33 56.68,55.88 v3(56.68,56.01) ; R80177.2 88.73,140.6 90.13,142 v4(90.13,143.33) 90.08,143.33 88.83,144.58 88.83,145.67 88.72,145.78 88.72,146.42 88.8,146.49 88.8,146.78 88.57,147 88.29,147 CPU1.AM5 ; v3(86.29,120.37) 85.41,120.37 81.49,124.28 80.09,124.28 79.33,123.52 73.48,123.52 73.24,123.28 73.24,122.45 72.61,121.83 70.89,120.11 66.36,120.11 66.36,120.1 65.98,120.1 62.85,123.24 47.03,123.24 46.8,123.01 46.08,123.01 45.88,123.21 36.21,123.21 v3(35.72,123.7)
  L3 w0.127: v3(35.72,123.7) 35.34,123.7 34.44,122.8 34.44,90.01 36.43,88.01 36.43,85.6 45.17,76.86 45.17,69.27 56.21,58.23 56.21,56.48 v3(56.68,56.01)
  BOTTOM w0.102: v4(90.13,143.33) 89.67,142.88 89.67,139.18 88.37,137.88 88.37,134.84 89.26,133.95 89.26,130.41 90.08,129.6 90.08,124.15 87.13,121.21 v2(87.13,121.18) 87.11,121.18 v3(86.29,120.37)
BIST_DISABLE: length 115.1
  TOP w0.102: R533.1 52.15,81.93 R531.2 52.62,80.24 52.62,79.44 52.17,78.98 R79924.2 51.47,78.74 v3(51.34,78.87) ; v3(142.17,59.44) 141.71,58.98 141.71,57.99 143.13,56.57 U109.112
  L4 w0.127: v3(142.17,59.44) 142.13,59.47 129.36,59.47 127.4,61.43 125.31,61.43 124.49,60.61 124.49,60.3 123.38,59.18 122.96,59.18 121.03,57.25 114.24,57.25 113.19,58.3 113.19,58.61 110.75,61.05 102.63,61.05 101.03,62.65 100.33,62.65 96.84,66.14 89.59,66.14 87.13,68.61 65.84,68.61 64.55,69.89 64.55,71.38 60.37,75.56 56.39,75.56 53.09,78.87 v3(51.34,78.87)
  BOTTOM w0.102: v3(51.34,78.87) 51.32,78.87 v2(50.58,79.61)
BIST_DISABLE_1: length 2.4
  TOP w0.254: Q9632.5 53.98,79.5 53.73,79.76 v1(53.2,79.76) 53.06,79.62 R79924.1
BIST_EN: length 8.4
  TOP w0.254: Q9632.6 55.03,78.85 55.51,79.32 55.51,79.73 55.92,80.15 Q9632.3 v3(56.34,80.89)
  BOTTOM w0.254: Q9633.2 56.78,79.25 57.18,78.84 57.97,78.84 v2(58,78.82) 58.2,79.02 58.2,79.44 R524.2 57.44,79.88 56.68,80.64 56.62,80.64 56.5,80.77 56.46,80.77 v3(56.34,80.89)
BIST_EN_INV: length 12
  TOP w0.102: R517.2 v3(57.69,77.98) 56.55,76.83 55.89,76.83 55.62,76.57 SCA1.63
  BOTTOM w0.102: v2(54.47,81.28) Q9633.6 55.02,79.9 55.28,79.64 55.28,78.87 55.55,78.6 Q9633.3 56.77,78.6 57.39,77.98 v3(57.69,77.98) 58.52,77.98 R80227.1
BIST_EN_SIO: length 96.9
  TOP w0.102: v3(133.26,65.91) 133.41,65.76 U109.25
  L3 w0.127: v3(124.19,63.02) 119.46,67.74 103.82,67.74 99.03,72.53 85.29,72.53 81.61,76.2 72.55,76.2 v3(68.11,80.64)
  BOTTOM w0.102: R282.1 v3(133.26,65.91) 133.26,67.84 135.87,70.46 135.87,71.69 135.6,71.96 133.26,71.96 124.32,63.02 v3(124.19,63.02) ; v3(68.11,80.64) 66.84,79.38 v2(62.39,79.38) 61.32,79.38 60.68,78.74 R80227.2
BIST_ENABLE: length 108.1
  TOP w0.102: v3(142.17,58.67) 142.17,58.01 143.22,56.97 U109.113
  L4 w0.127: v3(142.17,58.67) 141.63,59.22 128.95,59.22 127.91,60.26 125.32,60.26 123.99,58.93 123.07,58.93 121.13,57 114.13,57 112.94,58.2 112.94,58.51 110.65,60.79 102.53,60.79 100.93,62.4 100.23,62.4 96.74,65.89 89.39,65.89 86.92,68.35 65.73,68.35 64.29,69.79 64.29,71.28 60.39,75.18 56.37,75.18 53.45,78.11 v3(51.34,78.11)
  BOTTOM w0.102: R79923.2 52.1,78.87 v3(51.34,78.11) 51.32,78.08 50.55,78.08 50.55,78.08 v2(50.53,78.08)
BIST_ENABLE_1: length 4.8
  BOTTOM w0.102: Q9633.5 53.44,79.25 R79923.1 R79806.2 R523.1 53.06,81.47 v2(52.64,81.89)
BIST_PIN25: length 130.2
  TOP w0.102: v3(134.02,65.91) 133.81,65.71 U109.24
  L3 w0.127: v3(123.43,63.02) 123.43,63.42 119.38,67.47 103.7,67.47 98.92,72.25 85.2,72.25 81.51,75.95 71.92,75.95 65.69,82.17 53.75,82.17 53.44,82.49 51.28,82.49 45.94,87.82 45.94,90.24 44.04,92.14 v3(44.04,97.16)
  BOTTOM w0.102: v3(44.04,97.16) 43.59,97.16 43.21,96.77 42.07,96.77 39.85,99 Q9651.G ; v3(123.43,63.02) 123.88,63.47 124.29,63.47 133,72.19 135.7,72.19 136.1,71.79 136.1,70.13 134.47,68.5 v2(134.47,66.67) 134.02,66.21 v3(134.02,65.91) 134.4,65.53 R79933.2
BKLT_ADJ: length 4.2
  TOP w0.165: C87.1 C33.1 42.64,23.62 R79621.2 43.61,24.64 R133.2 43.85,24.75 v1(43.85,25.65)
BKLT_EN: length 7.7
  BOTTOM w0.102: C88.1 R138.2 43.59,23.56 R139.2 43.59,23.69 R79625.2 42.45,24.83 v2(42.45,26.11) 42.45,27.62 Q22.C
BKLT_EN1: length 5.2
  BOTTOM w0.102: R135.2 45.69,28.51 v2(45.47,28.73) 44.9,29.31 Q22.B
BOARD1: length 6
  TOP w0.102: R1661.2 R1663.1 146.92,63.89 146.92,63.37 v1(146.67,63.12) 146.2,62.65 146.2,62.29 145.27,61.37 U109.124
BOARD2: length 10.5
  TOP w0.102: U109.125 145.27,61.77 145.73,62.22 145.73,64.06 146.13,64.47 146.67,64.47 147.48,65.28 148.92,65.28 149.08,65.44 149.08,66.05 R79931.1 v1(150.6,66.61) 151.52,66.61 R1662.2
BOARD3: length 6.7
  TOP w0.102: U109.126 145.29,62.17 145.5,62.38 145.5,64.58 146.12,65.2 v1(146.48,65.2) 147,65.72 R1660.1 R1659.2
BOOT1_PHASE1: length 2.5
  TOP w0.508: v1(129.34,93.34) 129.22,93.22 PC19.2 PR43.2
BP_PWRGD_RST#: length 21.3
  TOP w0.102: v1(21.01,225.32) 19.91,224.22 C9901.1 R9926.1 18.42,223.81 18.42,219.95 19.55,218.82 26.6,218.82 27.57,217.86 27.57,217.81 27.95,217.42 28.52,217.42 29.83,216.11 XDP1.41
BPM_CPU_N0: length 106.6
  TOP w0.089: 70.39,175.19 71.12,175.93 72.03,175.93 72.13,176.03 CPU1.C55
  TOP w0.102: v3(64.4,182.88) 63.41,181.89 63.41,178.5 62.8,177.89 62.8,173.54 63.47,172.87 65.12,172.87 65.84,173.58 67.26,173.58 68.28,174.6 69.8,174.6 70.39,175.19 ; XDP1.21 24.83,216.32 v3(24.42,216.73)
  L3 w0.127: v3(66.77,218.16) 65.76,218.16 65.15,217.55 58.33,217.55 56.59,219.29 26.92,219.29 24.42,216.78 v3(24.42,216.73)
  BOTTOM w0.102: v3(64.4,182.88) 64.4,182.91 63.91,183.39 63.91,186.46 63.92,186.46 v2(63.92,186.57) 63.92,188.49 63.91,188.49 63.91,191.15 65.07,192.3 66.03,192.3 68.61,194.88 68.61,215.59 66.77,217.42 v3(66.77,218.16)
BPM_CPU_N1: length 114.9
  TOP w0.089: 70.11,173.51 70.4,173.81 70.61,173.81 71.81,175 arc(71.85,175.03) 71.9,175.05 72.26,175.13 73.06,175.13 73.31,175.39 CPU1.D55
  TOP w0.102: v3(25.18,216.76) 25.33,216.61 XDP1.23 ; v3(86.26,199.51) 86.09,199.51 83.55,202.06 83.55,202.74 81.47,204.83 v1(80.73,204.83) 80.02,204.83 v3(67.67,217.17) ; 70.11,173.51 70.04,173.44 70.04,173.38 69.63,172.97 v3(68.61,172.97)
  L3 w0.127: v3(67.67,217.17) 66.75,217.17 66.71,217.21 58.12,217.21 56.29,219.04 27.03,219.04 25.18,217.19 v3(25.18,216.76)
  L4 w0.127: v3(68.61,172.97) 68.61,185.32 72.14,188.85 72.8,188.85 83.47,199.51 v3(86.26,199.51)
BPM_CPU_N2: length 3.5
  TOP w0.089: CPU1.B54 71.88,175.25 71.75,175.19 arc(71.68,175.16) 71.61,175.11 70.49,173.99
  TOP w0.102: 70.49,173.99 70.26,173.99 69.88,173.61 TP9902.1
BPM_CPU_N3: length 4.1
  TOP w0.089: TP9903.1 70.01,175.13 71.01,176.13 71.95,176.13 72.12,176.3 72.5,176.3 72.79,176.59 CPU1.C56
BQ24737_REGN: length 7.7
  BOTTOM w0.305: 39.58,47.75 40.52,46.81 41.12,46.81 PU4404.16
  BOTTOM w0.508: 39.58,47.75 38.83,47.75 PC4416.2 38.45,47.63 PD4401.A PR5297.1 v2(35.91,49.73)
BT+:
  vias: v1(36.74,70.1)
BUZZER_SPKR_R: length 35.8
  TOP w0.102: C243.1 v3(154.08,54.61) ; R207.1 v3(155.86,82.93)
  L3 w0.102: v3(154.08,54.61) 151.34,57.35 151.34,63.17 154.85,66.68 154.85,68.46 158.02,71.63 158.02,77.84 158.1,77.92 158.1,79.3 157.64,79.76 157.64,81.15 v3(155.86,82.93)
  BOTTOM w0.102: v3(154.08,54.61) v2(153.27,54.61)
CAGND: length 20.1
  TOP w0.508: v3(34.27,28.1) 34.03,28.1 v1(33.38,28.75) 31.35,30.78 v3(31.1,30.78)
  L3 w0.508: v3(35.09,20.13) 36.23,21.27 v3(36.23,25.65)
  BOTTOM w0.305: U120.15 v3(34.27,28.1)
  BOTTOM w0.508: 33.56,19.68 34.64,19.68 v3(35.09,20.13) 35.09,20.24 35.59,20.75 R79628.2 36.14,20.89 37.03,20 C3455.2 R61.2 ; v3(31.1,30.78) 30.31,30.78 C5.2 30.2,29.27 R82.2
  vias: v3(35.47,26.42) v3(36.23,27.18) v3(36.23,26.42) v3(36.99,26.42)
CASA0#: length 44.7
  TOP w0.127: v1(62.51,102.37) 63.14,102.37 v4(63.81,103.04) ; v4(75.78,102.59) 75.78,102.18 GPU1.G19 ; v4(54.8,110.44) 54.8,110.62 54.68,110.74 54.68,110.74 54.48,110.93 53.78,110.93 53.65,110.8 53.65,110.61 53.78,110.48 MEM1.K3
  L3 w0.102: v4(75.78,102.59) 75.3,103.08 74.78,103.08 74.31,103.55 73.97,103.55 73.79,103.36 73.67,103.36
  L3 w0.165: v4(63.81,103.04) 63.89,102.96 64.91,102.96 65.03,103.09 65.03,103.29 65.16,103.41 66.4,103.41 66.53,103.29 66.53,103.08 66.65,102.95 67.17,102.95 67.3,103.08 67.3,103.24 67.42,103.36 71.62,103.36 71.76,103.23 71.76,102.89 71.9,102.75 73,102.75 73.13,102.87 73.13,103.24 73.26,103.36 73.67,103.36
  L4 w0.165: v4(54.8,110.44) 54.95,110.59 55.67,110.59 55.74,110.52 56.65,110.52 57.53,109.64 58.65,109.64 58.89,109.89 60.84,109.89 62.62,108.11 62.62,105.8 62.74,105.67 63.94,105.67 64.06,105.54 64.06,105.14 63.94,105.01 62.74,105.01 62.62,104.88 62.62,104.48 62.74,104.35 63.96,104.35 64.09,104.22 64.09,103.82 63.96,103.69 62.74,103.69 62.62,103.56 62.62,101.76 62.74,101.63 63.68,101.63 63.81,101.76 v4(63.81,103.04)
  BOTTOM w0.127: v4(54.8,110.44) 54.94,110.58 55.69,110.58 55.79,110.48 MEM3.K3
CASA1#: length 43.4
  TOP w0.127: GPU1.G16 75.68,99.4 76.29,98.78 76.29,98.59 76.54,98.34 76.54,98.09 76.99,97.65 76.99,97.52 77.37,97.13 77.37,96.78 77.5,96.65 77.71,96.65 77.83,96.52 77.83,96.27 77.73,96.17 77.5,96.17 77.37,96.04 v4(77.37,95.25) ; v4(54.95,92.24) 55.41,92.7 57.1,92.7 MEM2.K3
  L3 w0.165: v4(77.37,95.25) 77.37,95.5 76.88,95.99 76.22,95.99 76.1,95.86 76.1,95.12 75.84,94.87 75.04,94.87 74.48,95.43 72.85,95.43 72.55,95.73 68.85,95.73 68.66,95.54 67.54,95.54 67.19,95.88 62.17,95.88 61.91,96.14 61.91,96.53 61.39,97.05 61,97.05 60.67,97.38 v3(60.67,97.84)
  L4 w0.102: 59.76,93.91 56.06,93.91 55.9,93.75 55.9,93.49
  L4 w0.165: 55.9,93.49 55.3,92.89 55.3,92.59 v4(54.95,92.24) ; 59.76,93.91 60.9,93.91 61.25,94.25 61.25,95.66 60.62,96.29 60.62,96.91 60.75,97.04 61.09,97.04 61.22,97.16 61.22,97.71 61.09,97.84 v3(60.67,97.84)
  BOTTOM w0.127: v2(61.38,98.24) 61.08,98.24 60.67,97.84 v3(60.67,97.84) ; MEM4.K3 54.06,92.87 54.23,92.87 54.33,92.77 54.33,92.62 54.48,92.48 54.48,92 54.63,91.84 54.84,91.84 54.95,91.95 v4(54.95,92.24)
CATERR#_CPU: length 3.1
  TOP w0.102: v4(74.69,179.84) 74.22,179.84 CPU1.D63
  BOTTOM w0.102: v4(74.69,179.84) 74.46,179.84 73.82,179.2 TP401.1
CBN: length 6.3
  TOP w0.203: 162.97,70.76 162.97,70.96 163.51,71.49 163.51,71.65 163.53,71.67 163.53,72.57 163.59,72.63 U6.21
  TOP w0.508: 162.97,70.76 162.97,68.9 163.02,68.86 v1(163.02,68.74) 163.14,68.74 163.48,68.39 163.86,68.39 C150.2
CBP: length 6.8
  TOP w0.203: v3(165.39,72.14) 165.39,72.39 164.79,72.98 U6.24
  TOP w0.508: v3(164.63,69.22) 164.85,68.99 164.85,68.29 C150.1
  L3 w0.508: v3(164.63,69.22) 164.63,71.37 v3(165.39,72.14)
  BOTTOM w0.203: v3(165.39,72.14) v2(165.39,71.32)
CE: length 18.3
  TOP w0.102: R9504.1 72.11,58.8 71.53,58.8 v3(70.52,59.82) ; SCA1.118 62.62,57.3 v3(62.39,57.53)
  L4 w0.127: v3(62.39,57.53) 67.85,57.53 70.14,59.82 v3(70.52,59.82)
  BOTTOM w0.102: v3(62.39,57.53) 62.39,56.03 v2(62.31,55.96) 62.01,55.65 R9503.1 61.12,55.05 R9505.1
CE#_1: length 9.7
  TOP w0.102: U9501.1 79.66,62.23 76.74,59.31 75.47,59.31 74.35,58.19 v1(74.35,57.94) 73.74,58.55 R9504.2
CFG: length 6.9
  TOP w0.102: U118.23 129.21,36.56 v3(129.2,36.57)
  BOTTOM w0.102: v3(129.2,36.57) 129.2,36.58 129.12,36.66 v2(129.12,37.97) 129.12,39.1 129.47,39.46 129.47,40.92 129.9,41.35 R1594.2
CFG0: length 103.1
  TOP w0.089: v4(72.81,184.19) 73.04,183.96 73.04,183.48 73.63,182.9 CPU1.E68
  TOP w0.102: v3(44.1,225.43) 44.36,225.17 R9907.1 ; v3(20.99,217.93) 20.99,216.9 21.51,216.38 21.56,216.38 21.83,216.1 XDP1.9
  L4 w0.127: v3(71.15,220.85) 70.45,220.15 64.86,220.15 64.17,220.85 64.17,222.41 62.04,224.54 44.99,224.54 v3(44.1,225.43) 43.02,224.35 29.3,224.35 27.97,223.02 27.97,220.06 25.84,217.93 v3(20.99,217.93)
  BOTTOM w0.102: v4(72.81,184.19) v2(72.18,184.82) 71.71,185.29 71.71,191 73.03,192.32 73.03,205.43 73.46,205.86 73.46,218.06 71.99,219.53 71.99,220.01 v3(71.15,220.85)
CFG1: length 93.2
  TOP w0.089: CPU1.B67 72.31,182.9 72.03,183.18 71.65,183.18 70.89,183.95 70.89,184.17 v4(70.78,184.28)
  TOP w0.102: v3(22.26,217.04) 22.33,216.97 XDP1.11
  L3 w0.127: v3(72.17,217.81) 71.15,217.81 69.12,219.84 58.3,219.84 56.03,222.11 55.5,222.11 55.5,222.11 35.43,222.11 34.04,220.73 25.94,220.73 v3(22.26,217.04)
  BOTTOM w0.102: v3(72.17,217.81) 73.01,216.97 73.01,206.05 72.58,205.62 72.58,192.51 71.25,191.19 71.25,189.99 v2(70.54,189.28) 70.54,184.52 v4(70.78,184.28)
CFG2: length 94.9
  TOP w0.089: 70.99,182.21 71.26,181.94 73.25,181.94 CPU1.D65
  TOP w0.102: v3(23.02,217.04) 23.33,216.73 XDP1.15 ; v3(70.77,190.5) 70.31,190.04 70.31,189.12 R80163.1 70.31,188.2 70.31,182.89 70.99,182.21
  L3 w0.127: v3(23.02,217.04) 23.02,217.08 26.41,220.47 34.14,220.47 35.53,221.86 55.92,221.86 58.2,219.58 69.02,219.58 71.56,217.04 v3(72.17,217.04)
  BOTTOM w0.102: v3(72.17,217.04) 72.63,216.59 72.63,213.84 v2(72.5,213.72) 72.35,213.56 72.35,192.61 70.77,191.03 v3(70.77,190.5)
CFG3: length 107.2
  TOP w0.102: CPU1.D67 72.79,182.9 71.79,183.9 71.56,183.9 71.38,184.08 71.38,184.56 70.75,185.19 70.75,186.28 v4(71.15,186.69) 72.8,188.34 R604.1 ; v3(21.5,217.04) 21.95,217.5 23.58,217.5 23.83,217.24 XDP1.17 23.83,213.62 23.53,213.31 23.47,213.31 23.2,213.04 23.2,212.98 21.36,211.14 20.05,211.14 R9902.1
  L3 w0.127: v3(72.17,218.57) 70.75,218.57 69.23,220.09 58.41,220.09 56.13,222.37 55.4,222.37 55.4,222.37 35.26,222.37 33.87,220.98 25.43,220.98 v3(21.5,217.04)
  BOTTOM w0.102: v4(71.15,186.69) 71.15,187.47 v2(71.16,187.48) 71.16,187.51 71.48,187.83 71.48,191.1 72.8,192.42 72.8,205.52 73.24,205.95 73.24,217.5 v3(72.17,218.57)
CFG4: length 96.9
  TOP w0.089: v4(72.55,187.1) 73.19,186.46 73.19,185.98 73.82,185.35 73.82,184.84 CPU1.E70
  TOP w0.102: v4(72.55,187.1) 72.55,187.38 73.82,188.65 R605.1 ; v3(25.84,217.18) 25.84,216.6 26.33,216.1 XDP1.27
  L4 w0.127: v3(25.84,217.18) 25.84,217.57 28.27,219.99 28.27,222.95 29.4,224.09 43.13,224.09 43.28,224.24 59.38,224.24 v3(59.85,223.77)
  BOTTOM w0.102: v4(72.55,187.1) 72.5,187.15 72.5,190.77 73.72,191.99 73.72,205.14 74.18,205.6 74.18,219.68 68.94,224.92 60.99,224.92 v2(60.67,224.6) v3(59.85,223.77)
CFG5: length 102.4
  TOP w0.102: v3(26.5,216.74) 26.83,216.4 XDP1.29 ; CPU1.C68 73.46,183.62 74.06,183.02 v4(74.24,183.02)
  L4 w0.127: v3(73.06,224.03) 73.06,221.08 71.47,219.49 69.97,219.49 69.63,219.84 64.82,219.84 63.91,220.74 63.91,220.78 61.68,223.01 49.18,223.01 48.61,223.58 30,223.58 29.5,223.08 29.5,219.6 26.64,216.74 v3(26.5,216.74)
  BOTTOM w0.102: v4(74.24,183.02) 74.24,183.37 74.92,184.05 74.92,191.14 75.09,191.31 75.09,204.57 75.55,205.03 75.55,221.54 v2(74.94,222.15) v3(73.06,224.03)
CFG6: length 94
  TOP w0.089: v4(72.54,186.45) 72.93,186.06 72.93,185.96 72.94,185.96 72.94,185.6 73.1,185.44 73.1,185.05 73.46,184.68 CPU1.D68
  TOP w0.102: v3(26.76,217.52) 27.83,216.44 XDP1.33
  L4 w0.127: v3(60.61,223.77) 60.14,223.3 49.25,223.3 48.72,223.84 29.9,223.84 29.24,223.18 29.24,220.01 v3(26.76,217.52)
  BOTTOM w0.102: v3(60.61,223.77) 61.53,224.69 68.44,224.69 v2(70.8,222.33) 73.92,219.2 73.92,205.67 73.49,205.24 73.49,192.09 72.17,190.77 72.17,187.4 72.14,187.37 72.14,186.84 v4(72.54,186.45)
CFG7: length 94.7
  TOP w0.089: CPU1.C67 72.46,183.49 72.02,183.93 72.02,184.71 72.03,184.82 72.19,184.98 72.21,184.98 72.32,185.05 72.5,185.23 72.5,185.76 v4(72.54,185.79)
  TOP w0.102: XDP1.35 28.33,213.38 29.12,212.6 32.99,212.6 33.37,212.21 35.1,212.21 36.1,213.22 36.1,214.88 39.89,218.67 57.29,218.67 57.8,219.18 59.95,219.18 61.25,220.47 61.25,223.65 v3(61.37,223.77)
  BOTTOM w0.102: v4(72.54,185.79) 71.94,186.39 71.94,190.91 73.26,192.23 73.26,205.33 73.69,205.76 73.69,218.55 v2(72.91,219.33) 72.91,219.34 72.91,219.75 71.34,221.31 70.87,221.31 67.72,224.46 62.06,224.46 v3(61.37,223.77)
CFG8: length 97.3
  TOP w0.089: CPU1.F71 74.56,184.92 74.56,186.48 v4(73.78,187.25)
  TOP w0.102: v3(53.75,226.95) 53.06,227.65 24.5,227.65 21.95,225.1 21.95,222.57 21.83,222.45 XDP1.10
  BOTTOM w0.102: v3(53.75,226.95) v2(54.59,226.11) 55.13,225.58 58.13,225.58 58.16,225.6 69.22,225.6 74.86,219.96 74.86,205.32 74.4,204.86 74.4,191.71 74.23,191.53 74.23,187.7 v4(73.78,187.25)
CFG9: length 97.6
  TOP w0.089: CPU1.G69 74.88,184.48 74.88,185.01 74.74,185.15 74.74,186.93 v4(73.78,187.88)
  TOP w0.102: v3(52.99,226.95) 52.52,227.42 24.6,227.42 22.33,225.16 XDP1.12
  BOTTOM w0.102: v4(73.78,187.88) 73.68,187.99 v2(73.68,189.73) 73.68,191.3 74.18,191.8 74.18,204.95 74.63,205.41 74.63,219.87 69.13,225.37 58.25,225.37 58.23,225.35 54.59,225.35 v3(52.99,226.95)
CFG10: length 97.6
  TOP w0.089: v4(73.78,186.61) 74.36,186.04 74.36,185.16 74.36,185.16 74.36,184.69 74.68,184.37 CPU1.F70
  TOP w0.102: XDP1.16 23.33,225.83 24.69,227.19 51.5,227.19 52.2,226.49 54.06,226.49 v3(54.52,226.95)
  BOTTOM w0.102: v4(73.78,186.61) 74.46,187.29 74.46,191.33 74.63,191.5 74.63,204.76 75.09,205.22 75.09,220.45 70.04,225.5 v2(70.04,225.53) 70.01,225.53 69.71,225.83 58.06,225.83 58.04,225.81 55.66,225.81 v3(54.52,226.95)
CFG11: length 100.1
  TOP w0.102: v3(56.04,226.95) 55.35,226.26 52.11,226.26 51.41,226.96 24.79,226.96 23.83,226.01 XDP1.18 ; v4(74.87,183.01) 75.23,183.36 CPU1.G68
  BOTTOM w0.102: v4(74.87,183.01) 74.87,183.73 75.15,184.01 75.15,191.04 75.32,191.21 75.32,204.48 75.78,204.94 75.78,222.17 v2(71.94,226.01) 71.66,226.29 57.87,226.29 57.85,226.26 56.73,226.26 v3(56.04,226.95)
CFG12: length 100.7
  TOP w0.089: CPU1.H70 76.21,184.64 76.21,185.38 76.42,185.59 76.42,186 v4(76.01,186.4)
  TOP w0.102: v3(25.79,225.81) 26.33,225.26 XDP1.28
  BOTTOM w0.102: v4(76.01,186.4) 77.12,187.51 77.12,191.32 76.69,191.75 76.69,203.91 77.15,204.37 77.15,225.2 74.24,228.1 28.09,228.1 v2(26.6,226.62) v3(25.79,225.81)
CFG13: length 96.8
  TOP w0.089: v4(76.04,187.67) 75.36,186.99 75.36,185.43 CPU1.G71
  TOP w0.102: XDP1.30 26.83,223.41 26.69,223.56 26.69,225.16 v3(27.34,225.81)
  BOTTOM w0.102: v3(27.34,225.81) 29.17,227.63 73.67,227.63 v2(74.33,226.97) 76.69,224.61 76.69,204.56 76.23,204.1 76.23,191.56 76.66,191.13 76.66,188.3 v4(76.04,187.67)
CFG14: length 102.3
  TOP w0.089: CPU1.H69 75.9,183.82 75.7,184.02 75.67,184.13 75.63,184.24 75.61,184.25 75.61,186.63 v4(76.02,187.04)
  TOP w0.102: v3(26.58,225.81) 27.03,226.26 27.59,226.26 27.83,226.02 27.83,225.6 27.53,225.3 27.29,225.3 26.92,224.93 26.92,223.82 27.83,222.91 XDP1.34
  BOTTOM w0.102: v3(26.58,225.81) v2(28.36,227.59) 28.63,227.86 74.16,227.86 76.92,225.1 76.92,204.46 76.46,204.01 76.46,191.66 76.6,191.52 76.89,191.23 76.89,187.91 v4(76.02,187.04)
CFG15: length 96.2
  TOP w0.089: CPU1.G70 75.24,184.9 74.98,185.16 74.98,187.3 v4(76.08,188.4)
  TOP w0.102: XDP1.36 28.33,222.07 28.28,222.12 28.28,222.79 27.44,223.63 27.44,224.13 28.28,224.97 28.28,225.73 v3(28.35,225.81)
  BOTTOM w0.102: v3(28.35,225.81) 29.95,227.41 72.97,227.41 v2(75.83,224.55) 76.46,223.92 76.46,204.65 76,204.19 76,191.47 76.44,191.03 76.44,188.76 v4(76.08,188.4)
CFG16: length 107.1
  TOP w0.102: v3(55.28,226.95) 54.35,227.88 24.41,227.88 20.99,224.46 20.99,222.53 20.83,222.38 XDP1.6 ; CPU1.E63 74.35,180.42 74.68,180.76 v4(74.68,180.79)
  BOTTOM w0.102: v3(55.28,226.95) 56.19,226.03 57.94,226.03 57.97,226.06 70.24,226.06 v2(72.22,224.08) 75.32,220.98 75.32,205.13 74.86,204.67 74.86,191.4 74.69,191.23 74.69,185.78 73.44,184.53 73.44,183.26 71.89,181.71 71.89,181.25 72.36,180.79 73.12,180.79 73.31,180.97 74.49,180.97 v4(74.68,180.79)
CFG17: length 110.6
  TOP w0.102: v3(20.53,222.76) 20.33,222.56 XDP1.4 ; CPU1.F63 75,180.2 v4(75.37,179.83)
  BOTTOM w0.102: v3(20.53,222.76) 20.99,222.3 33.33,222.3 34.32,223.3 34.32,225.44 34.77,225.88 v2(51.82,225.88) 53.74,225.88 54.5,225.12 58.32,225.12 58.35,225.15 69.03,225.15 74.4,219.77 74.4,205.5 73.95,205.05 73.95,191.9 72.73,190.68 72.73,189.33 73.22,188.84 73.22,184.02 72.97,183.77 70.65,183.77 70.36,183.49 70.36,181 72.77,178.6 73.75,178.6 74.46,179.31 74.85,179.31 v4(75.37,179.83)
CFG18: length 103.3
  TOP w0.102: CPU1.E66 74.35,182.21 v4(74.68,181.88) ; v3(57.56,226.95) 56.42,225.81 51.92,225.81 51.22,226.5 24.98,226.5 24.47,226 24.47,223.98 25.33,223.11 XDP1.24
  BOTTOM w0.102: v3(57.56,226.95) 72.59,226.95 76.23,223.31 76.23,204.75 75.78,204.29 75.78,190.3 v2(75.93,190.14) 75.93,188.86 75.65,188.58 75.65,188.57 75.6,188.52 75.6,183.94 76.18,183.37 76.18,182.8 75.72,182.35 75.15,182.35 v4(74.68,181.88)
CFG19: length 101.2
  TOP w0.102: XDP1.22 24.83,223.23 24.24,223.82 24.24,226.09 24.88,226.73 51.31,226.73 52.01,226.03 55.89,226.03 v3(56.8,226.95) ; v4(75.77,182.97) 75.15,182.35 CPU1.F66
  BOTTOM w0.102: v3(56.8,226.95) 57.26,226.49 57.75,226.49 57.78,226.52 72.3,226.52 v2(73.95,224.87) 76,222.82 76,204.84 75.55,204.38 75.55,191.12 75.38,190.95 75.38,183.37 v4(75.77,182.97)
CFG_RCOMP: length 3.1
  TOP w0.203: CPU1.E60 74.41,178.3 v4(74.73,177.98)
  BOTTOM w0.203: v2(76.21,177.93) 76.21,178.17 R601.1 74.73,178.14 v4(74.73,177.98)
CHAR_CTL1: length 3.2
  BOTTOM w0.102: R80112.1 v2(161.58,107.7) 162.09,107.18 U9628.6
CHAR_CTL2: length 3.1
  BOTTOM w0.102: U9628.7 162.59,107.44 v2(162.85,107.7) 162.85,108.65 R80111.1
CHAR_CTL3: length 3.5
  BOTTOM w0.102: U9628.8 163.09,106.67 v2(164.12,107.7) 164.12,108.39 R80110.1
CHAR_EN: length 139
  TOP w0.102: CPU1.D9 73.29,149.68 71.61,149.68 71.37,149.45 71.37,149.4 68.61,146.63 68.3,146.63 67.83,146.16 67.83,145.14 67.32,144.63 67.32,143.85 R80133.1 67.37,143.83 68.03,144.49 68.03,144.96 v3(68.49,145.41)
  L4 w0.127: v3(68.49,145.41) 70.04,145.41 71.13,144.32 71.13,141.57 70.16,140.6 70.02,140.6 69.27,139.86 69.27,137.69 74.46,132.51 74.46,131.93 74.45,131.93 74.45,131.41 76.24,129.62 76.24,129.62 76.65,129.21 76.65,128.17 77.53,127.3 78.56,127.3 83.56,122.3 85.51,122.3 87.25,120.56 112.2,120.56 116.37,116.4 116.37,110.36 118.85,107.87 124.47,107.87 125.19,107.15 142.43,107.15 146.8,102.78 152.22,102.78 157.01,107.57 v3(157.13,107.57)
  BOTTOM w0.102: v3(157.13,107.57) 158.28,108.71 v2(159.29,108.71) 160.37,108.71 R80109.1 160.43,107.58 161.59,106.43 U9628.5
CHAR_ILIM_HI: length 3
  BOTTOM w0.254: U9628.16 161.59,102.25 v2(160.56,101.22) R80107.1
CHAR_ILIM_LO: length 2.8
  BOTTOM w0.254: R80114.1 161.83,100.52 v2(161.83,101.22) 161.83,101.59 162.09,101.85 U9628.15
CHAR_ILIM_SEL: length 4.1
  BOTTOM w0.102: v2(158.28,106.93) 158.21,106.87 R80108.1 159.62,105.79 160.4,105.02 U9628.4
CHAR_STATUS: length 3.8
  BOTTOM w0.102: TP9914.1 166.28,106.81 164.49,105.02 U9628.9
CHAR_USBOC#: length 3.5
  BOTTOM w0.102: U9628.13 163.09,101.85 163.85,101.09 v2(164.24,101.09) R80113.1
CHG_AGND: length 25.4
  TOP w0.406: PQ4401.4 56.83,41.26 56.52,41.57 56.52,42.19 56.15,42.56 PQ4401.1 55.48,42.76 v3(56.01,43.3)
  TOP w0.508: 41.69,43.66 40.42,42.39 40.42,41 39.96,40.54 37.68,40.54 36.61,41.61 v3(36.61,41.78)
  L4 w0.508: v3(56.01,43.3) 55.36,42.65 54.29,42.65 53.37,43.56 49.94,43.56 48.52,44.98 46.92,44.98 46.64,44.7 v3(45.63,44.7)
  BOTTOM w0.508: v3(36.61,41.78) 36.61,42.6 v2(36.58,42.62) 36.61,42.65 36.61,43.5 PC4411.2
CHG_ON#: length 152.5
  TOP w0.102: v3(92.49,54.74) 92.49,54.86 94.39,56.77 94.39,59.45 94.84,59.89 95.37,59.89 96.12,60.65 U4101.17 ; PR4404.2 33.18,43.5 v1(33.18,44.2) 33.18,44.58 v3(34.07,45.47) 35.69,45.47 PQ4402.G
  L3 w0.127: v3(92.49,54.74) 92.49,54.1 93.25,53.34 94.85,53.34 101.96,46.23 115.99,46.23 119.21,43.01 119.21,42.49 121.4,40.3 123.64,40.3 126.78,43.43 133.87,43.43 137.32,46.89 137.32,46.89 139.86,49.43 139.86,51.56 v3(142.4,54.1)
  L4 w0.127: v3(92.49,54.74) 91.47,53.72 88.27,53.72 86.86,52.32 86.86,49.49 82.84,45.47 71.57,45.47 70.37,44.26 63.88,44.26 57.81,38.19 52.34,38.19 50.27,40.26 41.94,40.26 37.63,44.58 34.96,44.58 v3(34.07,45.47)
  BOTTOM w0.102: v3(142.4,54.1) 142.91,54.61 143.3,54.61 143.85,55.16 143.85,55.56 144.34,56.06 145.49,56.06 145.65,55.89 R80204.1
CHG_ON#_C: length 5.8
  TOP w0.102: U109.101 143.84,52.17 143.16,52.85 v3(143.16,53.09)
  BOTTOM w0.102: v3(143.16,53.09) 143.29,52.96 144.84,52.96 v2(145.47,53.59) 145.68,53.8 145.68,54.7 R80204.2
CHG_SMB2_CLK: length 129.1
  TOP w0.203: U4101.35 89.91,59.86
  TOP w0.254: R306.1 121.57,50.8 v3(120.94,51.44) ; v3(91.35,57.05) 91.47,57.18 91.47,58.9 90.51,59.86 89.91,59.86 ; PR4432.2 v3(41.18,42.16)
  L3 w0.254: v3(120.94,51.44) 120.94,50.8 120.68,50.55 118.52,50.55 116.43,48.45 102.88,48.45 100.11,51.22 100.11,56.67 99.36,57.42 92.49,57.42 92.31,57.6 91.9,57.6 v3(91.35,57.05) ; v3(41.18,42.16) 41.48,42.47 41.48,42.85 40.52,43.81 37.47,43.81 35.59,45.69 35.59,56.99 35.2,57.39 34.82,57.39 v3(34.58,57.15)
  L4 w0.254: v3(91.35,57.05) 91.17,56.87 91.08,56.87 90.55,56.34 89.46,56.34 86.17,53.05 85.91,52.79 85.91,49.88 82.64,46.61 63.01,46.61 60.1,43.71 60.1,43.51 58.48,41.88 56.58,41.88 55.41,40.7 42.64,40.7 v3(41.18,42.16)
  BOTTOM w0.254: v3(34.58,57.15) 34.2,57.53 33.71,57.53 ; 33.71,57.53 v2(33.71,57.12) ; 33.71,57.53 33.31,57.53 33.19,57.65 RN4301.4 ; PU4404.9 41.82,42.81 v3(41.18,42.16)
CHG_SMB2_DATA: length 130.9
  TOP w0.203: U4101.34 90.05,60.26
  TOP w0.254: PR4426.2 42.07,41.47 v3(42.07,42.16) ; v3(120.94,52.2) 121.32,51.82 R307.1 ; v3(92.11,57.05) 91.85,57.3 91.85,59.05 90.65,60.26 90.05,60.26
  L3 w0.254: v3(34.58,57.91) 34.72,57.77 35.35,57.77 35.97,57.15 35.97,45.85 37.63,44.2 40.67,44.2 41.86,43 41.86,42.37 v3(42.07,42.16) ; v3(92.11,57.05) 92.12,57.04 99.2,57.04 99.73,56.52 99.73,51.06 102.72,48.07 116.59,48.07 118.68,50.16 120.84,50.16 121.32,50.64 121.32,50.93 121.57,51.18 121.57,51.56 v3(120.94,52.2)
  L4 w0.254: v3(42.07,42.16) 43.15,41.08 55.25,41.08 56.43,42.26 58.32,42.26 59.72,43.66 59.72,43.86 62.85,46.99 82.48,46.99 85.53,50.04 85.53,52.94 86.01,53.43 89.31,56.72 90.39,56.72 90.81,57.14 90.81,57.27 91.13,57.58 91.57,57.58 v3(92.11,57.05)
  BOTTOM w0.254: v2(33.71,58.52) 33.4,58.2 ; 33.4,58.2 33.69,57.91 v3(34.58,57.91) ; 33.4,58.2 33.3,58.3 RN4301.3 ; PU4404.8 42.32,42.42 v3(42.07,42.16)
CK_48M_SIO: length 3.4
  TOP w0.102: OSC2.3 120.76,61.72 v3(121.06,61.42) 121.64,61.99 R79943.1
  BOTTOM w0.102: v2(121.06,62.23) v3(121.06,61.42)
CK_48M_SIO_C: length 7.5
  TOP w0.102: R79943.2 122.98,62.56 124.38,62.56 124.39,62.57 v3(125.31,62.57) U109.34
  BOTTOM w0.102: v3(125.31,62.57) v2(126.12,62.57)
