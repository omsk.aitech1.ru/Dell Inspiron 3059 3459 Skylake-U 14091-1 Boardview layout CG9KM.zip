# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2_P1: length 115.1
  TOP w0.102: v3(156.37,104.65) 156.5,104.78 R80100.2 ; CPU1.AD7 84.02,147.98 84.31,147.98 84.47,148.14 v4(84.47,148.25)
  L3 w0.089: 85.17,146.15 85.14,146.19 85.14,147.73 84.9,147.97 84.75,147.97 v4(84.47,148.25)
  L3 w0.127: 85.17,146.15 85.17,145.47 84.79,145.08 84.79,141.63 85.45,140.97 85.45,131.27 95.75,120.97 114.01,120.97 114.44,120.54 126,120.54 126.82,119.71 156.55,119.71 157.89,118.37 157.89,110.49 156.43,109.03 156.43,107.13 155.46,106.15 155.46,104.67 155.73,104.4 156.12,104.4 v3(156.37,104.65)
  BOTTOM w0.102: v2(155.56,104.9) 156.12,104.9 v3(156.37,104.65) 156.5,104.78 R80100.2
USB2_P2: length 221.4
  TOP w0.089: v4(85.35,143.13) 85.57,143.35 85.96,143.35 86.26,143.64 86.26,144.79 86.25,144.8 86.25,144.81 86.19,144.93 86.19,145.08 86.25,145.21 86.25,145.46 86.19,145.58 86.19,145.73 86.25,145.86 86.36,145.97 87.12,145.97 CPU1.AJ3
  TOP w0.102: v3(105.06,37.85) 105.1,37.81 TR7.4
  L3 w0.127: v4(85.35,143.13) 85.72,143.13 85.89,142.96 85.89,131.44 95.93,121.4 114.47,121.4 114.84,121.03 126.12,121.03 126.92,120.23 156.92,120.23 158.33,118.82 158.33,95.14 147.84,84.65 147.84,68.56 144.81,65.54 144.81,48.73 139.33,43.24 136.27,43.24 134.91,41.88 134.91,39.9 133.26,38.25 129.05,38.25 128.73,38.57 120.8,38.57 119.49,39.88 115.05,39.88 113.4,41.53 106.18,41.53 105.23,40.57 105.23,38.01 v3(105.06,37.85)
  BOTTOM w0.102: v2(84.54,142.85) 84.54,142.87 84.79,143.13 v4(85.35,143.13)
USB2_P3: length 223.7
  TOP w0.102: v4(84.49,150.29) 84.22,150.02 CPU1.AD10 ; TR5.1 107.94,37.81 v3(107.98,37.85)
  L3 w0.089: v4(84.49,150.29) 84.7,150.08 84.87,150.08 85.09,149.86 85.09,149.38 86.18,148.29 86.18,146.32 86.22,146.28 86.22,146.26
  L3 w0.127: 86.22,146.26 86.22,144.76 86.85,144.13 86.85,132.03 96.51,122.36 114.9,122.36 115.21,122.06 126.76,122.06 127.27,121.55 156.98,121.55 159.29,119.24 159.29,94.72 149.52,84.96 149.52,68.21 147.37,66.05 147.37,65.8 145.84,64.28 145.84,48.39 139.73,42.28 136.67,42.28 136.08,41.69 136.08,39.65 133.63,37.21 128.68,37.21 128.42,37.48 123.35,37.48 122.32,36.45 121.04,36.45 119.13,38.35 114.49,38.35 112.62,40.22 109.06,40.22 107.89,39.05 107.89,37.93 v3(107.98,37.85)
  BOTTOM w0.102: v2(107.96,36.98) 107.98,37.01 v3(107.98,37.85)
USB2_P4: length 163.8
  TOP w0.102: TR1.4 164.84,190.74 164.61,190.51 164.61,190.13 165.77,188.97 165.77,184.66 165.01,183.9 161.86,183.9 ; 161.86,183.9 v1(161.86,183.54) ; 161.86,183.9 158.96,183.9 158.64,183.58 158.64,182.77 v3(158.91,182.5) ; v4(87.28,142.88) 87.69,142.88 87.95,142.61 88.29,142.61 88.6,142.93 88.6,143.71 87.13,145.19 CPU1.AJ2
  L3 w0.127: v3(158.91,182.5) 158.66,182.25 158.66,181.91 159.27,181.31 159.27,127.54 154.78,123.05 127.43,123.05 127.06,123.41 115.89,123.41 115.73,123.57 97.06,123.57 88.81,131.83 88.81,141.35 87.43,142.72 v4(87.28,142.88)
USB2_P5: length 214.3
  TOP w0.102: v4(85.55,147.81) 85.47,147.81 85.22,148.06 CPU1.AF7 ; TR9.1 31.55,14.07 31.55,14.46 31.4,14.61 29.45,14.61 28.24,15.81 24.83,15.81 21.79,18.85 21.79,39.46 23.06,40.73 23.06,42.89 23.86,43.69 26.27,43.69 26.49,43.9 27.63,43.9 30.68,46.95 30.68,51.35 27.41,54.61 26.78,54.61 25.85,55.54 25.85,71.46 26.99,72.61 27.76,72.61 31.31,76.16 31.31,76.92 31.69,77.3 33.9,77.3 34.6,76.61 37.9,76.61 40.08,78.78 40.08,110.66 41.02,111.59 44.61,111.59 44.86,111.85 v3(44.86,111.89)
  L3 w0.127: v3(44.86,111.89) 45.12,111.63 45.37,111.63 45.5,111.76 45.5,119.9 53.11,127.51 70.91,127.51 78.03,120.39 83.09,120.39 83.27,120.57 v3(83.27,120.84)
  BOTTOM w0.102: 88.06,130.84 88.06,133.36 86.53,134.89 86.53,144.79 84.82,146.51 84.82,147.35 85.28,147.81 v4(85.55,147.81) ; 88.06,130.84 v2(87.69,130.84) ; 88.06,130.84 88.06,129.6 88.84,128.82 88.84,126.33 83.98,121.46 83.98,121.21 83.61,120.84 v3(83.27,120.84)
USB2_P6: length 215.5
  TOP w0.102: TR12.1 109.47,198.37 109.34,198.25 109.15,198.25 109.02,198.12 109.02,197.97 109.19,197.8 112.86,197.8 ; v4(87.28,141.6) 87.08,141.81 86.9,141.81 86.77,141.68 86.77,141.3 86.65,141.17 86.25,141.17 86.13,141.3 86.13,142.07 86.77,142.72 86.77,145.29 86.47,145.59 CPU1.AH2 ; v3(146.46,197.74) 146.72,197.49 146.72,197.23 146.55,197.07 145.13,197.07 142.47,199.73 120.21,199.73 118.28,197.8 112.86,197.8 ; v1(112.86,198.22) 112.86,197.8
  L3 w0.127: v4(87.28,141.6) 87.47,141.42 87.95,141.42 88.29,141.08 88.29,131.7 96.85,123.14 115.27,123.14 115.59,122.82 127.02,122.82 127.42,122.42 154.87,122.42 159.71,127.26 159.71,187.03 155.23,191.52 155.23,193.93 152.35,196.81 147.14,196.81 146.72,197.23 146.72,197.49 v3(146.46,197.74)
USB2N_EXT: length 20.3
  TOP w0.102: USB3.2 100.44,38.03 99.33,36.92 99.33,32.47 101.99,29.82 102.05,29.76 105.6,29.76 105.98,30.14 105.98,31.79 105.51,32.26 D24.3 105.58,33.68 105.58,35.14 105.78,35.34 TR7.2
USB2P_EXT: length 20.3
  TOP w0.102: TR7.3 105.1,35.35 105.37,35.09 105.37,34.39 105.27,34.29 105.14,34.29 105.04,34.19 105.04,33.02 105.29,32.77 105.29,32.17 105.76,31.7 105.76,31.17 D24.4 105.76,30.66 105.76,30.23 105.51,29.97 102.14,29.97 99.55,32.56 99.55,36.83 99.86,37.13 100.62,37.13 101.06,36.69 USB3.3
USB3_TX0_EMI_DN: length 3.9
  TOP w0.102: 162.77,116.22 163.36,116.22 163.6,115.99 L4.1 ; 162.77,116.22 161.28,116.22 C91.2 ; 162.77,116.22 v1(162.77,115.8)
USB3_TX0_EMI_DP: length 3.9
  TOP w0.102: C1757.2 161.15,116.44 161.88,116.44 ; L4.4 163.6,116.67 163.36,116.44 161.88,116.44 ; v1(161.88,116.87) 161.88,116.44
USB3_TX1_EMI_DN: length 4.2
  TOP w0.102: v1(162.62,96.75) 162.62,97.17 ; 162.62,97.17 160.9,97.17 C113.2 ; 162.62,97.17 163.24,97.17 163.47,96.94 L56.1
USB3_TX1_EMI_DP: length 4.1
  TOP w0.102: 161.6,97.39 160.77,97.39 C111.2 ; 161.6,97.39 163.24,97.39 163.47,97.62 L56.4 ; 161.6,97.39 v1(161.6,97.82)
USB3N_EXT: length 25.9
  TOP w0.102: TR5.3 107.26,35.34 107.53,35.08 107.53,34.71 107.67,34.57 107.67,33.86 D24.1 107.41,31.97 106.94,31.5 106.94,30.23 107.2,29.97 107.2,28.73 103.07,24.6 103.07,14.72 102.49,14.14 101.74,14.14 101.09,14.79 USB4.2
USB3P_EXT: length 25.8
  TOP w0.102: TR5.2 107.94,35.37 107.74,35.17 107.74,34.8 107.88,34.66 107.88,33.02 107.63,32.77 107.63,31.88 107.41,31.66 D24.6 107.41,28.64 103.28,24.51 103.28,14.63 102.58,13.92 101.98,13.92 USB4.3
USB30_RX_CPU_N0: length 127.1
  TOP w0.102: v3(154.34,114.43) 154.05,114.72 154.05,114.97 154.17,115.1 156.94,115.1 157.98,114.07 159.93,114.07 ; 159.93,114.07 163.36,114.07 163.6,113.83 L5.1 ; 159.93,114.07 v1(159.93,113.72) ; v4(76.69,148.72) 76.36,149.05 CPU1.H8
  L3 w0.127: v4(76.69,148.72) 76.26,148.29 70.59,148.29 69.25,146.94 68.3,146.94 67.09,145.73 67.09,140.46 74.61,132.94 80.77,132.94 95.51,118.2 124.91,118.2 126.7,116.41 153.56,116.41 154.03,115.93 154.03,114.73 v3(154.34,114.43)
USB30_RX_CPU_N1: length 144.2
  TOP w0.102: 158.73,95.02 v1(158.73,94.61) ; 158.73,95.02 162.44,95.02 162.68,94.78 L57.1 ; 158.73,95.02 156.52,95.02 v3(156.24,94.74) ; CPU1.J6 77.01,148.12 v4(76.69,147.8)
  L3 w0.127: v4(76.69,147.8) 76.49,147.6 76.49,147.32 76.11,146.95 73.44,146.95 73.2,147.18 70.63,147.18 69.26,145.81 69.26,139.3 74.91,133.65 81.07,133.65 95.16,119.56 113.01,119.56 113.55,119.01 125.11,119.01 126.96,117.16 154.5,117.16 155.11,116.55 155.11,113.01 155.74,112.39 155.74,107.57 154.73,106.57 154.73,102.22 157.84,99.11 157.84,95.56 157.26,94.97 156.47,94.97 v3(156.24,94.74)
USB30_RX_CPU_P0: length 127.1
  TOP w0.102: L5.4 163.6,114.51 163.36,114.28 161.96,114.28 ; v3(153.58,114.43) 153.83,114.68 153.83,115.06 154.08,115.32 157.03,115.32 158.07,114.28 161.96,114.28 ; v1(161.96,114.66) 161.96,114.28 ; CPU1.G8 75.71,149.05 v4(76.04,148.72)
  L3 w0.127: v4(76.04,148.72) 75.87,148.55 70.48,148.55 69.14,147.21 68.19,147.21 66.82,145.84 66.82,140.35 74.5,132.67 80.66,132.67 95.4,117.93 124.8,117.93 126.59,116.14 153.45,116.14 153.77,115.82 153.77,114.62 v3(153.58,114.43)
USB30_RX_CPU_P1: length 144.1
  TOP w0.102: v4(76.04,147.8) 76.36,148.12 CPU1.H6 ; v3(156.24,95.5) 156.52,95.23 161.02,95.23 ; L57.4 163.56,95.46 163.43,95.34 163.43,95.13 163.3,95 162.77,95 162.53,95.23 161.02,95.23 ; 161.02,95.23 v1(161.02,95.61)
  L3 w0.127: v4(76.04,147.8) 76.22,147.62 76.22,147.43 76,147.21 73.55,147.21 73.31,147.45 70.52,147.45 68.99,145.92 68.99,139.19 74.8,133.38 80.96,133.38 95.05,119.29 112.9,119.29 113.44,118.75 125,118.75 126.85,116.89 154.39,116.89 154.85,116.44 154.85,112.9 155.47,112.28 155.47,107.68 154.47,106.68 154.47,102.11 157.58,99 157.58,95.67 157.14,95.24 156.51,95.24 v3(156.24,95.5)
USB30_TX_CPU_N0: length 126.6
  TOP w0.089: 69.63,151.44 69.63,151.38 70.07,150.94 70.84,150.94 71.36,151.46 71.36,151.95 71.42,152.01 71.62,152.09 71.75,152.09 71.91,152.01 72.09,152.01 72.25,152.08 72.43,152.08 72.61,152 72.8,152 CPU1.C13
  TOP w0.102: 158.25,115.84 153.92,115.84 153.03,114.95 153.03,114.34 152.75,114.06 152.32,114.06 v3(152.18,113.92) ; 158.25,115.84 v1(158.25,115.44) ; 158.25,115.84 159.04,115.84 159.36,116.16 159.65,116.16 C91.1 ; 69.63,151.44 69.43,151.64 v4(69.43,151.64)
  L3 w0.127: v3(152.18,113.92) 151.94,114.16 151.18,114.16 150.6,114.74 125.7,114.74 123.93,116.51 94.8,116.51 80.07,131.24 73.9,131.24 65.3,139.84 65.3,146.55 67.2,148.45 67.2,150.46 67.79,151.04 69.41,151.04 69.61,151.24 69.61,151.45 v4(69.43,151.64)
USB30_TX_CPU_N1: length 137.6
  TOP w0.102: CPU1.B13 72.12,151.6 72.12,151.38 71.86,151.13 71.69,151.13 70.93,150.37 69.93,150.37 69.72,150.15 69.72,149.77 v4(69.88,149.61) ; v1(158.48,96.34) 158.48,96.76 ; 158.48,96.76 157.73,96.76 157.31,97.18 156.4,97.18 v3(156.24,97.03) ; 158.48,96.76 159.6,96.76 C113.1
  L3 w0.127: v3(156.24,97.03) 156.52,97.31 156.73,97.31 157.15,97.72 157.15,98.82 153.97,102 153.97,106.82 154.97,107.83 154.97,112 153.08,113.89 153.08,115.11 152.48,115.71 126.13,115.71 124.34,117.49 95.21,117.49 80.48,132.23 74.31,132.23 66.28,140.26 66.28,146.13 68.36,148.21 68.99,148.21 69.66,148.88 69.66,149.39 v4(69.88,149.61)
USB30_TX_CPU_P0: length 126.7
  TOP w0.089: 69.93,151.51 69.93,151.35 70.15,151.13 70.76,151.13 71.17,151.54 71.17,152.03 71.33,152.19 71.39,152.19 71.59,152.27 71.79,152.27 71.95,152.19 72.05,152.19 72.21,152.26 72.47,152.26 72.65,152.17 73.28,152.17 CPU1.D13
  TOP w0.102: 153.21,115.43 153.83,116.05 158.95,116.05 159.28,116.38 159.65,116.38 C1757.1 ; 153.21,115.43 v1(152.94,115.7) ; 153.21,115.43 152.81,115.04 152.81,114.43 152.66,114.27 152.47,114.27 152.18,114.57 v3(152.18,114.68) ; 69.93,151.51 v4(70.06,151.64)
  L3 w0.127: v4(70.06,151.64) 69.88,151.45 69.88,151.13 69.52,150.77 67.9,150.77 67.47,150.35 67.47,148.34 65.57,146.43 65.57,139.95 74.01,131.51 80.18,131.51 94.91,116.78 124.04,116.78 125.81,115.01 150.71,115.01 151.29,114.43 151.93,114.43 v3(152.18,114.68)
USB30_TX_CPU_P1: length 137.5
  TOP w0.102: 69.64,150.38 69.84,150.58 70.84,150.58 71.69,151.43 CPU1.A13 ; 69.64,150.38 69.5,150.24 69.5,149.94 v4(69.17,149.61) ; 69.64,150.38 v1(69.35,150.67) ; C111.1 159.19,97.66 159.06,97.54 159.06,97.1 158.94,96.98 157.82,96.98 157.4,97.4 156.64,97.4 v3(156.24,97.79)
  L3 w0.127: v4(69.17,149.61) 69.4,149.38 69.4,148.99 68.88,148.48 68.25,148.48 66.01,146.24 66.01,140.15 74.2,131.96 80.37,131.96 95.1,117.23 124.23,117.23 126.02,115.44 152.37,115.44 152.81,115 152.81,113.78 154.71,111.89 154.71,107.94 153.7,106.93 153.7,101.89 156.88,98.71 156.88,97.83 156.62,97.57 156.46,97.57 v3(156.24,97.79)
USB_EN: length 5.4
  BOTTOM w0.102: R1783.2 123.29,13.27 123.73,12.83 v2(123.73,12.42) 123.63,12.32 C1764.2 122.78,12 C249.1 Q43.4
USB_EN1: length 5.8
  BOTTOM w0.102: 120.4,16.26 120.37,16.26 R1781.1 119.87,16.91 Q1217.3 v2(121.14,18.21) ; 120.4,16.26 120.4,15.75 119.77,15.11 R1780.2 ; 120.4,16.26 Q1217.2
USB_EN2: length 5.5
  BOTTOM w0.102: Q1217.6 123.02,14.34 R1783.1 R1779.1 121.51,14.16 v2(120.89,13.54) 120.58,13.23 120.58,13.04 R1777.2
USB_OC#0_1: length 173
  TOP w0.102: v3(68.49,146.18) 68.58,146.18 71.69,149.28 CPU1.A9 ; v3(156.45,110.32) 156.45,110.97 v1(155.7,111.72) 154.26,113.16 151.28,113.16 150.96,113.48 150.96,115.12 152.29,116.46 158.78,116.46 159.55,117.22 159.89,117.22 R1728.2 163.48,118.91 R1727.1 C1756.1
  L4 w0.127: v3(68.49,146.18) 68.85,145.81 69.95,145.81 71.53,144.22 71.53,141 72.64,139.89 72.64,135.12 74.71,133.05 74.71,131.83 74.71,131.51 76.35,129.87 76.91,129.31 76.91,128.28 77.63,127.55 78.67,127.55 83.67,122.56 85.81,122.56 87.53,120.83 112.3,120.83 119.79,113.33 119.79,109.58 121.25,108.13 124.58,108.13 125.3,107.4 142.53,107.4 146.9,103.04 151.9,103.04 153.45,104.58 153.45,108.49 155.28,110.32 v3(156.45,110.32)
  BOTTOM w0.102: R80113.2 166.34,100.14 164.75,98.55 160.13,98.55 159.47,99.22 159.47,100.28 158.66,101.09 155.86,101.09 154.85,102.11 154.85,108.71 v3(156.45,110.32)
USB_OC#2_3: length 195.5
  TOP w0.089: 72.17,149.07 72.72,149.07 CPU1.C9
  TOP w0.102: C12363.1 90.33,19.88 R80103.2 ; C12363.1 R80102.1 ; C12363.1 90.08,20.89 89.57,21.4 v3(89.57,22.73) ; 72.17,149.07 72.12,149.07 69.44,146.38 69.44,142.42 68.68,141.66 67.52,141.66 v1(67.42,141.56) 65.49,139.62 58.83,139.62 58.78,139.62 54.59,135.43 42.53,135.43 39.11,132.02 39.11,131.03 38.64,130.56 36.1,130.56 v3(35.59,130.05)
  L3 w0.127: v3(89.57,22.73) 89.57,37.18 85.95,40.8 85.95,43.18 85.15,43.98 70.27,43.98 62.68,51.57 62.16,51.57 59.88,53.85 59.69,53.85 57.18,56.36 57.18,57.02 56.8,57.4 56.8,58.01 45.42,69.39 45.42,76.97 36.69,85.7 36.69,88.12 34.69,90.11 34.69,121.88 36.27,123.45 36.27,124.76 38.09,126.59 38.09,129.48 37.53,130.05 v3(35.59,130.05)
USB_PCH_DN4_NN: length 6.6
  TOP w0.102: TR1.2 164.16,193.05 164.39,193.28 164.39,194.93 163.77,195.55 163.77,196.09 ; v1(163.41,196.09) 163.77,196.09 ; 163.77,196.09 163.77,196.73 163.25,197.25 WEBCM1.2
USB_PCH_DP4_PP: length 6.6
  TOP w0.102: v1(164.98,193.85) 164.61,193.85 ; 164.61,193.85 164.61,195.01 163.98,195.64 163.98,196.73 164.5,197.25 WEBCM1.1 ; 164.61,193.85 164.61,193.28 164.84,193.05 TR1.3
USB_TOUCH_N: length 8
  TOP w0.102: v1(31.96,10.06) 31.69,10.33 ; 31.69,10.33 30.89,9.53 30.89,8.71 29.95,7.77 29.64,7.77 29.38,7.5 TOUCH1.4 ; 31.69,10.33 31.78,10.41 31.78,10.73 C1774.1 31.81,11.59 31.81,12.19 32,12.37 TR9.3
USB_TOUCH_P: length 8.7
  TOP w0.102: TOUCH1.3 29.37,8.5 29.49,8.38 29.49,8.1 29.61,7.98 29.86,7.98 30.68,8.8 30.68,9.61 31.57,10.5 31.57,10.82 C1773.1 31.6,11.56 31.6,12.19 31.32,12.48 TR9.2 v1(30.16,12.58)
USBCOMP: length 3.5
  TOP w0.102: CPU1.AB6 83.22,147.41 v4(83.4,147.59)
  BOTTOM w0.102: R1603.1 83.98,145.77 v2(83.75,146) 83.23,146.52 83.23,147.42 v4(83.4,147.59)
USBP0N_EXT: length 21
  TOP w0.102: SSUSB1.2 172.62,117.28 173.92,115.98 174.68,115.98 175.41,115.25 175.41,112.46 173.98,111.04 173.98,109.31 175.01,108.28 175.01,106.76 174.66,106.4 172.55,106.4 171.83,107.12 171.25,107.12 171.03,106.9 D4.1 170.77,107.12 170.48,107.12 170.23,106.87 170.08,106.72 TR3.3
USBP0P_EXT: length 20.9
  TOP w0.102: SSUSB1.3 172.62,116.63 172.72,116.73 172.86,116.73 173.83,115.76 174.59,115.76 175.19,115.16 175.19,112.55 173.77,111.13 173.77,109.22 174.8,108.19 174.8,106.85 174.57,106.62 173.97,106.62 D4.6 173.4,106.87 173.15,106.62 172.64,106.62 171.91,107.34 170.39,107.34 169.99,106.94 169.58,106.94 169.45,107.06 169.45,107.42 169.32,107.54 169.19,107.54 169.04,107.4 TR3.2
USBP1N_EXT: length 19.5
  TOP w0.102: TR5205.3 169.44,104.43 v3(169.48,104.39) 169.48,104.51 170.19,105.22 170.48,105.22 170.73,104.97 D4.3 171.43,104.97 171.69,105.22 172.87,105.22 173.03,105.05 173.03,104.6 173.13,104.5 173.79,104.5 174,104.28 174,100.74 175.17,99.57 175.17,96.95 174.66,96.44 173.81,96.44 172.93,95.57 172.61,95.57 172.44,95.75 172.44,96.16 SSUSB2.2
  BOTTOM w0.102: TR5205.3 169.44,104.43 v3(169.48,104.39)
USBP1P_EXT: length 19.5
  TOP w0.102: TR5205.2 169.44,105.12 v3(169.48,105.16) 169.82,105.16 170.1,105.44 172.98,105.44 173.45,104.97 D4.4 173.72,104.87 174.21,104.37 174.21,100.83 175.38,99.66 175.38,96.86 174.75,96.23 173.9,96.23 173.02,95.35 172.78,95.35 172.62,95.19 SSUSB2.3
  BOTTOM w0.102: v3(169.48,105.16) 169.44,105.12 TR5205.2
USBVCC01: length 45.2
  TOP w0.508: 171.73,120.34 SSUSB1.1 172.62,121.23 ; 165.98,124.21 TC8.1 ; TC8.1 167.04,125.26 ; TC8.1 167.04,123.15 ; TC8.1 168.09,124.21 ; v5(175.67,107.06) C1753.2 175.48,105.92 D4.5
  TOP w0.762: v5(163.99,102.74) v5(172.62,102.74)
  L3 w1.016: SSUSB2.1 v5(172.62,102.74) 172.62,104.01 v5(175.67,107.06)
  L3 w1.27: v5(169.71,120.9) 170.77,119.84 170.77,111.96 v5(175.67,107.06)
  BOTTOM w0.305: v5(163.99,102.74) 163.99,103.42 U9628.12
  BOTTOM w0.508: v5(169.71,120.9) 169.71,120.88 v2(169.04,120.22)
USBVCC23: length 28.7
  TOP w0.508: 92.36,13.3 TC23.1 ; TC23.1 91.31,14.35 ; TC23.1 93.42,14.35 ; TC23.1 92.36,15.41 ; D24.5 106.46,29.65 C271.1 105.63,28.64 105.14,28.14 103.54,28.14 103.03,28.66 v3(103.03,28.83) ; 101.06,39.5 USB3.1 ; USB3.1 100.03,40.53 ; USB3.1 101.06,41.56 ; 100.06,17.53 USB4.1 ; USB4.1 101.09,16.5 ; USB4.1 101.09,18.56
  L3 w0.508: USB3.1 103.03,38.56 v3(103.03,28.83)
USBVCCTP: length 8
  TOP w0.254: v5(28.27,5.59) 28.43,5.59 28.96,5.05 v1(28.96,3.43)
  TOP w0.635: TOUCH1.5 28.47,5.8 v5(28.27,5.59)
  BOTTOM w0.889: v5(28.27,5.59) 28.27,6.26 27.47,7.06 C592.1 24.82,7.06 F15.2
V_0P675_S3: length 81.8
  TOP w0.305: DIMM1.203 131.2,127.02
  TOP w0.33: v5(144.94,127.31) 145.18,127.55 DIMM2.203 ; DIMM2.204 153.18,127.25 v5(152.82,127.61) ; v5(137.75,127.53) 138.02,127.26 139.39,127.26 DIMM1.204
  TOP w1.016: 126.53,127.39 126.53,129.29 121.6,134.21 121.6,178.54 107.2,192.94 105.8,192.94 v5(105.06,193.68)
  vias: v2(101.48,197.18) v2(154.29,127.38) v4(129.83,127.64)
V_1P5_HDMI: length 26.3
  TOP w0.203: U118.19 131.35,39.88 130.72,40.51 C12203.1 ; U118.20 130.95,38.69 130.65,38.99 C12205.1 ; U118.31 130.4,33.02 ; 135.16,33.02 U118.40 ; 134.65,39.24 134.15,38.74 U118.12
  TOP w0.508: v3(137.87,31.58) 137.57,31.58 137.06,32.09 C12202.1 135.88,33.02 135.16,33.02 ; 130.4,33.02 129.76,32.38 C12204.1 129.76,31.05 129.45,30.73 v3(128.81,30.73) ; C12206.1 135.03,39.62 134.65,39.24
  L3 w0.508: v3(128.81,30.73) 129.11,31.03 129.11,31.07 130.57,32.54 136.74,32.54 137.52,31.75 137.57,31.75 137.74,31.58 v3(137.87,31.58)
  BOTTOM w0.508: v3(128.81,30.73) 128.28,31.27 128.25,31.27 v2(128.2,31.32)
  vias: v2(137.5,30.86) v3(138.97,40.64)
V_1P05_LAN: length 6.1
  TOP w0.203: U16.22 v3(34.58,14.26) ; U16.24 v3(35.79,12.42) ; v3(40.67,17.02) 40.17,17.02 39.96,16.81 U16.8 ; v3(38.42,11.28) 38.48,11.33 U16.30 ; v3(40.93,14.21) 40.88,14.26 U16.3
  vias: v2(34.37,16.59) v2(40.93,19) v3(35.16,11.89)
V_3_CARD: length 21.7
  TOP w0.508: MEMCD1.4 166.41,144.09 166.83,143.66 v3(168.31,143.66)
  L3 w0.508: v4(172.63,135.89) 171.71,135.89 170.59,137.01 170.59,141.38 v3(168.31,143.66)
  BOTTOM w0.203: U14.12 174.98,141.5 174.51,141.02
  BOTTOM w0.508: v4(172.63,135.89) 173.11,135.89 v2(173.74,136.53) 173.74,137.74 C330.1 174.34,138.54 C12161.2 C329.2 174.51,139.99 174.51,141.02
V_3P0_BAT_VREG: length 127
  TOP w0.254: v3(107.86,138.18) 107.17,138.86 107.17,140.95 103.3,144.82 v3(103.3,145.02) 103.3,145.05 103.44,145.19 103.44,146.6 C2119.1 C2118.1 C2117.1 102.97,149.8 R2106.1 ; v3(146.59,80.52) 147.35,80.52 147.73,80.9 R322.2 146.07,81.53 D2.3
  L4 w0.254: v3(147.86,118.75) 146.15,120.46 139.54,120.46 136.13,117.06 134.87,117.06 129.62,117.06 112.82,133.86 111.81,133.86 111.29,134.39 111.29,134.75 v3(107.86,138.18)
  BOTTOM w0.254: v3(103.3,145.02) 103.81,144.5 105.43,144.5 105.65,144.73 106.42,144.73 109.76,148.07 v2(109.76,149.48) 109.76,151.64 109.32,152.08 R80057.1 109.63,152.59 109.63,153.93 109.26,154.31 108.17,154.31 R80059.1 ; R80038.1 107.92,138.24 v3(107.86,138.18) ; v3(146.59,80.52) 146.59,87.86 v2(146.29,88.16) 145.65,88.8 145.65,116.54 v3(147.86,118.75)
V_3P3_A: length 574.1
  TOP w0.178: R80054.2 108.49,121.23 110.65,119.08 110.65,118.11 110.52,117.98
  TOP w0.203: U109.32 130.21,64.52 v3(129.7,65.02) ; v3(143.04,65.91) 143.01,65.89 U109.1 ; U109.64 125.96,50.57 125.92,50.61
  TOP w0.254: R80254.2 140.88,84.33 146.9,90.35
  TOP w0.305: RN7.3 120.25,55.7 119.54,54.99 v3(119.54,54.36) 120.23,55.05 RN7.4 ; R79936.1 124.15,52.07 v3(123.48,52.07)
  TOP w0.381: v3(123.48,49.66) 123.55,49.66 124.51,50.61 C185.1 125.92,50.61
  TOP w0.508: R80041.1 104.94,118.9 105.85,117.98 114.99,117.98 v1(115.1,118.08) 115.2,117.98 126.79,117.98 130.37,114.4 136.16,114.4 144.02,106.54 144.02,93.22 146.9,90.35 149.16,90.35 150.27,89.23 150.27,84.12 149.59,83.44 149.03,83.44 148.43,82.84 R319.1 146.16,82.68 D2.1 145.69,82.41 v3(144.81,81.53) ; v3(112.17,60.45) 112.43,60.2 L9525.1 113.44,60.07 R80151.1 ; 35.53,42.1 36.1,42.67 PR4407.1 37.69,42.1 v3(37.37,41.78) ; 35.53,42.1 R80223.2 PR4404.1 ; 35.53,42.1 35.59,42.04 35.59,41.53 37.5,39.62 40.42,39.62 41.18,40.39 PR4432.1 PR4426.1 ; PR4434.1 PR4402.1 47.72,43.12 v3(47.4,42.8) ; PC4501.1 135.48,13.14 ; v3(147.02,35.18) 147.61,35.76 147.61,39.88 149.59,41.86 C195.1
  L3 w0.254: v3(34.07,52.96) 33.54,52.43 33.54,46.75 34.6,45.69 34.6,44.55 v3(37.37,41.78)
  L3 w0.508: v3(123.48,52.07) 121.19,54.36 v3(119.54,54.36) ; v3(47.4,42.8) 47.38,42.82 45.65,42.82 44.33,41.5 37.65,41.5 v3(37.37,41.78) ; v3(27.85,25.25) 27.85,23.57 28.18,23.24 28.18,9.35 27.54,8.71 v3(27.13,8.71)
  L3 w0.762: v3(112.17,60.45) 111.03,61.59 101,61.59 97.95,64.64 v5(95.28,64.64)
  L4 w0.508: v3(147.02,35.18) 146.02,35.18 144.37,33.53 130.48,33.53 129.29,32.34 129.29,32.33 128.48,31.52 126.68,31.52 125.64,30.48 v3(125.13,30.48) ; v3(37.37,41.78) 37.37,41.61 36.88,41.12 36.25,41.12 35.87,41.5 31.84,41.5 25.46,35.12 25.46,31.86 25.28,31.68 25.28,29.28 27.08,27.47 27.08,26.01 v3(27.85,25.25) ; v3(143.04,65.91) 142.37,65.25 137.94,65.25 136.61,66.57 131.17,66.57 130.72,66.12 130.72,65.49 130.25,65.02 v3(129.7,65.02) ; v5(133.61,9.4) 133.61,8.23 128.13,2.74 25.17,2.74 24.29,3.62 24.29,5.46 27.13,8.31 v3(27.13,8.71)
  L4 w0.762: v5(133.61,9.4) 133.48,9.27 129.32,9.27 128.35,8.3 124.05,8.3 122.79,9.56 122.79,16.05 121.93,16.92 121.93,20.9 122.11,21.08 122.11,23.06 122.05,23.11 122.05,27.15 125.13,30.23 v3(125.13,30.48)
  BOTTOM w0.254: v3(147.02,35.18) 147.51,35.18 151.34,39.01 151.34,44.01 151.91,44.58 155.35,44.58 156.12,45.34 156.88,45.34 ; 156.88,45.34 157.77,44.45 R79984.1 R390.1 ; 156.88,45.34 156.88,50.8 156.37,51.31 R79989.1 ; PR4450.2 26.96,57.15 26.2,56.39 26.2,55.37 26.86,54.71 27.63,54.71 28.13,54.2 32.82,54.2 v3(34.07,52.96) ; PG4501.1 v5(133.87,10.29)
  BOTTOM w0.508: v5(95.28,64.64) 94.33,65.6 C6725.2 R80228.2 ; v2(38.29,42.01) 38.06,42.01 37.83,41.78 v3(37.37,41.78) 37.37,43.18 37.31,43.24 PR4422.2 ; v3(143.04,65.91) 143.21,65.91 143.8,66.5 143.8,73.22 144.81,74.24 v2(144.81,78.44) v3(144.81,81.53) ; 90.05,58.76 89.2,58.76 88.73,58.29 88.73,56.65 R80211.2 R80224.1 ; 90.05,58.76 90.05,59.94 90.63,60.53 90.63,62.74 ; 90.05,58.76 90.55,58.76 90.58,58.74 R80225.1 R80226.1 ; R1760.1 v3(27.85,25.25) ; PR4427.1 49.44,43.43 48.8,42.8 v3(47.4,42.8) ; v3(123.48,49.66) v3(123.48,52.07) 123.52,52.07 126.14,54.69 126.14,56.2 R79944.1 128.11,58.48 127.77,58.83 127.77,61.06 128.56,61.85 v2(128.56,62.69) 128.56,63.88 v3(129.7,65.02) 129.89,64.83 C194.1
  BOTTOM w0.762: v3(125.13,30.48) 125.13,32.03 v2(124.47,32.69) 120.68,36.47 120.68,40.65 119.16,42.17 119.16,43.56 116.87,45.85 116.87,48.26 118.4,49.78 118.4,53.21 v3(119.54,54.36) 117.13,56.77 114.64,56.77 113.27,58.14 113.27,59.36 v3(112.17,60.45) ; Q9649.S 88.83,62.74 R80230.1 92.36,62.74 94.27,64.64 v5(95.28,64.64)
  vias: v2(144.23,11.07) v5(134.53,9.27) v5(134.78,10.29)
V_3P3_LAN: length 91.4
  TOP w0.203: 34.81,13.49 35.18,13.86 U16.23 ; U16.11 v3(38.48,17.91) ; v3(39.34,11.28) 39.28,11.34 U16.32
  TOP w0.508: C209.1 47.79,17.14 v1(48.37,16.56) 47.68,15.88 C1803.1 C1804.1 v4(47.94,14.61) ; v3(71.41,29.34) 72.17,30.1 C1802.1 73.76,30.16 C1806.1 75.15,30.16 75.6,29.72 75.6,29.08 75.85,28.83 U12.5 ; U10.5 v3(47.53,11.94) ; R79618.2 v3(84.49,26.73) ; R1819.1 C572.1 40.19,11.38 v3(40.11,11.3) 39.36,11.3 v3(39.34,11.28) ; 34.81,13.49 34.48,13.49 33.31,12.32 C1807.1 34.12,12.19 v3(34.3,12.37)
  L3 w0.508: v3(68.74,23.88) 68.74,25.43 70.26,26.95 70.26,28.19 v3(71.41,29.34) 74.48,26.26 83.7,26.26 84.17,26.73 v3(84.49,26.73) ; v3(47.53,11.94) 46.39,11.94 44.33,9.88 41.54,9.88 v3(40.11,11.3)
  L4 w0.508: v3(68.74,23.88) 64.04,23.88 57.69,17.53 49.82,17.53 47.94,15.65 v4(47.94,14.61) 47.53,14.2 v3(47.53,11.94)
  BOTTOM w0.508: v3(34.3,12.37) 34.17,12.49 v2(33.48,12.49) 32.39,11.4 32.39,9.4 31.96,8.97 31.96,8.92 31.72,8.68 R1816.1 ; C3454.1 C587.1 C84.1 38.42,17.97 v3(38.48,17.91) ; U11.5 v3(47.53,11.94)
V_3P3_PCIVAUX: length 39.1
  TOP w0.381: Q1229.G 144.72,222.92 R1932.1 142.59,223.14 v1(140.11,223.14) v5(125.38,223.14)
  BOTTOM w1.016: v5(125.38,223.14) 125.38,207.77 v5(126.14,207.01)
  vias: v1(120.84,222.78) v1(126.27,205.36) v5(145.83,199.26) v5(146.97,199.26) v5(148.12,199.26)
V_5_CODEC: length 4.9
  TOP w0.203: U6.39 163.99,80.2 C147.2
  TOP w0.508: v1(163.56,86.31) 163.61,86.26 164.75,86.26 L19.1 ; C146.1 164.82,82.18 C147.2
V_5_LCD1: length 1.7
  BOTTOM w0.508: v2(37.73,113.18) 37.75,113.21 L1.1
V_5_LCD2: length 3.6
  TOP w0.508: R8.2 43.85,117.35 42.55,117.35 41.94,116.74 41.94,116.54 v3(41.69,116.28)
  vias: v2(40.39,116.64)
V_5HDD: length 8.5
  TOP w0.508: 12,198.93 SATAP1.1 ; SATAP1.1 13.07,200 ; SATAP1.1 10.93,200 ; SATAP1.1 12,201.07 ; 12,193.93 SATAP1.3 ; SATAP1.3 13.07,195 ; SATAP1.3 12,196.07 ; SATAP1.3 10.93,195
V_5P0_A: length 395.2
  TOP w0.203: U52.4 129.83,7.37
  TOP w0.254: PG4532.1 144.56,5.08
  TOP w0.381: v3(72.55,124.13) 72.78,124.36 78.98,124.36 80.02,125.4 80.02,125.7 81.57,127.25 PC5224.1 83.85,127.38 85.25,127.38 85.63,127 85.63,125.22 85.89,124.97 PU5302.6
  TOP w0.508: PC4511.1 145,13.14 ; v3(156.88,83.69) 157.05,83.69 157.54,84.18 157.54,86.94 158.99,88.39 160.43,88.39 161.32,89.28 162.85,89.28 163.61,88.52 ; v3(20.23,158.62) 19.97,158.37 R80233.2 ; R80233.2 R80235.2 ; R80233.2 18.51,157.8 v3(18.19,157.48)
  L3 w0.508: v3(72.55,124.13) 70.21,126.47 54.36,126.47 46.46,118.56 46.46,115.3 46.98,114.78 46.98,110.53 45.55,109.09 ; 45.55,109.09 45.98,108.66 45.98,90.83 46.38,90.43 46.38,88.01 51.46,82.93 67.81,82.93 70.35,80.39 73.69,80.39 76.49,77.6 81.67,77.6 86.29,72.97 99.22,72.97 102.75,69.44 107.78,69.44 108.08,69.75 110.19,69.75 110.88,69.06 v3(117.43,69.06) ; 45.55,109.09 v3(44.91,109.09)
  L3 w0.635: v5(133,6.35) 130.08,9.27 124.63,9.27 121.95,11.95 121.95,18.16 v3(120.05,20.07)
  L4 w0.508: v3(18.19,157.48) 18.51,157.16 18.51,145.14 20.63,143.03 20.96,143.03 21.75,142.24 21.75,140.84 24.42,138.18 30.13,138.18 34.07,134.24 34.07,127.05 36.58,124.53 36.58,124.19 37.07,123.7 40.67,123.7 44.2,120.17 44.2,109.8 v3(44.91,109.09) ; v3(156.88,83.69) 156.6,83.69 156.24,84.05 142.5,84.05 141,82.55 141,78.36 v3(137.19,74.55)
  L4 w0.635: v3(120.05,20.07) 119.65,20.46 119.65,27.42 121.34,29.11 v3(121.34,29.84)
  BOTTOM w0.203: U54.4 v3(145.07,8.51)
  BOTTOM w0.305: PC5202.1 26.27,151.5 26.27,150.16 25.71,149.6 PU5201.7
  BOTTOM w0.508: PC5202.1 25.75,154.37 21.5,158.62 v3(20.23,158.62) ; v3(137.19,74.55) v2(135.01,74.55) 123.48,74.55 120.91,71.98 120.36,71.98 117.51,69.14 117.51,69.14 v3(117.43,69.06) 117.43,69.06 110.45,62.07 109.66,61.29 108.44,61.29 107.22,60.07
  BOTTOM w0.635: v3(121.34,29.84) 121.34,30.11 120.88,30.57 119.73,30.57 v2(119.67,30.63) 119.65,30.62 117.63,30.62 117.11,31.14 115.5,31.14 113.24,33.4 113.24,40.06 103.9,49.4 103.9,56.75 107.22,60.07
  vias: v2(133.18,3.89) v5(133,5.33) v5(134.02,6.35) v5(134.02,5.33) v5(135.16,6.35) v5(135.16,5.33) v5(145.07,7.49)
V_5P0_HDMI_CONN: length 2.2
  TOP w0.305: HDMI1.18 115.69,41.32 v5(115.35,41.66)
  vias: v2(117.18,41.38)
V_5P0_HDMI_CONN_L: length 3.7
  BOTTOM w1.016: L25.2 F7.2 119.21,35.86 v2(119.44,35.64)
V_19_INV: length 6.3
  TOP w0.508: 43.47,31.62 v1(43.47,29.13) 43.47,28.57 42.64,27.75 R5.1
V_SM_VREF_CNT: length 128.5
  TOP w0.089: CPU1.AY67 93.29,182.63 93.69,182.63 93.81,182.66 94.17,182.66 94.23,182.64 94.47,182.64 94.65,182.82 94.65,182.92 95.12,183.39 95.33,183.39 95.44,183.5
  TOP w0.127: 95.44,183.5 95.64,183.7 95.64,184.75 95.97,185.08
  TOP w0.508: v3(153.07,191.64) 152.37,190.94 149.71,190.94 148.97,191.67 144.46,191.67 143.73,190.94 134.74,190.94 131.67,194.01 127.82,194.01 126.88,194.94 104.33,194.94 103.52,194.14 100.32,194.14 v3(99.86,193.68) ; v4(96.11,187.18) 96.11,185.22 95.97,185.08
  L3 w0.508: v3(153.07,191.64) 153.77,190.94 153.77,187.63 155.61,185.8 155.61,151 v3(156.37,150.24)
  BOTTOM w0.508: v4(96.11,187.18) 97.16,187.18 98.14,188.16 98.15,188.16 v2(98.56,188.57) 99.86,189.87 v3(99.86,193.68) ; R1220.2 C1257.1 146.38,148.48 150.38,148.48 150.67,148.2 153.35,148.2 155.05,149.9 v2(155.05,149.96) 155.11,149.96 155.39,150.24 v3(156.37,150.24)
VGA_CORE: length 84.4
  TOP w0.254: PR28.1 123.31,103.91 120.12,103.91 v3(119.9,104.14)
  TOP w0.305: GPU1.AA12 86.4,96.57 v4(86.86,96.12)
  TOP w0.508: PT4.1 107.13,86.23 ; PT4.1 106.08,87.29 ; PT4.1 106.08,85.18 ; PT4.1 105.02,86.23 ; PT3.1 113.95,95.42 ; PT3.1 115.01,94.36 ; PT3.1 113.95,93.31 ; PT3.1 112.9,94.36 ; PT1.1 106.08,95.42 ; PT1.1 107.13,94.36 ; PT1.1 106.08,93.31 ; PT1.1 105.02,94.36
  L3 w0.254: v3(119.9,104.14) 119.51,103.76 117.86,103.76 115.32,101.22 103.57,101.22 100.78,104.01 98.23,104.01 92.46,109.78 88.19,109.78 86.91,108.5 85.79,108.5 v4(85.25,109.04)
  L3 w0.508: 113.95,93.31 PT3.1 ; PT3.1 112.9,94.36 ; PT3.1 115.01,94.36 ; PT3.1 113.95,95.42 ; 105.02,94.36 PT1.1 ; PT1.1 106.08,95.42 ; PT1.1 107.13,94.36 ; PT1.1 106.08,93.31 ; PT4.1 106.08,87.29 ; PT4.1 105.02,86.23 ; PT4.1 106.08,85.18 ; PT4.1 107.13,86.23
  L4 w0.508: PT1.1 106.08,95.42 ; PT1.1 106.08,93.31 ; PT1.1 105.02,94.36 ; PT1.1 107.13,94.36 ; 105.02,86.23 PT4.1 ; PT4.1 107.13,86.23 ; PT4.1 106.08,85.18 ; PT4.1 106.08,87.29 ; PT3.1 115.01,94.36 ; PT3.1 113.95,93.31 ; PT3.1 113.95,95.42 ; PT3.1 112.9,94.36
  BOTTOM w0.254: PC12179.1 84.88,109.41 v4(85.25,109.04)
  BOTTOM w0.508: v5(113.83,88.65) v2(113.83,87.58)
  vias: v2(80.68,108.66) v3(81.44,108.84) v3(82.18,108.81) v4(80.07,102.7) v4(80.07,99.98) v4(80.09,95.96) v4(82.11,102.68) v4(82.07,100.83) v4(82.07,99.98) v4(82.12,99.12) v4(82.33,97.11) v4(83.13,96.11) v4(83.93,101.83) v4(83.93,100.87) v4(83.92,99.12) v4(84.08,102.86) v4(84.73,101.88) v4(84.88,98.14) v4(85.6,93.6) v4(85.84,98.04) v4(85.94,100.76) v4(85.91,99.19) v4(89.4,92.8) v4(89.4,91.2) v4(90.2,92.8) v4(90.2,92) v4(90.2,91.2) v5(80.09,101.91) v5(80.09,100.94) v5(80.07,99.04) v5(84.89,102.85) v5(105.82,92.84) v5(105.82,91.82) v5(106.84,92.84) v5(106.84,91.82) v5(107.73,83.57) v5(107.86,92.84) v5(107.86,91.82) v5(107.86,89.66) v5(107.86,88.65) v5(107.86,86.87) v5(107.86,85.85) v5(108.75,83.57) v5(108.87,89.66) v5(108.87,88.65) v5(108.87,86.87) v5(108.87,85.85) v5(109.38,95.12) v5(109.38,94.11) v5(109.38,93.09) v5(109.76,83.57) v5(109.89,89.66) v5(109.89,88.65) v5(109.89,86.87) v5(109.89,85.85) v5(110.4,95.12) v5(110.4,94.11) v5(110.9,83.57) v5(111.79,89.66) v5(111.79,88.65) v5(111.92,83.57) v5(112.05,95.12) v5(112.05,94.11) v5(112.81,89.66) v5(112.81,88.65) v5(112.94,92.84) v5(112.94,83.57) v5(113.83,89.66) v5(113.95,92.84) v5(114.97,92.84)
VIDALERT#_CPU: length 4.8
  TOP w0.089: CPU1.B63 72.1,180.19 71.87,180.19 71.81,180.16 70.96,180.16
  TOP w0.102: 70.96,180.16 69.94,181.19 v1(69.43,181.19) R80030.1
VIDALERT#_CPU_R: length 82.3
  TOP w0.102: v3(66.58,183.26) 66.77,183.07 R80029.2 R80030.2 ; PR4609.2 25.69,189.74 v3(25.18,189.23)
  L4 w0.127: v3(25.18,189.23) 23.15,187.2 20.31,187.2 18.96,185.84 18.96,180.87 19.68,180.15 19.68,177.97 26.2,171.45 47.19,171.45 52.44,176.7 55.23,176.7 56.82,178.29 58.38,178.29 59.37,178.29 63.15,182.07 63.15,184.21 63.67,184.72 65.12,184.72 v3(66.58,183.26)
  BOTTOM w0.102: v3(25.18,189.23) 24.19,190.22 v2(24.19,190.73) 24.19,192 22.64,193.55 PR4660.1
VIDSCK_CPU: length 8.9
  TOP w0.102: CPU1.A63 71.05,180.42 68.92,182.56 68.92,183.33 68.53,183.72 66.38,183.72 66.01,184.09 R80032.2 v1(65.69,183.13)
VIDSCK_CPU_R: length 82.7
  TOP w0.102: v3(24.42,189.23) 24.67,189.48 PR4618.2 ; v3(66.58,184.98) R80032.1 R80028.2
  L4 w0.127: v3(24.42,189.23) 24.89,189.7 24.93,189.7 24.97,189.74 25.39,189.74 25.69,189.44 25.69,189.02 23.27,186.61 20.52,186.61 19.46,185.55 19.46,181.15 20.19,180.42 20.19,180.36 20.19,178.18 26.41,171.96 46.98,171.96 52.23,177.21 55.02,177.21 56.61,178.8 59.16,178.8 62.64,182.28 62.64,184.42 63.46,185.23 66.33,185.23 v3(66.58,184.98)
  BOTTOM w0.102: v3(24.42,189.23) 23.4,190.25 23.4,192.02 v2(22.39,193.03) 21.62,193.8 PR4662.1
VIDSOUT_CPU: length 9.2
  TOP w0.089: CPU1.D64 73.07,180.99 72.78,180.7 71.05,180.7 69.85,181.9
  TOP w0.102: v1(67.93,186) 68.44,185.5 R80031.2 68.8,185.1 69.35,184.56 69.35,182.4 69.85,181.9
VIDSOUT_CPU_R: length 84.4
  TOP w0.102: v3(66.58,184.21) R80027.2 R80031.1 ; PR4616.2 23.66,193.55 v3(23.91,193.8)
  L4 w0.127: v3(23.91,193.8) 23.53,193.42 23.53,188.34 22.96,187.77 20.16,187.77 18.45,186.06 18.45,180.66 19.17,179.94 19.17,177.76 25.99,170.94 47.4,170.94 52.65,176.19 55.44,176.19 56.93,177.67 59.48,177.67 63.66,181.86 63.66,183.57 64.2,184.11 64.7,184.11 66.02,182.79 66.78,182.79 67.05,183.07 67.05,183.74 v3(66.58,184.21)
  BOTTOM w0.102: PR4668.1 23.66,194.06 v3(23.91,193.8) 24.3,193.41 v2(24.3,192.99)
VOUT_INV: length 13.4
  L3 w0.508: v3(35.72,29.72) 35.72,30.23 35.47,30.48 33.18,30.48 32.42,31.24 32.42,37.21 31.91,37.72 v5(31.02,37.72)
  BOTTOM w0.305: U120.18 36.23,29.21 v3(35.72,29.72)
  vias: v1(30.51,39.12) v5(29.98,37.76)
VR_EN: length 9.4
  TOP w0.102: R80144.1 21.23,188.72 22.2,188.72 v3(22.73,189.25)
  BOTTOM w0.102: PR4666.2 20.61,193.37 21.62,192.35 v2(21.62,190.45) 22.73,189.35 v3(22.73,189.25)
VR_EN_C_1: length 4.9
  TOP w0.152: R8511.2 19.6,186.61 v1(19.01,186.61) 18.63,186.61 17.72,185.71 Q9636.G 17.42,184.23 Q9637.6
VR_EN_C_2: length 4.6
  TOP w0.152: R80140.2 13.69,181.67 v1(13.88,181.86) 13.88,182.75 14.21,183.08 14.77,183.08 15.07,183.39 Q9637.2
VR_RDY: length 9.4
  TOP w0.102: R80146.1 23.27,188.92 23.27,189.35 22.92,189.7 22.42,189.7 v3(21.96,189.25)
  BOTTOM w0.102: v3(21.96,189.25) 21.96,189.4 21.42,189.94 21.41,189.94 20.85,190.5 v2(20.85,191.91) 20.85,192.04 20.04,192.85 PR4615.2 PR4665.2
VR_TT#: length 3.1
  TOP w0.203: U9.4 130.68,103.51 131.44,104.27 131.61,104.27 132.37,105.03 TP204.1
VRAM1_VREFCA: length 6.7
  BOTTOM w0.178: R885.1 49.75,109.47 v2(50.14,109.47) 52.11,109.47 52.26,109.31 52.78,109.31 MEM3.M8
  BOTTOM w0.508: R886.2 C529.1 R885.1
VRAM1_VREFDQ: length 10.9
  BOTTOM w0.178: 59.92,110.97 58.81,112.07 MEM3.H1
  BOTTOM w0.508: C559.1 R924.2 R928.1 v2(62.39,105.99) 61.96,106.43 61.53,106.43 60.9,107.05 60.9,108.92 59.99,109.84 59.99,110.9 59.92,110.97
VRAM2_VREFCA: length 18.8
  TOP w0.178: v4(60.11,108.86) 59.68,108.42 59.29,108.42 59.26,108.45 58.72,108.45 58.29,108.88 MEM1.M8
  TOP w0.508: v3(50.51,108.74) 50.47,108.78 R230.1 C163.1 R1905.2
  L3 w0.178: v4(60.11,108.86) 60.09,108.86 59.66,108.42 59.66,108.42 59.42,108.18 58.09,108.18 55.66,110.62 55.25,110.62 54.98,110.88 54.23,110.88 53.96,110.62 53.25,110.62 51.97,109.35 51.12,109.35 v3(50.51,108.74)
  BOTTOM w0.254: v3(50.51,108.74) 50.17,108.4 v2(50.17,107.95)
VRAM2_VREFDQ: length 7.5
  TOP w0.178: MEM1.H1 52.16,111.83 51.62,111.83 50.73,112.72
  TOP w0.508: 50.73,112.72 50.45,113 v1(50.45,113.57) 49.09,113.57 R203.1 R202.2 C1854.1 C835.1
VRAM3_VREFCA: length 14.9
  L3 w0.178: v3(50.69,94.08) 50.7,94.08 53.65,94.08 53.95,94.39 55.25,94.39 55.5,94.63 56.38,94.63 56.59,94.85 58.84,94.85 59.16,94.53 v4(59.41,94.53)
  BOTTOM w0.178: v4(59.41,94.53) 59.33,94.53 59.05,94.81 58.69,94.81 58.29,94.42 MEM4.M8
  BOTTOM w0.508: R1924.1 48.76,93.7 R1923.2 C1869.1 49.67,94.76 v2(49.97,94.47) 50.35,94.08 v3(50.69,94.08)
VRAM3_VREFDQ: length 8.2
  BOTTOM w0.178: MEM4.H1 52.41,91.43 51.91,91.94 51.35,91.94 50.79,91.39 50.4,91.39 50.16,91.63 R1922.1
  BOTTOM w0.508: v2(46.16,92.91) 46.39,92.68 C1868.1 C1867.1 R1921.2 R1922.1
VRAM4_VREFCA: length 7.1
  TOP w0.178: 50.39,95.69 51.13,95.69 51.78,95.04 52.02,95.04 52.23,94.84 52.8,94.84 MEM2.M8
  TOP w0.381: C1861.1 49.18,95.69 R80087.1
  TOP w0.508: C1861.1 48.74,97.16 R80088.2 ; 50.39,95.69 v1(50.3,95.69) R80087.1
VRAM4_VREFDQ: length 19.2
  TOP w0.203: v4(59.58,95.15) 59.9,94.83 59.9,91.62 59.5,91.22 MEM2.H1
  L3 w0.178: v4(51.02,95.12) 53.49,95.12 54.88,96.5 55.52,96.5 55.54,96.53 56.53,96.53 57.7,95.36 59.37,95.36 v4(59.58,95.15)
  BOTTOM w0.508: v4(51.02,95.12) 50.18,95.96 v2(50.12,95.96) 49.99,95.82 R945.1 48.86,95.76 C1860.1 R946.2
VRAM_ZQ1: length 6.1
  BOTTOM w0.102: MEM3.L8 53.18,109.68 52.85,110.01 52.16,110.01 52,109.85 51.51,109.85 51.3,110.06 48.98,110.06 v2(48.88,109.96) 48.85,109.98 48.85,110.99 R870.2
VRAM_ZQ2: length 16.9
  TOP w0.102: v4(60.29,106.77) 60.29,108.46 60.52,108.69 60.52,109.02 60.22,109.32 58.38,109.32 MEM1.L8
  L3 w0.127: v3(50.85,106.88) 51.2,107.23 51.96,107.23 51.98,107.21 52.06,107.21 52.3,106.96 52.3,106.95 52.43,106.82 55.28,106.82 55.32,106.86 60.2,106.86 v4(60.29,106.77)
  BOTTOM w0.102: v3(50.85,106.88) 50.5,106.53 v2(50.07,106.53) 49.82,106.78 R899.2
VRAM_ZQ3: length 18.3
  TOP w0.102: v3(50.2,97.89) 49.41,98.68 R299.2
  L3 w0.127: v3(60.41,95.5) 59.7,96.21 59.29,96.21 59.05,95.97 57.86,95.97 56.38,97.45 55.86,97.45 55.83,97.42 50.67,97.42 v3(50.2,97.89)
  BOTTOM w0.102: MEM4.L8 58.34,93.95 58.95,93.95 59.01,93.89 60.22,93.89 60.41,94.09 v3(60.41,95.5) 60.93,95.5 v2(61.31,95.12)
VRAM_ZQ4: length 5.8
  TOP w0.102: R320.2 49.35,94.51 v1(49.35,94.51) 50.12,94.51 50.15,94.54 51.02,94.54 51.51,94.05 52.78,94.05 MEM2.L8
VREF: length 5.3
  TOP w0.102: C4.2 40.83,28.98 v3(40.83,29.21)
  BOTTOM w0.102: U120.2 39.38,26.92 v2(39.78,27.31) 40.83,28.36 v3(40.83,29.21)
VREF_1: length 2.9
  TOP w0.203: v1(163.3,81.15) 163.19,81.04 U6.41
  TOP w0.508: v1(163.3,81.15) 163.23,81.23 C140.1
VREG_PCIAUX_PCH: length 12.4
  BOTTOM w0.254: Q3.D Q128.C 149.23,209.17 149.18,209.12 147.3,209.12 146.4,208.22 R10.2 v2(144.91,207.14) 144.18,207.14 143.67,206.63 R13.1
VREG_PCIAUX_PCH_1: length 5.4
  BOTTOM w0.254: R13.2 C1616.1 145.83,204.28 PC1.2 146.02,203.37 Q1211.G v2(144,202.79)
VRP: length 5.3
  TOP w0.203: U6.38 164.39,80.01 164.75,80.37
  TOP w0.254: 164.75,80.37 164.8,80.42 167.1,80.42 v1(167.36,80.67) 168.09,81.41 C155.1
VSUM_RC: length 2.8
  TOP w0.254: PC14.2 124.51,101.73 124.63,101.6 124.82,101.6 124.98,101.45 v3(125.03,101.45) 124.35,100.77 PR34.2
  BOTTOM w0.254: v2(124.21,101.45) v3(125.03,101.45)
VSUM_RR: length 8.1
  TOP w0.254: PR51.1 118.21,95.82 v3(119.29,96.9) 119.73,97.35 PR42.2
  BOTTOM w0.254: v2(120.18,96.9) v3(119.29,96.9)
VTT_EN: length 23.4
  TOP w0.102: R80162.2 R507.2 81.25,208.85 79.15,210.95 v3(78.39,210.95) v1(79.68,212.23) 80.49,213.04 80.49,219.27 81.2,219.98 U501.4
  BOTTOM w0.102: PU5104.7 82.06,211.18 81.44,210.57 C1797.1 81.06,210.69 R1810.1 80.17,211.9 R80118.2 79.98,211.52 79.66,211.2 78.65,211.2 v3(78.39,210.95)
WAKE_N: length 428.7
  TOP w0.102: R1718.1 R1719.2 147.28,222 155.11,214.17 v3(156.32,214.17) ; v3(33.46,14.91) 33.65,14.72 35.34,14.72 35.4,14.66 U16.21 ; v3(108.62,118.75) 108.62,119 107.32,120.3 107.32,125.1 110.07,127.84 110.07,133.93 109.76,134.24 109.76,146.42 103.23,152.95 102.5,152.95 R80037.2 101.7,152.15 R80048.2
  L3 w0.127: v3(33.46,14.91) 30.47,17.9 30.47,22.31 29.37,23.4 29.37,25.28 27.12,27.53 27.12,38.76 30.77,42.41 30.77,42.76 30.96,42.96 30.96,128.14 35.24,132.42 36.77,132.42 37.84,131.36 39.95,131.36 v3(40.42,131.83)
  L4 w0.127: v3(40.42,131.83) 41.69,130.56 42.83,130.56 45.71,127.67 63.73,127.67 65.75,129.69 72.24,129.69 83.66,118.28 108.15,118.28 v3(108.62,118.75)
  BOTTOM w0.102: v3(156.32,214.17) v2(158.89,211.6) 159.67,210.82 159.67,195.71 160.48,194.9 160.48,183.95 160.59,183.85 160.59,151.37 158.41,149.2 158.41,145.46 156.57,143.62 156.57,124.07 155.14,122.63 121.65,122.63 118.57,119.56 109.43,119.56 v3(108.62,118.75)
WEA0#: length 43
  TOP w0.127: v1(61.75,106.2) 61.75,107.01 v4(61.78,107.04) ; MEM1.L3 54.01,109.85 54.13,109.97 55.18,109.97 v4(55.37,110.16) ; v4(75.01,106.43) 75.01,106.67 75.14,106.8 GPU1.G25
  L3 w0.165: v4(61.78,107.04) 61.93,107.19 63.21,107.19 63.59,107.58 63.59,107.94 63.72,108.07 64.1,108.07 64.27,107.9 64.27,107.36 64.43,107.19 64.92,107.19 65.08,107.36 65.08,107.9 65.25,108.07 65.73,108.07 65.89,107.9 65.89,107.36 66.06,107.19 66.54,107.19 66.71,107.36 66.71,107.9 66.87,108.07 68.39,108.07 68.88,107.58 69.24,107.22 69.66,107.22 69.83,107.04 73.11,107.04 73.23,106.91 73.23,106.79 73.36,106.67 74.78,106.67 v4(75.01,106.43)
  L4 w0.165: v4(61.78,107.04) 61.78,102.36 61.91,102.23 62.22,102.23 62.35,102.36 62.35,108 60.73,109.62 59.01,109.62 58.85,109.46 58.85,108.78 58.72,108.66 58.07,108.66 57.92,108.8 57.92,109.25 57.8,109.37 57.42,109.37 56.53,110.25 55.77,110.25 55.67,110.16 v4(55.37,110.16)
  BOTTOM w0.127: v4(55.37,110.16) 55.45,110.24 56.66,110.24 MEM3.L3
WEA1#: length 40.6
  TOP w0.127: v4(54.58,93.69) 55.05,93.22 55.59,93.22 55.99,93.62 MEM2.L3 ; GPU1.H10 76.2,94.57 76.33,94.45 v4(76.6,94.45)
  L3 w0.165: v4(76.6,94.45) 76.44,94.28 74.47,94.28 74.15,93.96 73.67,93.96 73.54,94.09 73.54,94.67 73.41,94.8 72.98,94.8 72.85,94.67 72.85,94.54 72.7,94.39 71.01,94.39 70.51,94.89 66.91,94.89 66.74,95.06 61.17,95.06 60.87,95.36 60.87,96.18 60.61,96.45 59.81,96.45 59.8,96.46 58.98,96.46 58.86,96.58 58.86,97 58.98,97.13 v4(59.87,97.13)
  L4 w0.102: v4(54.58,93.69) 54.63,93.69 55.27,94.32 57.44,94.32 57.57,94.46 57.57,94.68 57.67,94.79 58.08,94.79 58.18,94.68 58.18,94.48 58.28,94.38 58.58,94.38
  L4 w0.165: v4(59.87,97.13) 59.87,97.57 59.75,97.7 59.35,97.7 59.22,97.57 59.22,96.52 58.59,95.89 57.74,95.89 57.64,95.79 57.64,95.28 57.74,95.18 58.59,95.18 58.7,95.07 58.7,94.51 58.58,94.38
  BOTTOM w0.127: v2(61.03,97) 60,97 v4(59.87,97.13) ; MEM4.L3 53.81,93.82 53.66,93.82 53.56,93.72 53.56,93.48 53.56,93.47 53.56,93.27 53.66,93.17 54.48,93.17 54.58,93.27 v4(54.58,93.69)
WEBCAM_DET: length 170.3
  TOP w0.102: v1(157.01,195.83) 157,195.84 WEBCM1.7 157,199.51 v3(157.13,199.64) ; v3(146.59,58.01) 146.57,58.01 145.92,57.37 U109.114 ; v3(164.12,178.44) 163.36,179.2 v3(158.4,179.2)
  BOTTOM w0.102: v3(158.4,179.2) 159.62,180.42 159.62,183.45 159.29,183.78 159.29,189.87 157.2,191.96 PC126.2 157.2,199.58 v3(157.13,199.64) 157.2,199.71 R12.2 ; v3(164.12,178.44) 164.7,177.85 164.7,150.96 162.03,148.29 162.03,121.37 160.43,119.76 158.28,119.76 157.03,118.52 151.04,118.52 147.02,114.5 147.02,103.2 148.6,101.63 148.6,97.28 146.44,95.12 146.44,89.5 147.4,88.54 147.4,58.83 v3(146.59,58.01)
WP#_1: length 5.5
  TOP w0.102: U9501.3 77.12,64.31 76.55,64.88 R9509.2 77.35,65.02 v1(77.5,65.18) 77.5,65.43 77.27,65.66 76.94,65.66 76.55,66.05 R9507.2 R9508.1
WP_PRO: length 10.6
  TOP w0.102: SCA1.40 67.12,74.08 v3(66.58,73.53)
  BOTTOM w0.102: v3(66.58,73.53) 64.8,71.75 62.11,71.75 61.92,71.57 v2(61.91,71.57) 61.05,71.57 60.86,71.75 60.23,71.75 59.83,72.15 RN9503.1
XCLK_BIASREF: length 2.5
  TOP w0.203: v4(74.79,167.92) 74.79,167.99 CPU1.E42
  BOTTOM w0.203: R80063.1 75.74,167.86 v2(75.58,168.02) 74.89,168.02 v4(74.79,167.92)
XDP_DBRESET#: length 174.2
  TOP w0.102: v3(33.43,225.43) 33.43,225.11 R9925.1 ; CPU1.B5 72.34,146.52 71.81,145.99 71.58,145.99 70.9,145.31 70.9,142.11 70.89,142.11 R80046.2 68.98,140.21 68.36,140.21 67.99,139.84 67.99,139.29 67.61,138.91 59.08,138.91 54.89,134.72 45.91,134.72 v3(45.8,134.62)
  L3 w0.127: v3(33.43,225.43) 32.96,224.96 28.26,224.96 27.57,224.27 16.91,224.27 11.97,219.33 11.97,202.55 14.11,200.41 14.11,188.6 11.63,186.12 11.63,154.27 16.04,149.86 16.04,142.71 23.72,135.03 38.74,135.03 41.14,132.63 43.81,132.63 v3(45.8,134.62)
XDP_DBRESET_XDP#: length 6.1
  TOP w0.102: XDP1.48 31.33,222.08 31.2,222.21 31.2,223.48 C9905.1 31.04,223.83 31.9,223.83 31.91,223.82 v1(31.94,223.82) 31.94,223.83 32.81,223.83 R9927.2 R9925.2
XDP_PRDY#: length 116.1
  TOP w0.089: 70.51,175 71.24,175.73 72.76,175.73 73.01,175.98 73.01,176.14 73.47,176.59 CPU1.D56
  TOP w0.102: 70.51,175 69.88,174.37 68.37,174.37 67.35,173.35 65.93,173.35 65.22,172.64 63.37,172.64 62.57,173.45 62.57,178.1 63.15,178.69 63.15,182.37 64.4,183.62 v3(64.4,183.64) ; v3(20.23,216.92) 20.83,216.31 XDP1.5 20.83,212.78 TP9901.1
  L3 w0.127: v3(67.66,218.16) 67,218.82 57.82,218.82 57.09,219.54 26.56,219.54 23.87,216.85 23.87,216.69 23.37,216.19 20.95,216.19 v3(20.23,216.92)
  BOTTOM w0.102: v3(64.4,183.64) 64.4,184.71 v2(64.42,184.73) 64.7,185.01 64.7,190.27 65.59,191.16 65.59,191.45 68.84,194.69 68.84,215.69 68.13,216.39 68.13,217.69 v3(67.66,218.16)
XDP_PREQ#: length 116.1
  TOP w0.102: CPU1.D61 74.08,179.07 74.26,178.89 v4(74.73,178.89) ; R9934.2 15.53,219.07 v3(16.67,217.93) 17.69,216.92 19.52,216.92 20.33,216.1 XDP1.3
  L3 w0.127: v3(16.67,217.93) 17.22,217.39 20.49,217.39 21.3,216.57 23.21,216.57 23.49,216.85 23.49,217.01 26.56,220.08 34.31,220.08 35.71,221.48 55.77,221.48 58.04,219.2 68.86,219.2 71.78,216.28 v3(72.17,216.28)
  BOTTOM w0.102: v3(72.17,216.28) 71.99,216.1 71.99,192.75 69.98,190.75 v2(69.98,185.19) 69.98,181 72.58,178.41 74.25,178.41 v4(74.73,178.89)
XDP_PRSENT_PIN60: length 9.3
  TOP w0.102: R9928.2 R9929.2 R9931.1 40.01,223.69 40.01,223.04 v1(39.3,222.33) 39.1,222.12 36.06,222.12 34.86,220.92 XDP1.60
XDP_PRSNT_PIN1: length 4.7
  TOP w0.102: R9902.2 18.71,211.66 v1(19.07,212.01) 19.83,212.78 XDP1.1
XDP_SMBCLK: length 25.1
  TOP w0.102: R9912.1 50.21,219.79 v1(47.33,219.79) 40,219.79 35.34,215.12 35.34,213.46 34.8,212.92 33.67,212.92 32.83,213.76 XDP1.53
XDP_SMBDAT: length 25.5
  TOP w0.102: R9911.1 50.79,219.23 v1(45.17,219.23) 39.95,219.23 35.72,215 35.72,213.34 34.95,212.57 33.52,212.57 32.33,213.76 XDP1.51
XDP_SYS_PWROK: length 20.8
  TOP w0.102: R9908.2 47.33,223.58 R9910.1 C9903.1 45.12,223.58 v1(43.86,222.33) 43.3,221.77 40.19,221.77 36.75,218.33 33.8,218.33 33.7,218.22 33.7,217.51 32.59,216.41 31.64,216.41 31.33,216.1 XDP1.47
XDP_TCK_JTAGX: length 75.4
  TOP w0.089: CPU1.A59 71.55,177.95 71.44,177.84 70.78,177.84 70.75,177.82 70.47,177.55 68.93,177.55 R80001.1
  TOP w0.102: v3(66.58,176.91) 66.58,177.03 67.1,177.55 67.66,177.55 R80001.1 ; v3(63.15,220.88) 62.82,221.21 62.82,224.06 62.19,224.69 51.76,224.69 51.67,224.6 R9915.1 R9922.2
  BOTTOM w0.102: v3(66.58,176.91) 65.9,177.6 65.9,188.94 66.73,189.78 66.73,190.97 69.98,194.22 69.98,218.11 68,220.09 68,220.99 67.2,221.79 v2(64.42,221.79) 64.07,221.79 v3(63.15,220.88)
XDP_TCLK: length 93.3
  TOP w0.089: R80003.1 68.99,179.96 69.76,179.2 71.35,179.2 71.42,179.27 71.46,179.28 71.47,179.29 71.59,179.33 71.79,179.33 71.92,179.27 72.14,179.27 CPU1.B61
  TOP w0.102: R80003.1 68.42,180.28 68.23,180.47 66.84,180.47 v3(66.58,180.72) ; v3(62.14,223.77) 61.45,224.46 52.73,224.46 R9921.1 51.85,223.71 R9915.2 48.2,221.34 40.36,221.34 34.66,215.64 34.66,213.61 34.56,213.51 34.07,213.51 33.83,213.74 XDP1.57
  BOTTOM w0.102: v3(66.58,180.72) v2(67.24,181.38) 67.57,181.71 67.57,190.62 70.82,193.88 70.82,218.95 69.98,219.79 69.98,220.28 67.51,222.76 63.15,222.76 v3(62.14,223.77)
XDP_TCLK1: length 24.8
  TOP w0.102: XDP1.55 33.33,213.78 33.84,213.28 34.66,213.28 34.96,213.58 34.96,215.24 40.11,220.4 49.69,220.4 v1(50.3,221.01) 50.3,221.02 R9914.2
XDP_TDI: length 102.6
  TOP w0.089: 71.6,176.93 72.8,176.93 73.48,177.61 73.78,177.61 73.97,177.81 73.97,178.08 73.55,178.51 CPU1.D60
  TOP w0.102: v3(64.55,176.02) 65.57,175.01 66.45,175.01 66.77,174.69 R80002.1 67.07,174.5 68.82,176.25 70.33,176.25 71.01,176.93 71.6,176.93 ; XDP1.56 33.33,222.08 33.88,222.63 36.93,222.63 R9916.2 37.76,223.71 37.5,223.98 37.5,225.17 v3(37.24,225.43)
  L4 w0.127: v3(37.24,225.43) 38.48,226.66 50.7,226.66 51.68,225.68 63.01,225.68 67.47,221.22 v3(67.47,220.88)
  BOTTOM w0.102: v3(67.47,220.88) 67.47,220.3 69.76,218.01 69.76,194.32 66.77,191.33 66.5,191.07 66.5,189.88 65.67,189.04 65.67,177.14 65.57,177.04 v2(65.57,177.01) 65.54,177.01 v3(64.55,176.02)
XDP_TDO: length 27.9
  TOP w0.102: XDP1.52 32.33,222.8 v3(32.42,222.88) 32.8,223.27 34.51,223.27 R9920.2 R9919.1 R9918.1 ; v3(49.44,225.43) 49.11,225.09 49.11,224.17 R9922.1
  L3 w0.127: v3(49.44,225.43) 47.91,223.9 33.89,223.9 33.54,223.56 33.09,223.56 v3(32.42,222.88)
  BOTTOM w0.102: v3(49.44,225.43) 49.11,225.09 v2(49.11,224.66)
XDP_TDO_CPU: length 88.9
  TOP w0.089: CPU1.A61 71.51,179.07 71.46,179.02 69.65,179.02
  TOP w0.102: R9919.2 35.72,224.85 v3(35.72,225.43) ; R80000.1 66.52,179.26 v3(66.58,179.2) 69.47,179.2 69.65,179.02
  L4 w0.127: v3(66.96,223.77) 63.32,227.42 37.71,227.42 v3(35.72,225.43)
  BOTTOM w0.102: v3(66.96,223.77) 67.24,223.77 v2(68.28,222.73) 70.31,220.7 70.31,219.79 71.05,219.05 71.05,193.78 67.8,190.53 67.8,180.42 v3(66.58,179.2)
XDP_TMS: length 92.3
  TOP w0.089: CPU1.C60 72.61,178.56 70.57,178.56 70.37,178.36
  TOP w0.102: R80005.1 v4(69.12,178.56) 69.53,178.16 70.16,178.16 70.37,178.36 ; v3(39.53,225.43) 39.53,224.03 39.21,223.71 R9917.2 39.02,223.27 38.13,222.38 34.13,222.38 33.83,222.08 XDP1.58
  L4 w0.127: v3(39.53,225.43) 40,225.89 50.36,225.89 51.34,224.92 62.39,224.92 v3(63.53,223.77)
  BOTTOM w0.102: v4(69.12,178.56) v2(68.34,179.34) 68.03,179.65 68.03,190.44 71.28,193.69 71.28,219.28 70.65,219.92 70.65,221.09 67.5,224.23 63.99,224.23 v3(63.53,223.77)
XDP_TRST#: length 100.2
  TOP w0.089: v4(69.76,178.56) 70.01,178.81 72.73,178.81 CPU1.C61 ; CPU1.B59 72.3,177.95 72.04,178.21 70.75,178.21 70.31,177.77 66.68,177.77 v3(66.58,177.67)
  TOP w0.102: v3(33.18,222.8) 32.83,222.46 XDP1.54
  L4 w0.127: v3(62.26,220.88) 60.38,222.76 49.08,222.76 48.82,223.01 48.8,223.01 48.48,223.33 33.71,223.33 v3(33.18,222.8)
  BOTTOM w0.102: v4(69.76,178.56) 70.33,177.99 R80004.1 70.07,177.55 v2(67.67,177.55) 66.71,177.55 v3(66.58,177.67) 66.12,178.13 66.12,180.15 66.13,180.15 66.13,180.53 66.12,180.53 66.12,188.85 66.96,189.69 66.96,190.88 70.21,194.13 70.21,218.2 68.23,220.18 68.23,221.09 67.02,222.3 63.69,222.3 v3(62.26,220.88)
XRF_TDC2: length 13.6
  TOP w0.508: 51.6,10.03 v3(50.3,10.03) ; C3452.1 v3(49.82,16.48) ; XF1.9 v3(50.3,13.84)
  L3 w0.508: v3(49.82,16.48) 49.82,14.33 v3(50.3,13.84)
  BOTTOM w0.508: v3(50.3,10.03) 51.6,10.03 XF1.9 v3(50.3,13.84) ; v3(49.82,16.48) 49.51,16.79 v2(49.03,16.79)
XTALIN: length 9.6
  TOP w0.102: X9505.1 101.63,109.06 100.86,109.83 99.37,109.83 R1879.1 98.16,109.26 C756.1 96.29,109.26 v3(96.22,109.2) GPU1.AM28
  BOTTOM w0.102: v2(97.04,109.2) v3(96.22,109.2)
XTALOUT: length 8.9
  TOP w0.102: GPU1.AK28 93.39,109.59 95.38,109.59 v3(96.25,110.46) 97.28,110.46 C757.1 97.4,110.47 R1879.2 99.43,110.47 100.11,111.15 X9505.3
  BOTTOM w0.102: v2(95.41,110.46) v3(96.25,110.46)
