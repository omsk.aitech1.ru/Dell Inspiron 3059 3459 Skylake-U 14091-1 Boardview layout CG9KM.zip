# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_AUD: length 8.2
  TOP w0.203: 163.99,81.84 163.99,80.97 163.59,80.57 U6.40
  TOP w0.508: 163.99,81.84 163.99,82.91 163.71,83.19 163.42,83.19 C145.2 163.29,84.52 C144.1 163.48,84.99 162.16,86.31 v1(162.06,86.31)
PVCC_3V3: length 83.9
  TOP w0.305: SCA1.84 55.15,64.9 v3(55.28,65.02) ; SCA1.49 62.62,74.7 63.03,74.3 v3(63.41,74.3)
  TOP w0.508: 75.66,68.26 R9544.1 R9507.1 ; 75.66,68.26 79.01,68.26 80.3,66.97 v3(80.3,66.8) ; 75.66,68.26 74.11,68.26 73.57,68.81 R79798.1 ; R79799.1 v3(74.96,74.17) 75.09,74.3 75.09,76.71 74.96,76.83 74.96,78.42 72.61,80.77 71.15,80.77 70.26,81.66 R80173.2 R79205.2 ; R79800.1 74.26,71.69 v3(74.46,71.5) ; v3(55.28,65.02) 55.45,65.02 55.94,64.54 55.94,58.45 v3(55.28,57.78)
  L3 w0.508: v3(74.96,74.17) 74.96,73.15 74.46,72.64 v3(74.46,71.5)
  BOTTOM w0.508: v3(55.28,65.02) 54.9,65.02 54.71,64.83 C12197.1 L9505.2 ; v5(78.14,56.77) 78.14,61.06 v2(79.05,61.98) 80.3,63.22 v3(80.3,66.8) 80.3,67.06 78.82,68.53 78.82,73.15 77.27,74.7 77.22,74.7 76.87,75.06 75.22,75.06 ; L9502.1 65.12,52.01 65.12,53.01 R9548.2 R9528.2 63.75,53.05 63.03,53.77 R9525.2 R9503.2 R79868.1 58.82,54.17 v2(58.81,54.15) 58.8,54.17 R9521.2 56.26,54.17 56.01,54.41 56.01,57.22 55.45,57.78 v3(55.28,57.78) 55.02,57.78 54.52,57.28 R79236.2
  BOTTOM w0.762: 56.8,68.45 55.53,68.45 v2(54.74,67.67) 54.14,67.06 L9505.2
  vias: v2(74.38,75.82)
PVCC_3V3_SDRAM: length 34.6
  TOP w0.305: C12184.2 55.98,52.13 56.62,52.78 SCA1.106 ; SCA1.62 56.12,74.38 v3(56.04,74.3)
  TOP w0.508: C12184.2 55.41,52.39 55.41,52.7 54.85,53.26 53.38,53.26 52.03,54.61 v3(51.98,54.61)
  BOTTOM w0.508: C12194.1 C9518.1 ; C9518.1 v3(56.04,74.3) ; C9518.1 55.47,75.37 C12244.1 54.26,74.17 L9503.2 v2(54.26,72.26) 54.26,70.36 51.98,68.07 v3(51.98,54.61)
V0.85A_VID0: length 3
  TOP w0.102: CPU1.AN11 88.6,150.87 v4(88.27,150.55)
  BOTTOM w0.102: v4(88.27,150.55) 88.25,150.55 87.82,150.11 87.18,150.11 86.75,149.68 TP2101.1
V0.85A_VID1: length 3.9
  TOP w0.102: CPU1.AN13 88.6,151.79 v4(88.27,151.46)
  BOTTOM w0.089: v4(88.27,151.46) 88.1,151.46 87.73,151.1 87.38,151.1 87.13,151.35 87.13,152.98 TP2102.1
VBAT1: length 5.8
  TOP w0.254: R79979.1 144.22,85.5 v3(144.81,85.5) BT1.1
  BOTTOM w0.254: v2(144.81,86.33) v3(144.81,85.5)
VBAT1_R: length 7.8
  TOP w0.254: D3.A 142.04,84.21 R79979.2 143.99,82.45 ; D2.2 143.99,82.45 ; 143.99,82.45 143.99,82.49 v3(144.76,83.26)
  BOTTOM w0.254: TP108.1 v3(144.76,83.26)
VBAT2: length 46.1
  TOP w0.254: R79929.2 123.6,47.18 v3(123.6,46.67) ; D3.K 140.52,81.28 v1(142.53,79.27) 142.53,78.61 v3(142.78,78.36)
  L3 w0.254: v3(123.6,46.67) 124.18,47.24 124.49,47.24 129.32,52.08 129.32,53.71 135.55,59.94 135.79,59.94 136.3,60.46 136.3,61.47 140.52,65.68 140.52,68.07 142.5,70.06 142.5,74.22 143.39,75.11 143.39,77.75 v3(142.78,78.36)
VBAT_SIO: length 9.6
  TOP w0.203: U109.66 131.01,48.24 130.81,48.03 130.74,48.03 130.72,48.01
  TOP w0.254: 130.72,48.01 128.61,48.01 127.27,49.34 v1(126.84,49.34) 126.82,49.34 126.02,48.54 124.33,48.54 C190.1 R79929.1
VCC: length 424.9
  TOP w0.254: R118.1 151.16,115.82 150.66,115.32 150.66,113.35 151.23,112.78 153.86,112.78 154.49,112.14 154.49,109.75 153.42,108.69 153.42,102.21 152.43,101.22 v3(152.43,100.58) ; v3(78.14,55.75) R9540.1
  TOP w0.381: D5205.A 123.99,29.02 R5217.1 ; v3(26.12,19.49) 26.14,19.47 27.97,19.47 28.18,19.27 36.11,19.27 36.95,20.1 41.05,20.1 41.12,20.17 45.94,20.17 47.11,21.34 47.11,30.57 v3(47.15,30.61)
  TOP w0.508: R79937.2 141.89,42.8 v3(142.02,42.67) ; PR5481.1 122.4,97.6 v3(121.83,97.03) ; v5(122.59,30.1) D5205.A ; v3(120.81,105.03) 121.95,106.17 PR11.1 ; PR44.2 131.77,93.09 132.54,93.09 v3(132.65,92.99) 140.34,92.99 v3(140.88,92.46) ; v3(100.49,68.33) 100.36,68.2 PC12190.1 ; PC12190.1 100.67,67.61 102.9,67.61 105.57,64.94 105.57,62.29 R6705.1 105.25,61.21 109.55,61.21 110.42,60.34 110.42,57.18 110.37,57.12 110.37,55.27 LPC1.8 ; PC12190.1 99.86,67.82 PU8501.6 ; v3(146.59,40.77) 145.96,41.4 R80251.2
  TOP w1.016: v5(22.51,2.92) 23.15,2.29 46.9,2.29 v5(49.31,4.7)
  L3 w0.381: v3(47.15,30.61) 47.15,35.69 50.2,38.73 v3(50.2,38.86)
  L3 w0.508: v3(121.83,97.03) 121.19,97.66 121.19,104.65 v3(120.81,105.03) 119.36,105.03 116.26,108.13 105.39,108.13 v3(104.81,108.71) ; v5(122.59,31.11) 122.68,31.21 122.68,35.93 123.61,36.86 126.88,36.86 127.8,35.94 127.8,34.92 128.81,33.91 129.47,33.91 129.7,34.14 136.15,34.14 137.47,35.46 137.47,40.08 139.05,41.66 140.75,41.66 141.77,42.67 v3(142.02,42.67)
  L4 w0.254: LPC1.8 108.26,57.38 102.65,57.38 99.96,60.07 99.06,60.07 98.15,60.99 96.4,60.99 95.77,61.61 95.77,61.61 95.59,61.8 91.64,61.8 91.31,61.47 88.17,61.47 87.79,61.09 85.12,61.09 81.34,57.3 80.45,57.3 78.9,55.75 v3(78.14,55.75)
  L4 w0.508: v3(140.88,92.46) 143.8,89.53 v3(151.42,89.53) 155.48,85.47 v3(156.88,85.47) ; v3(120.81,105.03) 127.65,105.03 128.43,104.25 129.42,104.25 129.98,104.8 132.89,104.8 133.89,103.8 133.89,102.36 132.49,100.97 132.49,93.14 v3(132.65,92.99)
  L4 w0.762: v5(122.59,31.11) v5(122.59,30.1) 122.59,29.08 120.48,26.97 120.48,21.7 120.91,21.26 120.91,16.68 121.9,15.68 121.9,8.84 122.97,7.77 v5(122.97,4.7)
  BOTTOM w0.254: R9540.1 v3(78.14,55.75) ; v3(152.43,100.58) 152.84,100.18 v2(152.84,95.53) 152.84,90.96 v3(151.42,89.53) ; R617.1 156.59,81.94 156.64,81.94 157.77,83.07 v2(157.77,83.74) 157.77,84.58 v3(156.88,85.47)
  BOTTOM w0.381: 112.05,51.69 112.05,53.59 LPC1.8 110.05,53.63 110.05,51.4 110.9,50.55 112.05,51.69
  BOTTOM w0.508: v3(142.02,42.67) 142.02,42.84 142.63,43.46 143.9,43.46 v3(146.59,40.77) ; R1849.1 v3(50.2,38.86) ; v3(104.81,108.71) v2(104.81,102.74) 104.81,100.12 104.15,99.46 104.15,91.35 101.76,88.96 101.76,86.49 99.41,84.14 99.41,80.92 100.49,79.84 v2(100.49,71.07) v3(100.49,68.33)
  BOTTOM w0.762: F7.1 115.78,33.99 114.33,35.43 114.33,40.13 110.9,43.56 110.9,50.55
  BOTTOM w1.016: 8.54,208.53 8.54,205.99 ; 8.54,205.99 v2(8.57,206.02) ; 8.54,205.99 9.56,204.98 9.56,189.74 v5(11.08,188.21) v5(12.1,188.21)
  vias: v2(118.09,32.05) v3(35.68,110.24) v3(35.72,109.35) v3(35.72,108.58) v5(22.26,43.43) v5(22.26,42.29) v5(22.26,41.27) v5(85.76,6.99) v5(85.76,5.84) v5(85.76,4.7) v5(93.51,7.62) v5(94.47,7.62) v5(122.97,3.68) v5(123.99,4.7) v5(123.99,3.68)
VCC3: length 1195.4
  TOP w0.203: U118.37 133.35,31.84 v3(133.26,31.75) ; v3(158.53,76.2) 158.58,76.25 U6.7 ; 158.53,74.17 159.01,74.65 U6.11 ; v3(99.09,56.26) 98.69,55.86 U4101.4 ; 135.16,38.73 134.78,38.73 134.55,38.5 U118.11
  TOP w0.254: v3(72.17,139.7) 72.17,139.51 R1615.1 ; R2012.1 87.45,139.47 v4(87.28,139.64) 87.36,139.71 R80177.1 ; R80219.2 100.74,137.22 v3(101.04,137.52) ; v3(164.5,212.22) 150.08,226.63 112.14,226.63 111,227.78 84.34,227.78 83.44,226.88 83.44,224.7 83.82,224.31 83.82,222.28 83.35,221.8 83.35,220.85 82.93,220.44 80.92,220.44 80.77,220.29 80.77,220.28 80.06,219.57 80.06,218.33 77.83,216.1 77.83,212.64 77.76,212.56 77.76,209.93 79.15,208.53 R507.1 ; v3(73.82,137.99) 73.49,137.67 R1610.2 ; v3(85.89,60.45) 86.14,60.45 86.77,61.09 R6703.1 ; v5(60.52,67.09) 60.52,67.09 64.8,71.37 64.8,73.79 v3(65.37,74.36) ; v3(141.77,127.61) 142.56,127.61 147.99,122.17 152.94,122.17 153.51,121.6 R79991.1 ; R213.1 155.16,80.2 v5(154.92,80.44) ; R41.1 v3(44.36,122.17) ; R251.2 124.75,54.99 v3(124.62,54.86) ; v3(101.13,113.81) 101.13,113.47 R79921.2
  TOP w0.305: R9927.1 32.58,224.94 32.55,224.94 v3(32.55,225.43) ; v3(19.62,189.64) 19.62,189.49 20.29,188.82 R80147.2 ; R342.1 38.13,127.25 v3(37.63,127.76) ; R79991.1 R124.1
  TOP w0.33: v4(128.3,127.64) 128.3,127.65 129.41,128.75 DIMM1.199 ; DIMM2.199 146.42,128.77 147.36,128.77 v4(147.99,128.14)
  TOP w0.381: 66.58,132.97 66.26,132.65 R1684.1 ; 66.58,132.97 66.58,132.72 67.1,132.19 69.42,132.19 R1687.1 70.54,133.31 70.67,133.31 70.96,133.6 71.62,133.6 72.19,133.03 74.39,133.03 v3(75.47,134.12) ; 66.58,132.97 R80180.1 ; R249.2 123.48,57.66 v3(123.35,57.53) ; R290.2 153.07,73.53 154.21,72.39 ; R80194.1 134.15,29.46 133.56,30.05 133.56,31.45 v3(133.26,31.75) ; v3(101.38,142.49) 101.25,142.37 R2032.1 R80080.1 ; R80148.2 14.19,178.75 v3(14.38,178.56) ; R2040.2 R2041.2 86.96,139.32 v4(87.28,139.64) ; v3(107.86,133.48) 108.49,132.84 108.49,131.7 107.86,131.06 v3(107.86,130.18) ; v3(72.17,139.7) R1611.2 R1617.2 ; v3(57.56,80.77) 57.69,80.64 R517.1 ; R80195.1 134.97,31.81 v3(134.91,31.88) ; v5(160.43,89.79) 160.94,90.3 Q77.S
  TOP w0.508: R80154.2 147.61,71.75 147.48,71.88 ; R79755.1 79.6,52.01 v3(79.66,51.94) ; R323.2 129.5,41.66 v5(128.94,41.66) ; v3(59.09,40.64) 59.09,40.51 58.55,39.98 55,39.98 v3(54.77,39.75) ; v3(136.81,38.61) 136.81,39.43 C12200.1 136.05,39.62 135.16,38.73 ; C131.1 158.08,73.72 158.53,74.17 ; 147.48,71.88 147.48,72.69 146.86,73.3 145.83,73.3 145.03,74.1 R265.2 143.56,73.74 142.69,73.74 140.5,71.54 140.5,71.18 R335.1 R296.2 ; 147.48,71.88 v3(148.75,71.88) ; v3(54.26,51.56) 54.96,50.86 R79174.2 R530.2 ; R80091.2 168.88,92.71 R79922.2 ; C836.2 161.28,90.74 Q77.S ; R71.1 13.69,221.42 D1.K v3(13.88,222.76) ; R80092.2 R79922.2 ; R79922.2 170.15,92.65 171.36,91.44 v5(171.36,89.66) ; R286.2 v3(139.23,43.94) ; v3(38.77,124.46) 63.66,124.46 66.34,127.14 72.92,127.14 74.33,125.73 R80179.1 77.31,125.29 77.6,124.99 v3(78.72,124.99) ; v5(79.66,61.09) 79.66,61.44 81.47,63.25 R6704.1 81.82,63.31 R6701.1 ; R377.1 31.78,3.99 32.34,3.43 39.02,3.43 40.04,4.45 v3(40.04,4.6) 40.13,4.6 40.67,5.14 R1183.2 ; 154.95,67.06 155.56,66.45 157.18,66.45 C509.1 157.73,66.99 C516.1 160.05,66.99 L21.1 ; R134.1 45.5,21.59 v3(46.01,21.08) ; R79171.1 78.9,49.21 v3(79.01,49.33) 79.19,49.15 R79838.1 ; R1699.1 106.01,60.26 106.46,59.82 106.46,58.04 107.03,57.47 LPC1.4 ; R9557.1 86.58,52.53 R9543.1 84.98,52.07 v3(84.62,52.07) ; R255.2 142.21,43.5 v3(142.91,42.8) ; R264.2 123.6,60.33 v3(123.73,60.2) 122.97,59.44 R324.1
  TOP w0.635: v5(178.21,137.79) 175.16,134.74 172.25,134.74 164.12,126.6 150.93,126.6 150.15,127.38 148.52,127.38 147.99,127.92 v4(147.99,128.14)
  TOP w0.762: v3(164.12,179.83) v3(167.8,179.83)
  TOP w1.016: v5(120.56,46.61) 120.56,46.33 122.82,44.07 124.24,44.07 125.89,42.42 128.35,42.42 128.94,41.83 v5(128.94,41.66)
  L3 w0.254: 80.44,59.07 81.29,59.92 81.41,59.92 81.94,60.45 v3(85.89,60.45) ; v3(159.16,208.66) v3(155.99,208.66)
  L3 w0.305: v3(19.62,189.64) 19.62,189.46 15.59,185.44 15.59,183.68 15.15,183.23 15.15,181.61
  L3 w0.381: v3(72.17,139.7) 73.82,138.05 v3(73.82,137.99) ; v3(159.16,208.66) 159.67,208.66 163.23,212.22 v3(164.5,212.22) ; v3(99.35,136.02) 99.53,136.02 v3(101.04,137.52) 101.04,136.99 v3(107.86,130.18) ; 15.15,181.61 15.15,179.32 v3(14.38,178.56) ; v3(54.26,51.56) 55.15,50.67 55.15,49.4 59.09,45.47 v3(59.09,40.64)
  L3 w0.508: v3(98.16,124.84) 98.16,126.59 100.6,129.03 106.71,129.03 v3(107.86,130.18) 107.86,130 108.34,129.51 108.9,129.51 110.14,128.27 127.8,128.27 128.18,127.9 128.18,127.76 v4(128.3,127.64) ; 97.65,53.9 99.09,55.34 v3(99.09,56.26) ; v3(84.62,52.07) 84.57,52.07 83.47,53.17 83.47,54.61 ; v3(40.04,4.6) 45.47,10.03 46.56,10.03 48.19,11.66 48.19,13.06 46.01,15.24 v3(46.01,21.08) 46.01,21.84 47.18,23.01 47.18,28.98 54.77,36.58 v3(54.77,39.75)
  L3 w0.762: v3(164.12,185.17) v3(164.12,179.83)
  L3 w1.016: v5(120.56,46.61) 120.56,46.89 119.82,47.62 117.4,47.62 116.95,47.18 102.36,47.18 97.65,51.89 97.65,53.9 95.88,55.66 88.97,55.66 87.92,54.61 83.47,54.61 83.47,56.03 79.66,59.84 v5(79.66,61.09)
  L4 w0.254: v3(57.56,80.77) 57.56,80.52 60.1,77.98 61.76,77.98 v3(65.37,74.36) ; v3(38.77,124.46) 41.31,124.46 43.59,122.17 v3(44.36,122.17)
  L4 w0.305: v3(73.82,137.99) 74.46,137.36 74.46,135.13 v3(75.47,134.12) ; v3(32.55,225.43) 32.55,225.4 31.94,224.79 29.12,224.79 28.1,223.77 14.89,223.77 v3(13.88,222.76) ; v3(46.01,21.08) 42.32,21.08 41.31,20.07 37.12,20.07 34.58,17.53 33.31,17.53 31,15.22 24.53,15.22 23.66,14.35 v3(22.69,14.35)
  L4 w0.381: v3(99.35,136.02) 98.2,134.87 91.73,134.87 87.28,139.32 v4(87.28,139.64) ; 59.5,67.09 56.04,63.63 55.45,63.63 50.62,58.79 50.62,54.24 53.29,51.56 v3(54.26,51.56)
  L4 w0.508: v3(14.38,178.56) 14.87,178.56 15.17,178.26 15.17,164.34 19.15,160.36 19.15,145.53 21.01,143.66 21.23,143.66 23.25,141.64 23.25,140.44 24.65,139.04 30.41,139.04 34.83,134.62 34.83,127.59 36.31,126.11 38.39,126.11 ; v5(60.52,67.09) 57.48,67.09 53.25,71.33 v3(53.25,75.09) ; LPC1.4 104.97,56.67 99.5,56.67 v3(99.09,56.26) ; 38.39,126.11 38.39,127 v3(37.63,127.76) ; 38.39,126.11 38.77,125.73 v3(38.77,124.46) ; v3(148.75,71.88) 151.42,71.88 152.23,72.69 v3(155.48,72.69)
  L4 w0.762: v5(177.07,153.03) v5(180.25,153.03) ; v5(60.52,67.09) 60.52,66.41 62.34,64.59 69.07,64.59 73.87,59.79 78.37,59.79 v5(79.66,61.09)
  BOTTOM w0.203: 175.42,141.99 175.38,142.02 U14.11
  BOTTOM w0.254: v3(133.26,31.75) 132.43,30.92 R1596.1 ; Q9627.5 R391.2 161.51,41.12 161.23,40.83 160.83,40.83 159.62,39.62 155.84,39.62 155.43,39.22 153.09,39.22 152.43,39.88 v3(152.31,39.88) ; R802.2 73.83,137.99 v3(73.82,137.99) ; R1716.2 155.1,205.87 155.99,206.76 v3(155.99,208.66) ; v3(75.47,134.12) 76.49,135.13 R803.2 ; R12.1 158.08,207.58 v3(159.16,208.66) ; v3(22.69,14.35) 22.16,14.88 22.16,15.39 22.56,15.8 22.56,26.87 23.07,27.38 23.07,30.48 23.68,31.09 R1757.1
  BOTTOM w0.305: v3(19.62,189.64) 19.62,189.64 19.59,189.66 v2(19.59,190.63) PR4615.1 ; v3(101.13,113.81) 101.13,115.06 98.16,118.03 98.16,124.54
  BOTTOM w0.381: R524.1 58.36,80.16 58.36,80.23 57.83,80.77 v3(57.56,80.77) ; R80067.2 R79761.1 R79762.1 ; R2006.1 106.9,131.83 R79759.1 108.2,131.76 108.45,132.02 108.45,132.88 v3(107.86,133.48) 107.22,134.11 R2007.1 R79763.1 R79762.1 ; R79762.1 107.16,136.65 109.53,136.65 110.65,137.77 110.65,139.38 R79764.1 109.57,141.6 108.75,142.43 R2021.1 106.78,142.49 v3(101.38,142.49) ; v3(107.86,130.18) 107.28,130.18 R79760.1 ; v3(167.8,179.83) 167.91,179.95 167.91,208.78 v2(165.92,210.77) 165.92,210.79 v3(164.5,212.22)
  BOTTOM w0.508: 123.35,55.37 122.59,54.61 v2(122.59,50.32) 122.59,48.64 v5(120.56,46.61) ; v3(53.25,75.09) 52.74,74.58 L9503.1 ; R79866.1 55.21,51.63 55.15,51.56 v3(54.26,51.56) ; v3(46.01,21.08) 44.61,21.08 43.78,21.91 R143.1 43.72,22.67 R138.1 ; v4(147.99,128.14) 147.92,128.21 C1311.1 R1302.1 145.89,128.4 142.56,128.4 v3(141.77,127.61) 140.39,128.98 130.79,128.98 130.61,129.16 129.4,129.16 128.61,128.37 128.61,128.1 128.3,127.8 v4(128.3,127.64) 128.3,127 127.8,126.49 C1203.1 ; D19.2 59.82,38.93 R1846.1 60.31,39.93 59.6,40.64 v3(59.09,40.64) ; v3(79.01,49.33) 79.01,51.3 v3(79.66,51.94) 80.11,52.39 ; v3(84.62,52.07) 84.49,52.07 83.98,52.58 80.3,52.58 80.11,52.39 ; R9533.1 R9532.1 80.11,52.39 ; v3(75.47,134.12) 75.6,133.99 v2(75.6,131.83) 75.6,130.3 76.39,129.51 76.39,127.33 78.71,125.01 ; 78.71,125.01 80.14,125.01 R80178.1 ; 78.71,125.01 v3(78.72,124.99) ; 78.71,125.01 78.71,124.35 83.96,119.1 92.72,119.1 98.16,124.54 v3(98.16,124.84) ; v3(13.88,222.76) 12.99,222.76 v2(11.59,221.36) 11.46,221.36 4.69,214.59 4.69,214.11 4.69,214.11 4.69,207.92 8.67,203.93 8.67,189.37 11.86,186.18 12.65,186.18 13.37,185.46 v2(13.37,180.82) 13.39,180.8 13.39,179.17 14,178.56 v3(14.38,178.56) ; 157.61,74.42 C474.1 159.67,74.49 159.67,75.44 C478.1 159.04,75.69 v3(158.53,76.2) ; 157.61,74.42 156.88,74.42 v3(155.86,73.41) ; 157.61,74.42 v2(157.59,74.4)
  BOTTOM w0.762: v5(182.53,137.79) 182.53,150.75 v5(180.25,153.03) 177.45,155.83 171.05,155.83 167.8,159.08 v3(167.8,179.83) ; R79842.1 176.94,153.16 v5(177.07,153.03)
  BOTTOM w1.27: v5(171.36,89.66) 171.32,89.69 171.32,106.83 171.38,106.89 v2(171.38,109.93) 171.32,109.99 171.32,122.02 182.53,133.22 v5(182.53,137.79) ; v5(160.43,89.79) 159.72,89.79 154.82,84.89 154.82,80.54 v5(154.92,80.44)
  vias: v2(135.9,40.56) v3(136.05,38.61) v3(151.8,61.21) v3(151.8,60.45) v5(124.62,11.43) v5(124.62,10.41)
VCC3_CAM:
  vias: v1(162.97,189.61)
VCC5_33_CT1: length 4.7
  TOP w0.102: C1837.1 123.96,8.72 123.96,8.51 123.96,7.87 123.96,7.87 123.96,6.99 v1(124.44,6.5) 124.66,6.5 125.12,6.97 U52.12
VCC5_33_CT2: length 3.8
  TOP w0.102: C1836.1 124.24,9.33 124.24,8.56 v1(124.54,8.26) 124.63,8.26 125.12,7.77 U52.10
VCC5_33_EN: length 10.3
  TOP w0.102: U52.5 129.21,7.77 v3(129.57,8.13) ; v3(129.45,6.73) 129.21,6.97 U52.3
  L4 w0.127: v3(129.57,8.13) 129.45,8 v3(129.45,6.73)
  BOTTOM w0.102: R1878.1 126.77,11.69 127.86,11.69 C1831.1 129.57,9.97 v2(129.57,9.5) v3(129.57,8.13)
VCC5_PANEL: length 28.1
  TOP w0.381: R79690.1 44.93,103.44 v3(44.86,103.5)
  L4 w0.381: v3(44.86,107.44) 45.63,106.68 45.63,104.27 v3(44.86,103.5)
  BOTTOM w0.381: R79687.1 43.53,87.31 v2(44.19,87.97) 44.86,88.65 v3(44.86,103.5)
  BOTTOM w0.508: Q9647.S 42.71,102.04 R80239.1 43.02,103.5 v3(44.86,103.5)
  vias: v2(43.95,107.11) v3(44.86,108.2)
VCC5_USB: length 90.2
  L4 w0.762: v5(101.13,6.6) 101.13,7.36 99.15,9.33 85.37,9.33 84.49,8.45 84.49,4.19 83.93,3.63 25.36,3.63 v5(25.05,3.94)
  BOTTOM w0.381: Q43.3 122.97,8.38 123.48,8.89 123.48,11.18 C249.2
  BOTTOM w0.508: v5(102.14,6.6) v2(102.14,5.66)
  BOTTOM w0.762: F15.1 24.8,4.19 v5(25.05,3.94) 25.51,3.48 v2(26.09,3.48)
  vias: v2(119.57,5.99) v5(115.35,8.64) v5(116.37,8.26) v5(117.38,8.26) v5(160.31,121.41) v5(160.31,120.4)
VCC_CORE: length 192.5
  TOP w0.254: v3(77,166.09) CPU1.J37 ; v4(71.31,169.54) 71.43,169.67 71.85,169.67 CPU1.A44 ; v4(71.28,167.55) 71.82,167.55 CPU1.A39 ; v4(71.03,162.18) 71.25,162.4 CPU1.A30 ; PG4702.2 PL4701.2 ; v4(70.65,164.21) 71.03,164.21 71.7,164.88 CPU1.A34 ; v3(77,164.26) CPU1.J33
  TOP w0.381: v3(149.26,98.81) 149.26,102.23 149.85,102.83 149.85,107.67 148.7,108.83 145.77,108.83 145.3,108.83 137.53,116.6 132.67,116.6 128.42,120.84 118.03,120.84 116.24,122.63 116.24,129.14 v3(115.81,129.57)
  TOP w0.508: PT4703.1 55.19,178.69 ; PT4703.1 53.08,178.69 ; PT4703.1 54.14,179.74 ; PT4703.1 54.14,177.63 ; 52.74,184.24 PT4701.1 ; PT4701.1 52.74,186.35 ; PT4701.1 51.68,185.29 ; PT4701.1 53.79,185.29
  L3 w0.178: 87.61,156.48 89.75,156.48 89.76,156.46 91.22,156.46 92.11,155.57 88.04,155.57 87.61,156.01 87.61,156.48 ; 87.61,156.48 87.6,156.46
  L3 w0.305: 87.6,156.46 87.6,163.13 v4(86.52,164.21)
  L3 w0.381: 92.11,155.57 95.93,155.57 97.61,153.9 97.61,148.73 106.73,139.61 108.58,139.61 115.81,132.38 v3(115.81,129.57)
  BOTTOM w0.381: G1.1 145.83,48.03 145.83,50 149.04,53.21 149.04,70.65 149.77,71.37 149.77,90.26 150.78,91.27 150.78,97.7 149.68,98.81 v3(149.26,98.81)
  BOTTOM w0.508: PT4701.1 52.74,186.35 ; PT4701.1 52.74,184.24 ; PT4701.1 51.68,185.29 ; PT4701.1 53.79,185.29 ; 54.14,177.63 PT4703.1 ; PT4703.1 53.08,178.69 ; PT4703.1 54.14,179.74 ; PT4703.1 55.19,178.69
  vias: v2(46.97,181.58) v2(64.12,173.84) v2(75.93,165.28) v3(65.95,169.54) v3(66.33,171.83) v3(77.38,168.61) v3(77.35,167.84) v3(77.38,167.13) v3(77.46,169.29) v4(68.63,171.83) v4(68.74,169.54) v4(68.74,167.51) v4(70.54,171.83) v4(70.65,169.54) v4(86.01,166.5) v4(86.52,167) v4(86.52,165.86) v4(86.52,164.97) v5(45.37,177.55) v5(45.37,176.4) v5(45.5,184.15) v5(45.5,183.01) v5(46.39,177.55) v5(46.39,176.4) v5(46.52,184.15) v5(46.52,183.01) v5(47.4,177.55) v5(47.4,176.4) v5(47.53,184.15) v5(47.53,183.01) v5(48.42,177.55) v5(48.42,176.4) v5(48.55,184.15) v5(48.55,183.01) v5(50.83,181.99) v5(50.83,180.85) v5(51.85,181.99) v5(51.85,180.85) v5(52.99,181.99) v5(52.99,180.85) v5(54.01,181.99) v5(54.01,180.85) v5(54.9,185.8) v5(54.9,184.66) v5(55.91,185.8) v5(55.91,184.66) v5(77.88,165.99) v5(79.28,165.61) v5(80.17,165.61) v5(81.44,165.61) v5(82.33,165.61) v5(83.6,165.61) v5(84.49,165.61)
VCC_FAN: length 8.1
  TOP w0.305: FANC3.2 14.37,211.9 R80.1
  BOTTOM w0.508: 12.82,212.27 FANC3.2 ; FANC3.2 14,213.45 ; FANC3.2 14,211.09 ; FANC3.2 15.18,212.27
  vias: v2(5.95,213.49)
VCC_VTT:
  vias: v2(87.71,208.28)
VCCCORE_SENSE: length 64
  TOP w0.254: 36.58,190.96 32.29,190.96 PG4607.2 ; 36.58,190.96 40.57,190.96 41.61,189.92 41.61,188.45 41.97,188.09 42.53,188.09 v3(42.83,188.39) ; 36.58,190.96 v1(36.58,191.29) ; v4(73.83,163.71) 74.41,163.13 CPU1.E32
  L3 w0.254: v3(42.83,188.39) 43.14,188.09 48.83,188.09 49.94,186.97 49.94,177.29 52.61,174.62 53.62,174.62 v3(53.88,174.88)
  L4 w0.254: v4(73.83,163.71) 73.66,163.88 72.48,163.88 71.79,163.19 69.07,163.19 58.53,173.74 54.9,173.74 53.88,174.75 v3(53.88,174.88)
  BOTTOM w0.254: R80017.2 72.49,163.58 73.7,163.58 v4(73.83,163.71)
VCCCOREG0: length 1.5
  TOP w0.102: CPU1.K32 77,163.25 v3(77,163.32)
  BOTTOM w0.102: v3(77,163.32) 77.17,163.14 TP701.1
VCCCOREG1: length 1.7
  TOP w0.102: CPU1.AK32 86.57,162.89 v4(86.39,163.07)
  BOTTOM w0.102: TP702.1 85.99,162.66 v4(86.39,163.07)
VCCGT_SENSE: length 101.7
  TOP w0.089: CPU1.J70 76.78,184.87 76.78,185.08 76.84,185.21 76.84,185.4 76.84,185.4 76.79,185.53 76.78,185.58 76.78,186.35 v4(77.49,187.06)
  TOP w0.254: v3(20.73,210.44) 20.53,210.24 PG4601.2 ; v4(77.49,187.06) 77.14,187.06 76.74,187.45 76.74,189.93 R80016.2
  L4 w0.254: v3(77.76,204.22) 77.41,204.57 77.41,210.03 68.11,219.33 59.12,219.33 56.2,222.25 48.55,222.25 47.91,222.88 34.67,222.88 27.05,215.26 22.86,215.26 20.99,213.39 20.99,210.69 v3(20.73,210.44)
  BOTTOM w0.254: 78.64,188.72 78.64,188.22 v4(77.49,187.06) ; 78.64,188.72 78.64,190.63 77.6,191.67 77.12,192.15 77.12,203.58 v3(77.76,204.22) ; 78.64,188.72 v2(78.27,188.72)
VCCIO_EN_C_1: length 19.7
  TOP w0.152: v3(21.05,141.86) 21.05,140.84 R80159.1 21.7,141.11 Q9635.6 ; v3(35.09,139.83) 34.51,139.26 Q9634.G
  BOTTOM w0.152: v3(21.05,141.86) 24.8,141.86 26.58,140.08 v2(31.91,140.08) 34.83,140.08 v3(35.09,139.83)
VCCIO_EN_C_2: length 4.6
  TOP w0.152: R80126.2 24.14,141.24 v1(24.14,141.43) 23.73,141.83 23.48,141.83 22.87,142.45 22.87,143.1 23.15,143.38 Q9635.2
VCCIO_EN_C_3: length 220.1
  TOP w0.152: v3(158.02,167.89) 158.08,167.96 R80243.1 PC12440.1 ; Q9635.5 22.13,143.38 22.51,143 v3(22.51,141.35) 22.51,140.64 22.28,140.41 R80127.2
  L4 w0.152: v3(158.02,167.89) 161.07,164.85 161.07,129.67 153.44,122.03 137.79,122.03 v3(134.42,118.67) ; v3(120.81,106.17) 119.95,105.31 116.57,105.31 111.49,110.39 111.49,115.42 110.18,116.73 83.01,116.73 71.58,128.16 70.2,128.16 70.2,128.16 66.59,128.16 64.42,125.98 44.48,125.98 39.89,130.58 38.95,130.58 37.9,131.63 37.9,131.93 36.23,133.6 v3(36.23,134.11)
  BOTTOM w0.152: v3(36.23,134.11) 31.02,139.32 v2(28.23,139.32) 26.83,139.32 24.8,141.35 v3(22.51,141.35) ; v3(134.42,118.67) 133.36,117.6 122.11,117.6 120.81,116.3 v3(120.81,106.17)
VCCIO_EN_C_4: length 6.2
  TOP w0.152: PR8509.2 25.69,146.24 25.69,145.16 25.23,144.7 v1(25.23,144.5) 25.03,144.5 24.67,144.15 ; Q9635.1 24.4,142.73 24.67,143 24.67,144.15 ; 24.67,144.15 24.66,144.16 24.53,144.03 Q9635.3
VCCIO_VR_FB: length 2.5
  TOP w0.254: v4(88.27,158.78) 87.95,158.45 CPU1.AM23
  BOTTOM w0.254: v4(88.27,158.78) 87.99,158.5 v2(87.41,158.5) R80020.2
VCCK_1V2: length 64.9
  TOP w0.305: 63.33,53.19 63.62,53.48 SCA1.120 ; v3(55.28,70.23) 55.11,70.4 SCA1.73 ; SCA1.60 57.12,74.83 57.56,74.39 v3(57.56,74.3)
  TOP w0.508: v3(62.77,50.67) 62.83,50.74 C12183.2 62.83,51.98 63.33,52.48 63.33,53.19
  BOTTOM w0.508: L9523.1 73.82,54.23 75.22,52.83 75.22,51.31 74.43,50.52 74.43,48.87 73.95,48.39 66.05,48.39 65.18,49.25 64.19,49.25 v2(63.79,49.66) v3(62.77,50.67) 62.7,50.6 62.7,49.93 61.66,48.9 58.33,48.9 57.31,49.91 54.54,49.91 52.74,51.72 52.74,55.83 52.73,55.84 52.73,56.43 52.74,56.44 C12169.1 L9504.2 52.74,67.69 v3(55.28,70.23) 55.21,70.29 C12196.1 55.21,71.77 v2(55.83,72.39) 57.56,74.12 v3(57.56,74.3) 57.56,74.55 57.82,74.8 C12195.1
VCCRTCEXT: length 6.1
  TOP w0.102: 95.66,149.2 97.09,149.2 97.44,148.84
  TOP w0.114: CPU1.BB10 94.62,150.25 95.66,149.2
  TOP w0.254: 97.44,148.84 97.72,148.56 v1(97.72,148.11) 97.91,147.92 C2112.1
VCCSA_SENSE: length 103.2
  TOP w0.089: CPU1.H20 76.65,155.86 76.65,157.01 76.92,157.29 76.92,158.01 v4(77.58,158.67)
  TOP w0.254: v3(20.38,189.63) 20.35,189.65 PG4603.2
  L3 w0.254: v3(20.61,162.94) 20.61,163.45 15.91,168.15 15.91,181.59 16.63,182.31 16.63,185.16 20.54,189.07 20.54,189.46 v3(20.38,189.63)
  BOTTOM w0.254: 40.85,158.5 45.58,158.5 48.45,161.37 51.21,161.37 51.77,160.81 58.79,160.81 60.15,159.44 60.15,155.56 60.52,155.19 65.66,155.19 68.3,157.84 69.73,157.84 70.89,159 72.11,159 72.42,159.32 R80022.2 73.98,159.32 74.42,159.77 76.87,159.77 77.58,159.06 v4(77.58,158.67) ; 40.85,158.5 v2(40.85,158.93) ; 40.85,158.5 24.7,158.5 21.18,162.02 21.18,162.37 v3(20.61,162.94)
VCCSENSE_EDRAM_VR: length 2.4
  TOP w0.254: CPU1.AC63 83.32,178.98 v3(83.18,178.84)
  BOTTOM w0.254: R80012.2 83.79,179.45 v3(83.18,178.84)
VCCSENSE_EOPIO_VR: length 5.5
  TOP w0.089: CPU1.AL63 87.39,180.11 86.8,179.52 86.8,179.32
  TOP w0.254: v3(86.14,178) 86.14,178.16 86.8,178.82 86.8,179.32
  BOTTOM w0.254: v2(85.25,175.92) R80014.2 86.14,177.86 v3(86.14,178)
VCCST_GD_1: length 6.3
  TOP w0.102: R80252.2 v1(75.09,221.49) 76.74,223.14 77.44,223.14 77.65,223.35 77.65,224.14 77.38,224.41 Q9654.2
VCCST_GD_2: length 6
  TOP w0.102: 79.79,224.66 79.54,224.41 Q9654.5 ; 79.79,224.66 79.79,223.27 78.96,222.44 R80253.1 78.96,221.3 v1(78.9,221.23) ; 79.79,224.66 79.39,225.06 Q9654.6
VCCST_GD_CPU: length 10
  TOP w0.089: CPU1.B65 72.08,181.29 71.4,181.29 71.39,181.3
  TOP w0.102: R80044.2 v1(69.5,188.47) 69.5,187.24 69.92,186.82 69.92,182.74 71.37,181.3 71.39,181.3
VCCST_GD_R: length 100.1
  TOP w0.102: R9903.1 17.81,225.85 18.56,226.59 22.54,226.59 24.18,228.23 54.63,228.23 55.41,227.46 63.93,227.46 70.39,220.99 70.39,220.85 v3(71.28,219.96) 75.07,223.76 Q9654.3 ; v3(71.23,192.86) 70.71,192.34 R80043.2 70.71,191.59 69.6,190.48 69.6,190.48 69.5,190.38 R80044.1 68.66,189.47 U9626.4
  BOTTOM w0.102: v2(70.65,192.23) 70.65,192.23 71.23,192.8 v3(71.23,192.86) 71.29,192.86 71.64,193.21 71.64,219.61 v3(71.28,219.96)
VCCSTG_EN: length 13.1
  TOP w0.102: R80160.1 33.54,138.13 33.54,139.9 33.72,140.08 34.01,140.08 Q9634.D 36.55,141.16 36.99,140.72 37.33,140.72 37.72,141.11 U704.4 ; R80160.1 33.88,136.97 v1(34.2,136.65) ; R80160.1 33.88,137.86 v3(35.09,139.06)
  BOTTOM w0.102: PC12439.1 D5212.1 35.15,139.13 v3(35.09,139.06)
VCCSTU_EN: length 228.6
  TOP w0.102: U706.4 47.11,143.02 v1(47.05,143.08) 47.05,142.85 47.93,141.97 47.93,140.6 47.39,140.07 47.39,136.13 47.15,135.89 42.48,135.89 38.42,131.83 v3(38.39,131.83) ; v3(158.02,167) 157.51,167.51 157.51,168.85 PC12441.1 Q9652.D 160.5,169.42 R80245.1
  L4 w0.127: v3(158.02,167) 160.68,164.35 160.68,129.83 153.27,122.43 137.42,122.43 v3(133.66,118.67) ; v3(119.92,106.17) 119.45,105.7 116.73,105.7 111.88,110.55 111.88,115.58 110.34,117.12 83.2,117.12 71.77,128.55 66.23,128.55 64.05,126.38 44.72,126.38 40.13,130.98 39.22,130.98 38.72,131.47 38.72,131.49 v3(38.39,131.83)
  BOTTOM w0.102: v3(133.66,118.67) 132.98,117.98 121.95,117.98 120.18,116.2 120.18,108.08 119.92,107.82 v3(119.92,106.17) ; D5212.2 34.1,137.92 37.58,134.45 37.58,132.92 38.39,132.11 v3(38.39,131.83)
VCCSTU_EN_C_1: length 7.3
  TOP w0.102: Q9653.6 162.59,174.19 163.36,173.43 v1(163.36,172.85) 163.36,171.39 162.91,170.94 R80244.1 162.37,170.43 Q9652.G
VCCSTU_EN_C_2: length 2.4
  TOP w0.102: R80247.2 v1(160.82,177.55) Q9653.2
VCCSTU_EN_C_3: length 5.9
  TOP w0.102: R80246.1 159.1,172.21 160.43,172.21 160.75,172.53 PC12442.1 ; Q9653.5 160.82,172.91 PC12442.1 ; v1(161.83,172.85) PC12442.1
VCCSTU_EN_C_4: length 5.9
  TOP w0.102: Q9653.3 160.16,175.38 160.31,175.23 161.32,175.23 161.47,175.38 Q9653.1 161.48,176.09 v1(163.23,176.09) 163.29,176.15 164.43,176.15 PR8527.2
VDDC_CT: length 11.9
  TOP w0.254: GPU1.AB21 87.38,103.4 v4(86.86,102.88) ; GPU1.AB20 87.34,102.4 v4(86.86,102.88) ; GPU1.AA20 86.4,102.42 v4(86.86,102.88) ; v4(86.86,102.88) 86.4,103.34 GPU1.AA21
  BOTTOM w0.254: v4(86.86,102.88) 86.94,102.96 C779.1 C781.1 89.28,102.96 89.75,103.43 v2(93,103.43) 93.23,103.43 93.76,102.9 C780.1 93.89,102.49 L48.2
VSS_AY3: length 16.9
  TOP w0.089: CPU1.AY3 93.03,145.89 93.38,145.54 93.38,144.93 93.51,144.81 93.51,144.27
  TOP w0.102: R606.2 99.28,133.86 v1(98.84,133.86) 97.65,135.05 97.65,139.5 93.51,143.64 93.51,144.27
VSS_AY71: length 12.4
  TOP w0.127: CPU1.AY71 93.2,185.62 93.32,185.75 93.32,187.93 93.8,188.4
  TOP w0.254: 93.8,188.4 94.37,188.98 99.47,188.98 v1(99.6,189.1) 99.6,190.31 R602.2
VSS_MECH: length 68.5
  TOP w0.305: v3(75.85,117.09) 74.57,117.09 74,116.53 v1(74,116.53) 72.88,116.53 70.7,114.34 70.7,112.6 72.2,111.09 GPU1.A32
  TOP w0.356: v4(94.39,111.25) 94.25,111.25 GPU1.AM32 ; v4(94.9,89.41) 94.69,89.2 GPU1.AM1
  BOTTOM w0.381: v4(94.9,89.41) 96.13,90.64 99.49,90.64 101.24,92.39 101.24,106.12 100.79,106.57 97.38,106.57 96.43,107.52 94.42,107.52 94.39,107.54 ; 94.39,107.54 93.5,106.65 88.91,106.65 88.24,107.33 87.5,107.33 86.04,108.79 86.04,109.19 84.77,110.46 84.32,110.46 83.56,111.22 83.56,111.41 77.89,117.09 v3(75.85,117.09) ; 94.39,107.54 v4(94.39,111.25)
VSSCORE_SENSE: length 66.7
  TOP w0.254: PG4606.2 30.89,191.26 31.57,190.58 40.41,190.58 41.23,189.76 41.23,188.93 ; v4(74.15,164.26) 74.41,164 CPU1.E33 ; 41.23,188.93 41.23,188.29 41.82,187.71 42.53,187.71 v3(42.83,187.4) ; 41.23,188.93 v1(40.95,188.93)
  L3 w0.254: v3(42.83,187.4) 43.14,187.71 48.67,187.71 49.56,186.82 49.56,177.13 52.45,174.24 54.22,174.24 v3(54.9,174.92)
  L4 w0.254: v4(74.15,164.26) 72.32,164.26 71.63,163.58 69.23,163.58 58.69,174.12 55.06,174.12 54.9,174.27 v3(54.9,174.92)
  BOTTOM w0.254: v4(74.15,164.26) 74.07,164.34 73.69,164.34 73.31,163.96 71.98,163.96 R80015.1
VSSGT_SENSE: length 101
  TOP w0.089: v4(77.49,186.42) 77.41,186.49 77.19,186.49 76.97,186.27 76.97,186.27 76.97,185.57 77.03,185.44 77.03,185.19 76.97,185.07 76.97,184.61 76.79,184.43 76.79,184.24 CPU1.J69
  TOP w0.254: R80018.1 77.31,187.96 78.01,187.26 78.01,186.82 77.62,186.42 v4(77.49,186.42) ; v3(21.5,210.44) 21.95,209.98 PG4604.2
  L4 w0.254: v3(21.5,210.44) 21.37,210.57 21.37,213.23 23.02,214.88 27.21,214.88 34.83,222.5 47.75,222.5 48.39,221.87 56.04,221.87 58.96,218.95 67.95,218.95 77.03,209.87 77.03,204.06 v3(77.76,203.33)
  BOTTOM w0.254: 79.03,190.58 79.03,190.79 77.99,191.83 77.5,192.31 77.5,203.07 v3(77.76,203.33) ; 79.03,190.58 v2(79.33,190.58) ; 79.03,190.58 79.03,188.06 77.97,187 77.97,186.86 77.53,186.42 v4(77.49,186.42)
VSSIO_VR_FB: length 5.7
  TOP w0.127: 86.52,158.23 86.89,157.86 87,157.86 87.46,157.4 CPU1.AM22
  TOP w0.254: v4(85.92,158.88) 86.08,158.72 86.08,158.69 86.52,158.24 86.52,158.23
  BOTTOM w0.254: v4(85.92,158.88) 85.92,159.02 85.42,159.51 84.62,159.51 v2(84.41,159.31) R80019.1
VSSSA_SENSE: length 103.4
  TOP w0.178: CPU1.H21 76.36,156.36 v4(76.03,156.03)
  TOP w0.254: v3(21.14,189.57) 21.37,189.81 PG4602.2
  L3 w0.254: v3(20.61,162.18) 21.24,162.81 21.24,163.35 16.29,168.31 16.29,181.43 17.02,182.16 17.02,185 20.92,188.91 20.92,189.36 v3(21.14,189.57)
  BOTTOM w0.254: 44.25,158.12 45.74,158.12 48.61,160.99 51.06,160.99 51.61,160.43 58.63,160.43 59.77,159.28 59.77,155.4 60.36,154.81 65.82,154.81 68.46,157.45 69.88,157.45 71.05,158.62 73.82,158.62 74.58,159.38 76.71,159.38 76.9,159.19 R80021.1 76.9,156.9 v4(76.03,156.03) ; 44.25,158.12 24.54,158.12 20.61,162.05 v3(20.61,162.18) ; 44.25,158.12 v2(44.25,157.73)
VSSSENSE_EDRAM_VR: length 2.6
  TOP w0.254: CPU1.AE63 84.23,179.2 v3(84.62,178.82)
  BOTTOM w0.254: R80011.1 84.23,178.44 v3(84.62,178.82)
VSSSENSE_EOPIO_VR: length 3
  TOP w0.254: CPU1.AJ62 85.96,179.09 v3(85.96,178.74)
  BOTTOM w0.254: v3(85.96,178.74) 86.1,178.88 R80013.1 87.03,178.63 v2(87.03,177.98)
0D95V_VGA_PWR: length 0.2
  TOP w0.254: PG8401.1 102.52,101.6
  vias: v1(101.76,102.36)
0D95V_VGA_S0: length 73.2
  TOP w0.508: v3(100.64,93.22) 103.03,90.83 103.03,84.58 v3(101.38,82.93) ; v5(100.36,104.65) 99.22,103.5 99.22,102.36 99.41,102.17 R1162.2 R1161.2 ; L51.1 70.52,82.8 v3(70.14,82.42)
  L3 w0.508: v3(101.38,82.93) 101.38,81.36 100.51,80.49 88.2,80.49 87.28,81.41 71.15,81.41 v3(70.14,82.42)
  BOTTOM w0.508: v5(100.36,104.65) 100.62,104.39 100.62,98.93 100.64,98.91 v3(100.64,93.22) 100.64,92.6 99.23,91.19 97.39,91.19 v2(95.31,93.27) 94.47,93.27 L53.1
  vias: v2(85.99,104.5) v4(79.35,107.07) v4(80.47,105.64) v4(80.51,104.96) v4(81.07,104.07) v4(82.98,103.81) v5(100.36,105.79)
1D0V_S5: length 178.7
  TOP w0.254: PG5202.1 51.21,153.03
  TOP w0.381: v3(71.92,132.46) 74.98,132.46 76.42,133.9 R1136.1 76.42,135.52 77.63,136.73 v3(77.68,136.73)
  TOP w0.508: PT5202.1 55.7,145.16 ; PT5202.1 54.64,144.11 ; PT5202.1 53.59,145.16 ; PT5202.1 54.64,146.22 ; 54.6,153.03 PT5203.1 ; PT5203.1 56.71,153.03 ; PT5203.1 55.66,151.98
  L4 w0.254: v3(52.87,150.5) 53.4,151.03 53.4,157.2 51.72,158.88 22.64,158.88 16.63,164.88 16.63,178.89 15.77,179.75 15.77,215.66 13.28,218.15 13.28,223.18 v3(14.13,224.03)
  L4 w0.381: v3(41.31,143.26) 40.36,142.3 37.35,142.3 36.65,141.6 36.65,136.8 38.32,135.13 44.36,135.13 47.26,132.22 55.7,132.22 56.36,132.88 61.89,132.88 62.51,132.26 71.71,132.26 v3(71.92,132.46)
  BOTTOM w0.381: v3(77.68,136.73) 77.5,136.91 R1120.1 ; R9901.1 15.63,222.94 v2(15.17,223.39) 14.54,224.03 v3(14.13,224.03)
  BOTTOM w0.508: v3(41.31,143.26) 40.8,142.75 R80023.1
  vias: v1(44.99,143.48)
1D8V_EDRAM: length 22.3
  TOP w0.127: CPU1.G61 75.81,179.25 76.31,179.25 76.59,178.96 77.06,178.96 v4(77.12,179.03) 77.06,179.09 77.06,179.51 76.3,180.27 CPU1.H63
  BOTTOM w0.254: v4(77.12,179.03) 77.45,179.36 77.45,185.07 77.97,185.59 77.97,185.61 78.01,185.65 78.01,186.18 v2(80.96,189.13) 81.31,189.48 R80010.2
1D8V_S0:
  vias: v2(80.58,198.86)
1D8V_S5: length 147.9
  TOP w0.381: R2107.2 83.22,136.21 R1138.1 82.65,136.02 v3(81.95,136.02) 81.88,135.95 R1129.1 ; v3(101.63,193.35) 101.63,193.04 104.94,189.74 104.94,173.23 102.47,170.76 102.47,167.31 104.78,165 104.78,162.59 115.64,151.73 115.64,130.53 115.01,129.9 115.01,124.5 v3(114.97,124.46)
  TOP w0.508: v3(83.42,131.98) 83.29,131.85 83.29,130.48 83.62,130.15 R1118.1
  L4 w0.381: v3(114.97,124.46) 114.89,124.39 114.06,124.39 111.96,126.49 107.35,126.49 106.27,127.57 96.11,127.57 v3(95.54,127)
  L4 w0.508: v3(83.42,131.98) 83.55,132.11 84.89,132.11 89.3,127.7 95.01,127.7 95.44,127.27 95.44,127.1 v3(95.54,127)
  L4 w0.635: v3(81.95,136.02) 83.42,134.54 v3(83.42,131.98)
  BOTTOM w0.381: 83.51,201.33 83.51,202.43 83.86,202.78 84.93,202.78 v2(86.47,201.24) 86.47,201.22 91.22,196.47 98.71,196.47 101.63,193.55 v3(101.63,193.35)
  BOTTOM w0.508: v2(81.95,135.13) v3(81.95,136.02)
  vias: v1(94.22,125.73)
1D8V_SIP_S5: length 7.8
  TOP w0.254: CPU1.AA1 82.49,143.48 82.86,143.1 82.86,142.29 83.62,141.53 83.62,139.8 v1(83.75,139.67) 83.79,139.64 C2108.1 83.79,138.43 83.85,138.37 R2107.1
1D8V_VCCPGPPF: length 26.8
  TOP w0.152: v4(85.1,156.41) 85.1,156.41 85.1,153.75 84.81,153.46 CPU1.AF16
  TOP w0.254: v3(81.95,136.78) 82.27,137.1 R1138.2
  L4 w0.254: v3(81.95,136.78) 81.03,137.69 81.03,144.42 82.86,146.25 82.86,149.88 83.98,150.99 83.98,155.29 v4(85.1,156.41)
  BOTTOM w0.254: v3(81.95,136.78) 82.33,136.78 v2(82.71,136.4)
1D8V_VGA_S0: length 80.1
  TOP w0.508: 100.03,82.8 102.4,85.17 102.4,90.17 99.98,92.58 ; R1900.2 99.28,92.58 99.98,92.58 ; L49.1 v3(74.84,82.8) 74.9,82.74 L50.1 ; R80083.2 99.92,96.33 99.98,96.39 ; 99.98,92.58 99.98,95 ; 99.98,95 99.41,94.42 R943.2 ; 99.98,95 99.98,96.39 ; 99.98,96.39 99.98,97.54 v3(99.35,98.17) 99.47,98.17 100.43,99.12 R935.1 100.43,102.45 v3(99.88,103)
  L3 w0.508: v3(74.84,82.8) 75.6,82.04 87.66,82.04 88.58,81.13 100.21,81.13 v3(100.62,81.53)
  L4 w0.508: v3(99.88,103) 97.57,105.31 97.57,111.38 v3(96.68,112.27)
  BOTTOM w0.508: 97.82,97.53 97.41,97.94 95.95,97.94 95.54,97.53 R1211.2 ; 97.82,97.53 97.86,97.49 97.86,95.55 97.54,95.22 v2(97.54,95.17) 97.49,95.17 97.19,94.87 L52.1 ; 97.82,97.53 98.7,97.53 v3(99.35,98.17) ; L47.1 L48.1 96.24,103 v2(97.32,103) v3(99.88,103)
1D35V_S3: length 183.1
  TOP w0.127: v4(95.42,171.29) 95.26,171.13 CPU1.BB47 ; v4(98.28,175.33) 96.72,173.78 94.18,173.78 CPU1.BB51 ; CPU1.BB32 95.2,162.52 95.32,162.4 v4(95.73,162.4)
  TOP w0.203: v4(91.81,165.55) 91.81,165.33 CPU1.AU35 ; CPU1.BB23 94.01,157.43 94.3,157.43 94.85,156.88 94.87,156.88 94.97,156.79 v4(95.3,156.79) ; v4(90.91,167.89) 91.2,168.17 CPU1.AU42
  TOP w0.254: 156.88,165.99 156.88,171.45 157.7,172.28 R80246.2 ; PC5109.1 91.22,202.56 90.86,202.21 85.99,202.21 84.01,204.19 v3(83.98,204.19) ; v4(100.3,168.93) 99.06,167.69 94.7,167.69 94.57,167.56 94.19,167.56 94.19,167.56 94,167.56 CPU1.BB41 ; CPU1.AU23 91.2,158.24 91.52,157.91 v4(91.52,157.86) ; v4(91.53,161.53) 91.2,161.19 CPU1.AU28
  TOP w0.305: C501.1 82.39,218.38 82.09,218.68 U501.5 ; DIMM2.111 144.2,155.15 v4(144.19,155.16)
  TOP w0.33: DIMM2.118 v3(156.58,153.05) ; DIMM1.117 129.65,153.35 v4(129.61,153.39) 129.6,153.38 129.6,151.87 129.92,151.55 DIMM1.123 ; DIMM2.105 144.55,156.95 v4(144.18,157.32) 144.18,157.61 145.32,158.75 DIMM2.99 ; DIMM1.87 129.24,162.35 v4(129.19,162.31) ; DIMM1.93 129.42,160.55 v4(129.32,160.66) ; DIMM2.87 145.28,162.35 v3(144.43,163.19) ; DIMM1.112 140.55,154.85 v3(140.88,155.17) ; DIMM2.76 156.33,165.65 ; DIMM2.117 145.13,153.35 v4(144.31,152.53) 145.28,151.55 DIMM2.123 ; DIMM1.99 129.83,158.75 v4(129.57,158.5) ; DIMM2.75 145.16,165.95 v4(144.56,165.35) 144.56,165.21 145.6,164.16 146.39,164.16 DIMM2.81 ; DIMM2.100 v3(156.58,158.45) ; v4(129.32,163.83) 129.64,164.15 DIMM1.81 ; v3(156.45,151.64) 156.06,151.25 DIMM2.124 ; DIMM1.106 140.68,156.65 v3(141.26,157.23) 141.26,157.61 140.41,158.45 DIMM1.100 ; DIMM1.105 129.58,156.95 v4(129.57,156.94) 129.57,156 130.42,155.15 DIMM1.111 ; DIMM1.82 140.75,163.85 141.26,163.34 v3(141.26,163.27) 141.26,162.56 140.75,162.05 DIMM1.88 ; DIMM2.82 156.35,163.85 ; DIMM1.94 140.6,160.25 v3(141.26,160.91) ; DIMM1.124 140.18,151.25 141.13,152.2 v3(141.13,152.4) 140.48,153.05 DIMM1.118 ; v4(129.83,168.4) 129.83,166.37 130.25,165.95 DIMM1.75 ; DIMM1.76 141.46,165.65 v3(141.51,165.6) ; v3(156.58,162.05) DIMM2.88 ; DIMM2.94 v3(156.58,160.25) ; DIMM2.106 v3(156.58,156.65) ; v3(144.31,160.91) 144.43,160.91 144.79,160.55 DIMM2.93 ; DIMM2.112 v3(156.58,154.85)
  TOP w0.381: C501.1 82.39,211.65 83.13,210.91 83.13,205.04 v3(83.98,204.19)
  BOTTOM w0.254: PR5122.1 81.52,204.19 v3(83.98,204.19)
  BOTTOM w0.381: 123.73,155.7 111.58,143.55 103.92,143.55 102.31,145.16 102.31,145.92 103.07,146.69 106.52,146.69 107.49,147.65 107.49,148.45 106.9,149.03 R80074.1
  BOTTOM w0.508: 140.5,193.61 R1304.1 ; 140.5,193.61 140.37,193.48 140.37,187.45 ; 140.5,193.61 R1212.1
  vias: v2(95.59,210.31) v2(103.33,162.46) v2(128.38,172.44) v2(155.61,187.45) v2(158.05,152.96) v5(93,207.16) v5(93,206.25) v5(97.44,206.78) v5(97.44,205.87) v5(98.36,206.78) v5(98.36,205.87) v5(102.12,207.16) v5(102.12,206.25) v5(103.03,207.16) v5(103.03,206.25)
1D35V_VCCSFR_OC: length 7.8
  TOP w0.254: v4(88.27,157.86) CPU1.AL23
  BOTTOM w0.203: C718.1 90.55,159.23 89.76,159.23 89.76,159.23 89.38,159.23 88.27,158.12 v4(88.27,157.86)
  BOTTOM w0.254: C718.1 91.31,159.16 92.39,159.16 v2(92.49,159.26) 92.87,159.26 93.57,159.96 R80026.1
1D35V_VDDQ_CPUCLK: length 9.6
  TOP w0.254: v4(88.24,167.92) 87.95,167.63 CPU1.AM40
  BOTTOM w0.201: v4(88.24,167.92) 88.7,168.38 89.42,168.38 89.43,168.37 89.81,168.37 89.82,168.38 91.33,168.38 91.34,168.37 91.72,168.37 92.44,169.09 C715.1
  BOTTOM w0.254: R705.2 94.65,170.05 94.52,170.18 v2(94.01,170.18) 93.51,170.18 93.35,170.03 C719.1 92.48,169.11 C715.1
1D35V_VGA_S0: length 141.7
  TOP w0.203: MEM1.H9 59.41,111.48 60.76,111.48 60.89,111.61 61.78,111.61 ; v4(58.41,111.68) 58.41,111.68 58.41,110.87 MEM1.K8 57.63,110.1 57.63,108.72 57.88,108.47 58.2,108.47 58.52,108.15 58.75,108.15 MEM1.N9 ; v4(58.42,96.39) 58.42,95.84 58.81,95.45 MEM2.N1 ; MEM2.K2 58.4,92.44 58.4,91.6 MEM2.H2 ; v4(51.88,112.27) 51.91,112.27 52.1,112.46 52.82,112.46 53.2,112.08 MEM1.H2
  TOP w0.305: MEM2.H2 58.01,91.21 v4(57.61,90.81) ; MEM1.E9 58.81,114.29 59.33,113.78 59.33,113.72 59.59,113.45 v4(59.59,113.45) ; v4(51.6,87.31) 51.69,87.22 MEM2.C9 ; MEM2.C1 59.18,87.22 v4(59.36,87.4) 60.14,88.18 60.14,88.53 v3(60.16,88.55) ; v4(51.71,96.82) 51.71,96.82 MEM2.R9 ; v4(57.61,86.01) 57.61,86.01 MEM2.B2 MEM2.A1 ; v4(52.81,92.42) 52.81,92.42 MEM2.K8 ; v4(57.63,88.43) 57.63,88.41 MEM2.D2 ; MEM2.N9 51.94,95.7 v4(51.75,95.7) ; v4(58.42,96.39) 58.81,96.78 MEM2.R1 ; MEM2.H9 52.23,91.22 52.05,91.04 ; v4(52.82,87.62) 52.41,88.02 MEM2.D9 MEM2.E9 51.9,89.33 v4(50.83,89.33) ; GPU1.L13 GPU1.L12 78.6,96.51 v4(78.25,96.16) 78.6,95.81 GPU1.L11 ; v4(52.5,84.77) 52.56,84.77 53.21,85.43 MEM2.A8 ; v4(57.61,93.22) 57.61,93.22 MEM2.K2 ; v4(54.51,90.76) 54.35,90.76 MEM2.G7 ; MEM1.H9 58.81,112.08 v4(58.41,111.68)
  TOP w0.356: MEM1.R1 52.1,106.79 v4(51.89,106.79) ; MEM1.G7 57.2,112.88 v4(56.81,113.27) ; v4(77.4,94.41) 77.8,94.01 GPU1.K9 ; v4(77.4,94.41) 77.01,94.8 GPU1.J10 ; v4(77.4,94.41) 77,94.01 GPU1.J9 ; v4(77.4,94.41) 77.79,94.8 GPU1.K10 ; v4(59.36,90.75) 59.36,90.16 MEM2.F1 ; v4(50.89,90.93) 51.94,90.93 52.05,91.04 ; GPU1.H19 76.2,101.76 v4(76.58,101.38) ; GPU1.K23 77.8,105.21 v4(77.41,105.6) ; MEM1.F1 51.81,113.68 v4(51.78,113.65) ; MEM1.D9 58.81,115.28 v4(58.41,114.89) 58.81,114.49 MEM1.E9 ; v4(57.62,117.28) 58.01,117.67 MEM1.A8 ; v4(58.45,110.08) 58.42,110.08 MEM1.K8 ; v4(77.41,105.6) 77.01,105.2 GPU1.J23 ; v4(77.41,105.6) 77.8,105.99 GPU1.K24 ; v4(77.41,105.6) 77.01,106 GPU1.J24 ; GPU1.H13 76.2,97.04 75.93,97.31 75.93,97.38 v4(75.88,97.43) ; v4(75.87,99.95) 75.87,99.73 GPU1.H16 ; MEM1.C9 59.16,116.08 59.35,115.89 v4(60.06,115.89) ; MEM1.K2 v4(53.61,110.08) ; MEM1.N9 59.23,107.67 v4(59.32,107.67) 59.32,106.99 MEM1.R9 59.2,106.1 v4(59.22,106.1) ; MEM1.N1 52.35,108.08 52.21,108.23 51.62,108.23 v4(51.61,108.24) ; GPU1.L22 78.6,104.06 v4(78.09,103.55) 78.18,103.55 78.32,103.4 GPU1.L21 ; v4(78.08,102.53) 78.12,102.53 78.25,102.4 GPU1.L20
  TOP w0.381: v4(50.89,90.93) 49.53,90.93 C489.1 ; v4(50.83,89.33) 49.75,88.25 C1853.1
  TOP w0.508: v4(59.59,113.45) 59.64,113.45 59.89,113.7 61.31,113.7 61.79,113.22 61.79,112.77 61.78,112.76 61.78,108.44 60.9,107.56 60.9,106.52 60.48,106.1 v4(59.22,106.1) ; 81.66,70.87 PT8501.1 ; PT8501.1 82.71,69.81 ; PT8501.1 82.71,71.92 ; PT8501.1 83.76,70.87 ; v3(75.85,116.31) 76.73,116.31 R1200.1 R1890.1
  L3 w0.508: v4(59.4,118.31) 59.4,118.09 58.59,117.28 v4(57.62,117.28) 58.23,116.67 58.23,115.07 v4(58.41,114.89) 59.37,115.84 60.01,115.84 v4(60.06,115.89)
  L4 w0.254: v4(59.36,87.4) 58.83,87.93 58.13,87.93 v4(57.63,88.43)
  L4 w0.305: v4(57.61,90.81) 58.11,91.31 58.81,91.31 v4(59.36,90.75)
  BOTTOM w0.152: MEM4.E9 58.76,88.87 58.48,88.87 58.18,89.18 57.87,89.18 57.63,88.94 v4(57.63,88.43)
  BOTTOM w0.203: MEM3.H2 57.63,111.7 57.06,111.7 56.81,111.95 v4(56.81,113.27) ; v4(54.51,90.76) 54.51,91.27 54.17,91.6 53.6,91.6 MEM4.H2 ; v4(57.61,93.22) 57.61,94.56 57.89,94.84 58.17,94.84 58.55,95.22 MEM2.N1 ; MEM1.K8 58.01,110.62 58.41,111.02 v4(58.41,111.68) ; MEM4.H2 52.81,91.63 v4(52.81,92.42) ; MEM4.H2 52.81,90.81 51.93,90.81 ; MEM3.H9 52.81,112.47 53.61,112.47 MEM3.G7
  BOTTOM w0.229: MEM2.N1 58.81,95.45 58.42,95.84 58.42,96.18 58.42,96.19 v4(58.42,96.39)
  BOTTOM w0.305: 59.23,88.41 59.22,88.41 MEM4.E9 ; 59.23,88.41 58.84,88.02 MEM4.D9 ; 59.23,88.41 60.02,88.41 v3(60.16,88.55) 60.59,88.99 60.59,89.04 60.93,89.38 ; v4(57.61,90.81) 57.61,90.81 MEM4.G7 ; MEM1.R1 52.2,106.48 v4(51.89,106.79) ; MEM1.N1 52.25,108.24 v4(51.61,108.24) ; MEM2.K8 52.81,92.42 v4(52.81,92.42) ; MEM2.K2 58.01,92.82 v4(57.61,93.22) ; v4(59.36,90.75) 58.89,91.22 MEM4.H9 ; MEM2.C1 59.18,87.22 v4(59.36,87.4)
  BOTTOM w0.356: MEM1.K2 v4(53.61,110.08) ; v4(57.61,86.01) 58,85.62 MEM4.A8 ; MEM1.K8 58.42,110.08 v4(58.45,110.08) ; 61.88,95.76 61.5,96.14 60.06,96.14 59.39,96.82 MEM2.R1 58.81,96.78 v4(58.42,96.39) ; MEM1.R9 58.84,106.48 v4(59.22,106.1) ; MEM3.E9 52.41,114.54 52.06,114.89 52,114.89 v4(51.99,114.9) 51.99,114.9 52.37,115.28 MEM3.D9 ; v4(59.4,118.31) 59.4,118.2 58.88,117.68 MEM3.A1 ; v4(59.59,113.45) 59.36,113.68 MEM3.F1 ; MEM1.C9 58.84,116.06 59.17,116.06 59.34,115.89 v4(60.06,115.89) ; MEM1.N9 59.23,107.67 v4(59.32,107.67) ; MEM3.H9 52.08,112.08 51.89,112.27 v4(51.88,112.27) ; MEM3.B2 v4(57.62,117.28) ; MEM3.H2 v4(58.41,111.68) ; v4(52.45,118.56) 52.5,118.56 53.21,117.85 MEM3.A8 ; MEM3.D2 58.02,115.28 v4(58.41,114.89) ; MEM1.C1 52.3,116.08 51.98,116.4 v4(51.95,116.4)
  BOTTOM w0.381: R230.2 49.73,107.21 50.35,107.21 50.61,107.47 50.61,107.47 51.38,108.24 v4(51.61,108.24)
  BOTTOM w0.508: v4(59.36,90.75) 59.36,90.41 59.62,90.15 60.63,90.15 ; 49.18,99.19 48.65,99.71 46.81,99.71 45.77,98.68 45.77,94.62 47.59,92.81 R1924.2
  vias: v1(49.28,101.98) v2(49.81,101.93) v2(50.33,83.87) v2(62.14,101.35) v2(63.03,92.58) v2(72.68,99.57) v2(72.8,94.36) v3(50.17,118.03) v3(50.17,117.04) v3(50.17,116.17) v3(51.34,99.88) v5(50.32,105.1) v5(50.32,103.75) v5(76.11,79.12) v5(77.12,79.12) v5(78.14,79.12)
1P8V_PWR_PG: length 81
  TOP w0.102: v3(24.37,145.46) 24.29,145.54 PR8511.1 ; v3(86.9,119.76) 86.77,119.89 86.77,120.7 86.04,121.44 85.53,121.44 v1(84.36,122.61) 83.4,123.57 R1689.1
  L4 w0.127: v3(24.37,145.46) 24.89,144.95 25.26,144.95 29.37,140.84 30.85,140.84 38.09,133.6 44.18,133.6 46.89,130.9 71.75,130.9 71.75,130.9 72.06,130.9 72.51,130.45 72.56,130.45 83.72,119.29 86.43,119.29 v3(86.9,119.76)
3D3V_1D8V_VCCHDA: length 111
  TOP w0.089: v4(84.49,157.99) 84.49,157.99 84.52,158.02 85.46,158.02 86.05,157.43 86.05,155.71 CPU1.AJ19
  TOP w0.254: v4(87.54,132.08) 87.28,132.08 R1135.2 R1118.2 ; R1910.1 104.15,162.78 104.15,162.08 114.97,151.26 114.97,130.81 113.89,129.73 v3(113.89,125.54)
  L4 w0.254: v4(87.54,132.08) 87.54,130.39 89.72,128.21 106.57,128.21 107.84,126.94 112.5,126.94 v3(113.89,125.54)
  BOTTOM w0.254: v4(84.49,157.99) 84.58,157.9 86.29,157.9 C2111.1 86.58,156.84 86.56,156.84 84.7,154.98 84.7,153.12 83.97,152.4 83.97,147.33 84.51,146.79 84.51,146.3 86.05,144.76 86.05,138.49 v2(86.01,138.46) 86.01,133.6 v4(87.54,132.08)
3D3V_1D8V_VCCPGPPA: length 36.6
  TOP w0.127: CPU1.AK15 86.81,152.44 86.7,152.44 v4(86.55,152.28)
  TOP w0.254: v3(96.55,130.05) v1(95.44,130.05) 95.26,129.87 R1111.2 95.71,128.28 R1109.2
  L3 w0.203: 88.3,147.33 88.3,147.68 87.73,148.25 87.39,148.25 87.09,148.54 87.09,151.74 v4(86.55,152.28)
  L3 w0.254: v3(96.55,130.05) 97.06,130.56 99.86,130.56 100.11,130.81 100.11,133.35 98.34,135.11 98.34,138.8 90.15,146.99 88.64,146.99 88.3,147.33
3D3V_1D8V_VCCPGPPD: length 22.3
  TOP w0.254: R1108.2 79.66,135.13 v3(80.04,135.51) 80.42,135.13 R1129.2 ; CPU1.Y15 81.91,152.81 81.49,152.39 81.49,152.39 v4(81.29,152.2)
  L4 w0.254: v4(81.29,152.2) 81.83,151.66 81.83,148.48 82.17,148.14 82.17,146.4 80.58,144.81 80.58,136.04 v3(80.04,135.51)
  BOTTOM w0.254: v2(79.2,134.7) 80.02,135.51 v3(80.04,135.51)
3D3V_1D8V_VCCPSPI: length 40.2
  TOP w0.127: v4(85.53,152.24) 85.53,152.33 85.87,152.67 85.87,152.99 CPU1.AJ16
  TOP w0.254: R1128.2 R1126.2 93.23,129.51 v1(93.56,129.84) 93.76,130.05 v3(94.52,130.05)
  L4 w0.254: v4(85.53,152.24) 85.54,152.24 86.06,151.73 86.06,146.79 86.78,146.06 90.47,146.06 93,143.54 93,143.53 99.88,136.65 99.88,135.29 99.98,135.18 99.98,130.94 99.73,130.68 95.16,130.68 v3(94.52,130.05)
3D3V_AUX_EC: length 44.8
  TOP w0.203: 93.3,52.12 92.92,52.5 U4101.56 ; v5(87.41,58.67) 87.43,58.66 U4101.38 ; v3(95.31,58.04) 95.93,58.66 U4101.11 ; R79706.1 87.09,55.88 v5(87.41,55.88) 87.79,56.26 88.88,56.26 U4101.44 ; U4101.22 94.12,60.71 93.71,60.3 v3(93.71,59.79)
  TOP w0.254: v5(87.41,58.67) 87.35,58.61 PR8520.1 PR8519.1
  TOP w0.508: L9526.1 93.31,50.61 93.4,50.7 v3(93.4,51.51) 93.43,51.54 93.43,51.99 93.3,52.12
  L4 w0.381: v3(93.71,59.79) 93.71,59.74 95.31,58.14 v3(95.31,58.04)
  L4 w0.508: v5(87.41,58.67) 87.53,58.67 88.65,59.79 v3(93.71,59.79)
  BOTTOM w0.508: v3(93.4,51.51) 93.12,51.23 91.96,51.23 90.48,52.71 v2(90.48,53.04) 90.48,53.44 89.19,54.74 88.55,54.74 v5(87.41,55.88) v5(87.41,58.67) ; v3(93.71,59.79) 93.71,60.5 94.2,61 94.2,61.15 v2(94.24,61.19) 94.2,61.23 R80231.2
  BOTTOM w0.762: Q9649.D 88.07,59.97 89.31,61.21 R80230.2
  BOTTOM w1.016: v5(87.41,58.67) 87.28,58.8 Q9649.D
3D3V_AUX_S5: length 3.4
  TOP w0.254: PC4516.1 148.69,16.38 148.08,16.99 v1(148.07,16.99) 148.07,17.01 148.49,17.42 PG4506.2
3D3V_RUN_FFS: length 15.1
  TOP w0.305: 87.66,64.77 87.48,64.95 U6701.14 ; U6701.1 87.54,66.68 87.75,66.89
  TOP w0.508: 87.66,64.77 88.36,64.07 C6701.1 89.1,64.07 89.59,64.57 89.59,66.45 v3(89.82,66.67) 89.61,66.89 C6702.1 87.75,66.89
  BOTTOM w0.508: v3(83.22,66.67) 83.73,67.18 v2(86.11,67.18) 89.31,67.18 v3(89.82,66.67)
3D3V_VCCPDSW: length 97.2
  TOP w0.127: CPU1.AD18 83.47,155.12 83.47,156.16 83.51,156.2 83.51,157.15 83.33,157.32 83.33,157.85 v4(83.85,158.37) 83.85,158.03 84.31,157.57 84.78,157.57 85.03,157.82 85.38,157.82 85.85,157.35 85.85,155.61 85.86,155.61 85.86,154.59 CPU1.AJ17
  TOP w0.254: v3(105.82,144.15) 105.2,144.15 104.43,144.91 v3(104.43,145.67) 104.43,151.26 103.16,152.53 R80037.1 ; CPU1.AD17 CPU1.AD18
  TOP w0.381: R80049.1 106.47,123.77 106.47,125.45 109.21,128.19 109.21,133.52 108.87,133.86 108.87,141.29 106.02,144.15 v3(105.82,144.15)
  TOP w0.508: R80049.1 R80036.1 106.01,122.1 106.01,120.71 106.21,120.52 R80040.2 R80041.2
  BOTTOM w0.178: 89.38,157.4 91.85,157.4 92.06,157.4
  BOTTOM w0.203: 89.38,157.4 87.74,157.4 87.35,157.8 86.96,157.8 86.52,158.24 85.37,158.24 85.06,158.55 84.03,158.55 v4(83.85,158.37) ; 92.06,157.4 92.31,157.15 94.29,157.15 95.22,156.22 v2(100.31,156.22) 108.03,156.22 110.52,153.73 110.52,148.15 106.52,144.15 v3(105.82,144.15)
  BOTTOM w0.254: v3(104.43,145.67) 104.73,145.97 v2(105.57,145.97) 106.44,145.97 107.93,147.46 107.93,149.53 107.35,150.11 R80034.1
3D3V_VCCPGPPB: length 29.8
  TOP w0.127: v4(84.48,152.19) 84.68,152.39 84.98,152.39 85.41,152.81 CPU1.AG15
  TOP w0.254: R1116.2 91.6,129.57 v1(91.85,129.82) 91.85,130.18 v3(92.36,130.68)
  L4 w0.254: v3(92.36,130.68) 91.77,130.09 91.25,130.09 89.25,132.09 89.25,133.53 85.86,136.92 85.86,146.15 85,147.02 85,151.5 84.48,152.01 v4(84.48,152.19)
3D3V_VCCPGPPC: length 25.9
  TOP w0.127: v4(82.36,152.24) 82.51,152.38 82.51,152.98 82.15,153.33 CPU1.Y16
  TOP w0.254: R1123.2 79.09,133.99 C2106.1 79.43,133.31 79.43,133.38 79.64,133.58 80.45,133.58 v1(80.7,133.83) 80.7,133.88 80.14,134.44 v3(80.04,134.44)
  L3 w0.254: v4(82.36,152.24) 82.39,152.24 82.86,151.77 82.86,146.43 82.2,145.78 82.2,140.59 82.86,139.94 82.86,136.17 81.13,134.44 v3(80.04,134.44)
3D3V_VCCPGPPE: length 20.7
  TOP w0.127: CPU1.T16 80.1,153.09 80.1,152.42 v4(80.09,152.4)
  TOP w0.254: C2107.1 80.36,136.84 v3(80.04,137.16) 79.98,137.1 R1124.2
  L3 w0.254: v3(80.04,137.16) 80.65,137.77 80.65,145.9 80.7,145.94 80.7,151.84 80.13,152.4 v4(80.09,152.4)
  BOTTOM w0.254: v3(80.04,137.16) 79.81,137.16 v2(79.26,136.6)
3D3V_VCCPGPPG: length 13.5
  TOP w0.254: CPU1.AD15 83.44,152.42 v4(83.44,152.4)
  BOTTOM w0.254: R1137.2 v2(80.55,141.55) 80.55,142.77 81.03,143.26 81.03,143.79 81.67,144.42 81.67,145.47 82.13,145.92 82.13,146.83 82.18,146.88 82.18,147.47 82.9,148.18 82.9,151.85 v4(83.44,152.4)
