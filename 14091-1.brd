# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_ODT0: length 78
  TOP w0.089: v4(98.16,168.89) 97.62,168.34 94.94,168.34 94.91,168.37 94.21,168.37 94.13,168.33 93.89,168.33 CPU1.BA42
  TOP w0.165: v3(152.18,153.42) 152.04,153.42 151.91,153.54 151.91,153.89 152.04,154.02 153.38,154.02 153.75,153.65 DIMM2.116
  L4 w0.089: v4(98.16,168.89) 99.02,168.02 100.74,168.02 103.49,165.27 103.67,165.27
  L4 w0.216: 103.67,165.27 111.01,165.27 126.38,149.91 132.24,149.91 132.3,149.96 145.81,149.96 147.16,151.31 149.12,151.31 149.77,151.96 151,151.96 151.37,152.32 153.37,152.32 153.59,152.54 153.59,154.11 153.37,154.32 152.06,154.32 151.94,154.2 151.94,153.54 152.06,153.42 v3(152.18,153.42)
  BOTTOM w0.102: v3(152.18,153.42) 151.93,153.16 v2(151.93,152.58)
M_B_ODT1: length 79.6
  TOP w0.165: v4(91.53,168.83) 91.53,168.6 92.02,168.11 CPU1.AW42 ; DIMM2.120 153.27,152.45 152.79,152.93 152.3,152.93 152.13,152.76 152.13,151.79 152,151.66 151.6,151.66 151.47,151.79 151.47,152.76 151.31,152.93 150.53,152.93 150.04,153.42 v3(150.02,153.42)
  L4 w0.089: 103.22,166.76 100.64,169.34 97.49,169.34 96.76,170.08 95.23,170.08 95.03,169.88 95.03,169.03 94.83,168.83 v4(91.53,168.83)
  L4 w0.216: 103.22,166.76 112.78,166.76 114.06,165.47 114.06,165.17 113.99,165.09 113.99,164.79 114.29,164.48 114.6,164.48 114.67,164.56 114.98,164.56 115.28,164.25 115.28,163.95 115.14,163.8 115.14,163.64 115.58,163.19 115.75,163.19 115.89,163.34 116.2,163.34 116.5,163.03 116.5,162.73 116.43,162.65 116.43,162.34 116.73,162.04 117.04,162.04 117.12,162.11 117.42,162.11 117.73,161.81 117.73,161.5 117.65,161.43 117.65,161.12 117.96,160.82 118.26,160.82 118.34,160.89 118.64,160.89 127.66,151.88 137,151.88 137.02,151.85 145.66,151.85 146.85,153.03 149.64,153.03 v3(150.02,153.42)
  BOTTOM w0.102: v2(149.16,152.91) 149.51,152.91 v3(150.02,153.42)
M_B_RAS#: length 79.8
  TOP w0.089: v4(97.45,168.91) 96.86,169.5 95.21,169.5 94.89,169.17 94.23,169.17 94.1,169.21 93.89,169.21 93.85,169.2 93.27,169.06 93.25,169.05 92.65,169.05 CPU1.AW44
  TOP w0.165: v4(152.31,154.81) 152.31,154.83 152.92,155.45 DIMM2.110
  L4 w0.089: v4(97.45,168.91) 98.59,167.77 100.62,167.77 103.6,164.78 103.79,164.78
  L4 w0.216: 103.79,164.78 103.8,164.78 110.11,164.78 125.93,148.96 134.91,148.96 135.39,149.44 145.87,149.44 147.43,151 149.25,151 149.9,151.64 151.13,151.64 151.5,152.01 153.53,152.01 154.04,152.52 154.04,154.5 153.23,155.31 152.56,155.31 152.31,155.06 v4(152.31,154.81)
  BOTTOM w0.102: v4(152.31,154.81) 152.05,154.56 152.05,154.41 v2(151.8,154.15)
M_B_WE#: length 79.4
  TOP w0.089: v4(98.97,170.81) 98.33,170.18 97.95,170.18 97.84,170.07 94.98,170.07 94.96,170.05 94.9,170.05 94.85,170 93.73,170 93.38,169.65 93.33,169.65 CPU1.AY44
  TOP w0.165: v4(147.98,155.39) 147.98,154.81 147.72,154.55 DIMM2.113
  L4 w0.089: 102.65,169.29 101.7,170.24 99.54,170.24 v4(98.97,170.81)
  L4 w0.216: 102.65,169.29 114.49,169.29 115.45,168.33 115.75,168.33 116.43,169 116.73,169 117.04,168.69 117.04,168.39 116.37,167.72 116.37,167.41 116.67,167.11 116.98,167.11 117.65,167.78 117.95,167.78 118.26,167.47 118.26,167.17 117.59,166.49 117.59,166.19 117.89,165.88 118.2,165.88 118.87,166.56 119.18,166.56 119.48,166.25 119.48,165.95 118.81,165.27 118.81,164.97 119.11,164.66 119.42,164.66 120.09,165.33 120.4,165.33 120.7,165.03 120.7,164.72 120.03,164.05 120.03,163.75 120.34,163.44 120.64,163.44 121.31,164.11 121.62,164.11 121.93,163.81 121.93,163.5 121.25,162.83 121.25,162.52 121.56,162.22 121.86,162.22 122.64,162.99 122.82,162.99 123.25,162.56 123.25,162.38 122.47,161.61 122.47,161.3 123.34,160.43 125.16,160.43 130.14,155.46 132.05,155.46 132.52,155.93 138.1,155.93 138.35,155.68 147.5,155.68 147.79,155.39 v4(147.98,155.39)
  BOTTOM w0.102: v2(147.89,154.46) 147.89,155.3 v4(147.98,155.39)
M_VREF_CA_DIMMA: length 16.8
  TOP w0.33: DIMM1.126 141.03,150.65
  TOP w0.508: v4(142.15,152.4) 142.15,151.76 141.03,150.65
  BOTTOM w0.508: v4(142.15,152.4) 142.15,151.98 141.14,150.98 v2(140.39,150.98) 139.38,150.98 138.97,151.38 ; R1218.2 138.97,152.34 138.97,151.38 ; 138.97,151.38 C1201.1 C1202.1 R1219.1 C1218.1 R1217.2 R1220.1
M_VREF_CA_DIMMB: length 19.9
  TOP w0.33: v3(156.27,149.22) 155.79,149.7 155.79,150.4 155.54,150.65 DIMM2.126
  BOTTOM w0.508: v3(156.27,149.22) 155.61,149.22 155.04,148.65 C1309.1 C1308.1 C1306.1 154.13,145.52 151.13,145.52 150.26,146.39 149.74,146.39 149.69,146.34 145.79,146.34 v2(144.99,147.14) 144.11,148.02 R1217.1
M_VREF_DQ_DIM0: length 49.6
  TOP w0.305: v4(93.08,184.1) 93.27,183.92 CPU1.AY68
  TOP w0.508: v3(97.82,193.68) 97.82,194.56 99.07,195.81 102.52,195.81 103.69,196.98 127.75,196.98 v3(128.52,196.22)
  BOTTOM w0.508: R1215.1 C1256.1 128.6,194.5 v2(127.95,195.15) 127.95,195.65 v3(128.52,196.22) ; v4(93.08,184.1) 93.57,184.59 v2(93.57,185.24) 93.57,187.33 95.09,188.85 95.92,188.85 97.82,190.75 v3(97.82,193.68)
M_VREF_DQ_DIM1: length 64.1
  TOP w0.089: CPU1.BA67 94.26,183.2 94.42,183.25 94.61,183.44 94.61,183.81 94.8,184 94.8,184.09 v4(95.22,184.5)
  TOP w0.508: v3(98.84,193.68) 98.84,194.14 99.67,194.97 103.08,194.97 104.07,195.96 127.33,195.96 128.01,195.28 134.2,195.28 136.06,193.43 140.78,193.43 142.78,195.43 v3(142.78,195.71)
  BOTTOM w0.508: R1305.1 C1328.1 142.67,194.63 v2(142.45,194.84) 142.45,195.38 v3(142.78,195.71) ; v3(98.84,193.68) 98.84,190.33 96.34,187.83 95.9,187.83 95.5,187.44 v2(95.5,186) 95.5,184.79 v4(95.22,184.5)
M_VREF_DQ_DIMMA: length 14.1
  TOP w0.33: DIMM1.1 131.88,190.55 132.75,191.42 v4(132.75,191.77)
  BOTTOM w0.508: R1213.1 C1204.1 C1206.1 R1215.2 ; R1213.1 133.45,192.6 C1205.1 ; R1213.1 132.37,192.15 v4(132.75,191.77) 132.75,191.26 133.07,190.94 136.87,190.94 v2(137.29,191.36) 137.45,191.52 R1212.2
M_VREF_DQ_DIMMB: length 10
  TOP w0.33: DIMM2.1 148.01,190.55 v4(148.5,191.04)
  BOTTOM w0.508: R1304.2 R1305.2 143.86,192.66 144.88,192.66 R1307.1 C1302.1 C1310.1 147.67,192.72 C1305.1 147.86,191.92 147.56,191.62 v2(147.56,191.19) 147.7,191.04 v4(148.5,191.04)
MAA0: length 56.9
  TOP w0.102: GPU1.K17 78.14,100.6 78.26,100.47 78.26,100.15 78.14,100.03 v4(77.99,100.03) ; v4(56.58,95.37) 56.58,95.09 56.69,94.99 56.98,94.99 MEM2.N3 ; v1(61.04,102.66) 60.29,102.66 v4(60.2,102.57) ; MEM1.N3 54.2,108.08 54.67,108.55 55.42,108.55 v4(55.61,108.36)
  L3 w0.127: v4(77.99,100.03) 77.99,100.15 77.65,100.49 76.79,100.49 76.66,100.61 76.21,100.61 76.08,100.49 75.47,100.49 75.24,100.72 74.83,100.72 74.71,100.84 74.38,100.84 74.25,100.72 73.82,100.72 73.5,101.03 73.5,101.4 73.37,101.53 73.12,101.53 72.99,101.4 72.99,101.03 72.85,100.89 71.6,100.89 71.38,101.11 68.73,101.11 68.31,101.53 66.69,101.53 66.56,101.4 66.56,100.99 66.43,100.87 66.18,100.87 66.05,100.99 66.05,101.6 65.92,101.73 65.67,101.73 65.54,101.6 65.54,100.99 65.42,100.87 65.16,100.87 65.04,100.99 65.04,101.58 64.91,101.71 64.65,101.71 64.53,101.58 64.53,100.99 64.4,100.87 64.15,100.87 64.02,100.99 64.02,101.55 63.89,101.68 63.64,101.68 63.51,101.55 63.51,100.99 63.38,100.87 63.13,100.87 63,100.99 63,101.38 62.88,101.51 61.98,101.51 61.57,101.92 61.57,102.52 61.45,102.65 61.09,102.65 60.97,102.52 60.97,102.14 60.84,102.01 60.2,102.01 60.08,102.14 60.08,102.44 v4(60.2,102.57)
  L4 w0.127: v4(56.58,95.37) 56.46,95.49 56.46,96.2 57.59,97.33 57.59,98.14 59.83,100.38 60.14,100.38 60.42,100.66 60.42,101.28 60.23,101.47 60.23,102.01 60.36,102.14 60.64,102.14 60.77,102.27 60.77,102.44 60.64,102.57 v4(60.2,102.57) 60.23,102.59 60.23,105.45 60.71,105.94 60.71,106.95 60.45,107.21 57.56,107.21 56.67,108.09 56.63,108.09 56.36,108.36 v4(55.61,108.36)
  BOTTOM w0.102: v4(56.58,95.37) 56.33,95.62 54.53,95.62 54.13,95.22 MEM4.N3 ; v4(55.61,108.36) 55.76,108.51 56.1,108.51 56.76,107.85 56.98,107.85 MEM3.N3
MAA1: length 51
  TOP w0.102: v4(75.75,103.51) 76.15,103.51 76.19,103.47 76.2,103.47 76.67,103 GPU1.J20 ; v4(55.33,96.95) 55.12,96.95 54.2,96.02 MEM2.P7 ; v4(55.94,106.4) 55.94,106.9 56.32,107.28 MEM1.P7
  L3 w0.127: v4(75.75,103.51) 75.3,103.95 74.55,103.95 74.51,103.99 71.35,103.99 71.34,103.98 70.86,103.98 70.68,104.17 64.76,104.17 64.62,104.03 59.66,104.03 59.28,103.66 57.71,103.66 57.58,103.79 55.65,103.79 55.64,103.79 55.3,103.79 55.29,103.79 55.23,103.79 55.02,103.58 55.02,103.23 54.07,102.28 52.85,102.28 52.62,102.5 52.62,103.11 v3(52.86,103.34)
  L4 w0.127: v4(55.33,96.95) 54.14,98.14 54.14,101.6 52.86,102.88 v3(52.86,103.34) 52.44,103.76 52.44,105.33 53.05,105.94 53.05,106.32 53.66,106.93 54.07,106.93 54.17,107.03 54.17,107.31 54.27,107.41 54.62,107.41 54.72,107.31 54.72,107.07 54.97,106.83 55.22,106.83 55.64,106.4 v4(55.94,106.4)
  BOTTOM w0.102: v4(55.33,96.95) 55.7,96.58 56.42,96.58 56.98,96.02 MEM4.P7 ; MEM3.P7 54.51,107.28 54.97,106.82 55.08,106.82 55.08,106.82 55.38,106.82 55.8,106.4 v4(55.94,106.4) ; v3(52.86,103.34) 52.19,103.34 v2(52.04,103.5)
MAA2: length 56
  TOP w0.102: MEM2.P3 57.05,96.18 56.63,96.18 56.24,96.58 55.91,96.58 55.82,96.67 55.82,96.82 v4(56.04,97.03) ; v4(55.14,107.24) 54.96,107.43 54.67,107.43 54.58,107.33 54.58,107.15 54.47,107.05 54.25,107.05 MEM1.P3 ; v4(76.48,104.73) 76.48,104.92 GPU1.H23
  L3 w0.127: v4(58.01,104.12) 58.24,103.89 58.98,103.89 59.39,104.3 59.39,104.91 59.52,105.03 59.82,105.03 59.95,104.91 59.95,104.45 60.08,104.32 60.33,104.32 60.46,104.45 60.46,104.92 60.58,105.04 60.84,105.04 60.97,104.92 60.97,104.46 61.09,104.33 61.43,104.33 61.52,104.42 61.52,104.92 61.65,105.04 61.87,105.04 62,104.92 62,104.69 62.24,104.45 64.57,104.45 64.62,104.5 64.98,104.5 65.11,104.63 65.11,105.09 65.24,105.22 65.49,105.22 65.62,105.09 65.62,104.63 65.74,104.5 66,104.5 66.12,104.63 66.12,105.09 66.25,105.22 66.51,105.22 66.63,105.09 66.63,104.63 66.76,104.5 67.01,104.5 67.14,104.63 67.14,105.09 67.27,105.22 67.52,105.22 67.65,105.09 67.65,104.63 67.78,104.5 68.03,104.5 68.16,104.63 68.16,105.09 68.28,105.22 68.54,105.22 68.66,105.09 68.66,104.63 68.79,104.5 70.51,104.5 70.85,104.84 71.56,104.84 71.68,104.71 71.68,104.45 71.81,104.32 72.34,104.32 72.47,104.45 72.47,104.71 72.6,104.84 73.26,104.84 73.39,104.71 73.39,104.36 73.51,104.23 74.47,104.23 74.48,104.22 74.61,104.22 74.65,104.18 75.62,104.18 75.81,103.99 76.3,103.99 76.61,104.31 76.61,104.6 v4(76.48,104.73)
  L4 w0.127: v4(55.14,107.24) 55.56,106.82 56.9,106.82 57.21,106.52 57.21,106.29 57.08,106.16 56.31,106.16 56.18,106.03 56.18,105.78 56.36,105.6 57.87,105.6 58,105.47 58,105.15 57.87,105.02 57.55,105.02 57.42,104.9 57.42,104.37 57.68,104.12 v4(58.01,104.12) 58.01,103.88 58.99,102.9 58.99,100.6 56.82,98.43 56.82,97.82 v4(56.04,97.03)
  BOTTOM w0.102: MEM4.P3 54.81,96.82 54.81,97 55.16,97.35 55.72,97.35 v4(56.04,97.03) ; v4(55.14,107.24) 55.26,107.24 55.68,106.83 56.67,106.83 57.12,107.28 MEM3.P3 ; v4(58.01,104.12) 58.28,103.85 58.41,103.85 v2(58.64,103.62)
MAA3: length 60.5
  TOP w0.102: v4(55.35,96.05) 55.86,95.68 56.19,95.68 56.48,95.78 56.8,95.78 MEM2.N2 ; GPU1.G23 75.05,104.85 v4(75,104.85) ; v4(55.77,107.34) 55.46,107.65 52.91,107.65 52.79,107.78 52.79,108.42 52.91,108.55 53.5,108.55 53.63,108.42 53.63,108.21 53.5,108.08 MEM1.N2
  L3 w0.127: v4(75,104.85) 74.51,105.34 71.96,105.34 71.91,105.39 69.81,105.39 69.19,106 68.74,106 68.39,106.35 67.95,106.35 67.55,105.95 64.62,105.95 64.5,105.83 64.5,105.63 64.13,105.27 62.7,105.27 62.4,105.57 61.42,105.57 61.29,105.69 61.29,105.82 61.16,105.95 60.91,105.95 60.78,105.82 60.78,105.69 60.65,105.57 60.4,105.57 60.27,105.69 60.27,105.82 60.15,105.95 59.89,105.95 59.76,105.82 59.76,105.69 59.64,105.57 58.14,105.57 58.01,105.69 58.01,106.23 57.89,106.35 56.73,106.35 56.6,106.23 56.6,105.57 56.98,105.19 57.79,105.19 57.92,105.06 57.92,104.89 58.05,104.76 58.52,104.76 v4(58.65,104.89)
  L4 w0.127: v4(55.35,96.05) 55.84,96.54 56.13,96.54 57.05,97.45 57.05,98.24 59.22,100.41 59.22,103 58.65,103.57 v4(58.65,104.89) 58.34,104.89 58.23,105 58.23,105.5 58.34,105.61 59.52,105.61 59.64,105.74 59.64,106.45 59.42,106.67 57.38,106.67 56.74,107.31 55.8,107.31 v4(55.77,107.34)
  BOTTOM w0.102: v4(75,104.85) 74.73,104.85 v2(74.23,105.35) ; MEM3.N2 58.23,108.08 58.24,108.08 58.36,108.08 58.48,108.21 58.48,108.22 58.63,108.36 58.63,108.58 58.53,108.68 58.28,108.68 58.15,108.55 57.84,108.55 57.56,108.26 57.56,107.92 57.59,107.89 57.59,107.74 57.46,107.61 56.76,107.61 56.63,107.49 56.63,107.13 56.53,107.03 55.9,107.03 55.77,107.16 v4(55.77,107.34) ; v4(55.35,96.05) 54.6,96.05 54.2,95.64 53.64,95.64 MEM4.N2
MAA4: length 55.3
  TOP w0.102: MEM2.P8 53.48,96.02 53.9,96.45 54.17,96.45 55.49,97.76 v4(55.49,97.87) ; v4(56.01,105.36) 55.96,105.41 55.96,105.68 55.96,105.68 55.96,105.82 56.08,105.94 56.38,105.94 56.73,106.3 56.73,106.42 56.44,106.72 56.44,106.86 56.64,107.06 56.83,107.06 57.04,106.85 58.06,106.85 58.16,106.95 58.16,107.14 MEM1.P8 ; GPU1.G24 75.01,105.61 75.01,105.56 v4(75,105.55)
  L3 w0.127: v3(53.78,103.77) 53.78,105.78 53.91,105.91 55.34,105.91 55.36,105.92 56.24,105.92 56.37,106.05 56.37,106.46 56.49,106.58 59.67,106.58 59.8,106.46 59.8,106.3 59.92,106.18 62.4,106.18 62.49,106.08 62.62,105.96 62.62,105.8 62.74,105.67 63.96,105.67 64.09,105.8 64.09,106.25 64.2,106.36 67.39,106.36 67.51,106.49 67.51,106.74 67.51,106.74 67.51,107.14 67.64,107.26 68.05,107.26 68.91,106.41 69.19,106.41 69.93,105.67 73.76,105.67 73.82,105.6 74.17,105.6 74.24,105.67 74.88,105.67 v4(75,105.55)
  L4 w0.127: v4(55.49,97.87) 54.6,98.76 54.6,102.33 54.54,102.39 54.54,102.39 53.78,103.16 v3(53.78,103.77) 53.78,105.52 54.4,106.14 54.7,106.14 54.93,105.91 54.94,105.91 54.95,105.91 55.3,105.91 55.38,105.99 55.85,105.99 55.95,105.88 55.95,105.41 v4(56.01,105.36)
  BOTTOM w0.102: v4(75,105.55) 75,105.59 74.3,106.29 v2(74.3,106.76) ; MEM4.P8 57.61,96.43 57.14,96.43 56.54,97.03 56.54,97.11 56.17,97.47 56.09,97.47 55.69,97.87 v4(55.49,97.87) ; v4(56.01,105.36) 55.8,105.15 55.42,105.15 55.35,105.08 54.97,105.08 54.74,105.32 54.74,105.35 54.63,105.46 54.63,106.34 54.13,106.83 53.67,106.83 MEM3.P8
MAA5: length 56.9
  TOP w0.102: v4(75.77,105.59) 75.79,105.59 GPU1.H24 ; MEM1.P2 52.98,107.04 52.98,106.93 53.07,106.83 54.94,106.83 55.12,106.64 v4(55.12,106.32) ; MEM2.P2 58.01,96.31 57.85,96.47 56.75,96.47 56.55,96.67 56.55,97.35 56.4,97.5 56.4,97.74 v4(56.26,97.88) ; v4(53.65,102.7) 54.24,102.11 v1(54.24,102.11)
  L3 w0.127: v4(75.77,105.59) 75.42,105.24 75.42,104.67 75.17,104.43 74.83,104.43 74.47,104.78 74.47,104.82 74.23,105.07 69.73,105.07 69.1,105.69 67.87,105.69 67.72,105.55 64.99,105.55 64.3,104.86 62.41,104.86 61.98,105.29 59.29,105.29 59.1,105.1 59.1,104.75 58.77,104.42 58.3,104.42 58.19,104.54 57.85,104.54 57.63,104.75 57.25,104.75 56.91,104.41 56.56,104.41 56.08,104.89 54.92,104.89 54.67,104.64 54.67,104.07 54.18,103.58 54.18,103.23 v4(53.65,102.7)
  L4 w0.127: v4(55.12,106.32) 54.93,106.52 53.86,106.52 53.45,106.1 53.45,105.4 53.32,105.28 52.9,105.28 52.77,105.15 52.77,104.92 52.9,104.79 53.32,104.79 53.45,104.67 53.45,104.46 53.32,104.34 52.9,104.34 52.77,104.21 52.77,104.01 52.9,103.88 53.2,103.88 53.32,103.75 53.32,102.82 53.45,102.7 v4(53.65,102.7) 54.37,101.97 54.37,98.67 55.07,97.97 55.07,97.7 55.32,97.45 55.66,97.45 55.67,97.46 55.79,97.46 56.21,97.88 v4(56.26,97.88)
  BOTTOM w0.102: MEM4.P2 53.64,96.45 54.11,96.45 54.51,96.85 54.51,97.17 54.68,97.34 54.68,97.64 55.32,98.28 55.86,98.28 v4(56.26,97.88) ; MEM3.P2 57.6,106.86 57.04,106.86 56.16,105.98 55.47,105.98 v4(55.12,106.32)
MAA6: length 65.3
  TOP w0.102: v4(54.6,103.4) 54.61,103.42 54.77,103.42 55.16,103.81 56.74,103.81 v1(57.39,103.15) 57.92,103.68 58.46,103.68 58.59,103.81 58.59,104.08 58.42,104.26 58.42,104.29 58.18,104.52 57.91,104.52 57.59,104.85 57.59,106.05 MEM1.R8 ; GPU1.J19 77.09,101.71 77.34,101.71 77.47,101.83 77.47,102.26 77.34,102.38 v4(77.12,102.38) ; v4(55.37,100.15) 55.48,100.04 55.48,99.78 54.84,99.14 54.68,99.14 54.53,99.29 54.37,99.29 54.25,99.17 54.25,99 54.4,98.85 54.4,98.71 54.26,98.56 54.12,98.56 53.94,98.74 53.77,98.74 53.65,98.63 53.65,98.46 53.83,98.28 53.83,98.13 53.64,97.94 53.64,96.47 53.5,96.33 53.34,96.33 53.21,96.46 MEM2.R8
  L3 w0.127: v4(55.86,102.08) 55.83,102.08 55.7,102.2 55.7,102.58 55.83,102.7 56.49,102.7 56.88,103.1 59.56,103.1 59.79,103.34 60.83,103.34 60.83,103.33 61.05,103.11 61.45,103.11 61.67,103.34 61.93,103.34 62.06,103.21 62.06,102.11 62.19,101.98 62.48,101.98 62.61,102.11 62.61,103.24 62.74,103.37 63.24,103.37 63.37,103.24 63.37,102.66 63.49,102.54 65.32,102.54 65.46,102.67 65.46,102.93 65.59,103.05 65.97,103.05 66.1,102.93 66.1,102.73 66.3,102.53 67.33,102.53 67.49,102.37 73.46,102.37 73.74,102.09 74.07,102.09 74.3,102.32 74.58,102.32 74.81,102.09 75.25,102.09 75.55,101.78 75.94,101.78 76.25,102.09 76.89,102.09 77.12,102.32 v4(77.12,102.38)
  L4 w0.127: v4(55.37,100.15) 55.37,101.01 55.86,101.49 v4(55.86,102.08) 55.86,102.27 55.13,103 55.01,103 54.61,103.4 v4(54.6,103.4)
  BOTTOM w0.102: MEM3.R8 52.92,106.48 52.82,106.38 52.82,105.32 52.72,105.22 51.85,105.22 51.72,105.09 51.72,104.79 51.85,104.66 52.73,104.66 52.87,104.52 52.87,104.05 53.47,103.44 53.47,103.14 53.21,102.89 53.21,102.38 53.34,102.25 54.09,102.25 54.09,102.27 54.25,102.43 54.25,102.73 54.58,103.06 54.58,103.38 v4(54.6,103.4) ; MEM4.R8 57.67,96.82 57.57,96.92 57.57,98.18 57.84,98.44 58.02,98.44 58.15,98.57 58.15,98.78 58.02,98.9 57.22,98.9 57.09,99.03 57.09,99.21 57.22,99.33 58.07,99.33 58.2,99.46 58.2,99.9 58.07,100.03 57.03,100.03 56.72,99.72 56.27,99.72 55.9,100.09 55.43,100.09 v4(55.37,100.15)
MAA7: length 61.6
  TOP w0.102: MEM2.R2 57.75,96.82 57.65,96.92 57.65,98.12 57.75,98.22 58.23,98.22 58.33,98.32 58.33,98.65 58.23,98.75 57.62,98.75 57.52,98.85 57.52,99.18 57.62,99.28 58.16,99.28 58.27,99.4 58.27,100.93 v1(58.35,101.02) 56.71,101.02 56.7,101 v4(56.65,101) ; GPU1.K19 77.81,101.8 77.93,101.67 77.93,101.35 77.81,101.22 v4(77.36,101.22) ; MEM1.R2 53.54,106.15 53.54,105.52 53.35,105.33 53.35,103.59 53.95,103 55.09,103 v4(55.47,103.38)
  L3 w0.127: v4(77.36,101.22) 77.77,101.22 77.9,101.35 77.9,101.68 77.61,101.96 77.25,101.96 77.09,101.8 76.29,101.8 76,101.52 75.47,101.52 75.2,101.78 74.94,101.78 74.81,101.66 74.81,101.41 74.68,101.29 74.44,101.29 74.3,101.43 74.3,101.72 74.17,101.85 73.52,101.85 73.23,102.14 72.79,102.14 72.66,102.01 72.66,101.24 72.55,101.12 72.27,101.12 72.16,101.24 72.16,102.01 72.03,102.14 70.94,102.14 70.75,101.95 70.51,101.95 70.32,102.14 68.69,102.14 68.41,101.86 67.52,101.86 67.18,102.2 66.94,102.2 66.62,101.87 66.41,101.87 65.88,102.4 65.69,102.4 65.33,102.04 64.8,102.04 64.65,102.18 64.21,102.18 64,101.97 63.64,101.97 63.43,102.18 62.98,102.18 62.85,102.06 62.85,101.86 62.72,101.74 62.08,101.74 61.8,102.01 61.8,102.61 61.8,102.75 61.68,102.87 60.81,102.87 60.69,102.99 59.9,102.99 59.79,102.87 58.07,102.87 57.82,102.63 57.54,102.63 57.29,102.87 57.02,102.87 56.92,102.77 v4(56.92,102.2)
  L4 w0.127: v4(55.47,103.38) 55.64,103.38 56.05,103.78 56.39,103.78 56.92,103.26 v4(56.92,102.2) 56.98,102.2 57.1,102.08 57.1,101.13 56.98,101 56.66,101 v4(56.65,101)
  BOTTOM w0.102: MEM4.R2 53.61,97.21 53.61,99.14 54.76,100.3 54.76,100.4 55.12,100.76 55.22,100.76 55.69,101.23 56.13,101.23 56.32,101.04 56.46,101.04 56.5,101 v4(56.65,101) ; MEM3.R2 57.67,106.48 57.57,106.38 57.57,105.31 57.67,105.2 58.08,105.2 58.18,105.1 58.18,104.75 58.08,104.65 57.97,104.65 57.61,104.29 57.61,104.17 57.16,103.73 57.04,103.73 56.94,103.63 56.94,103.14 56.63,102.84 55.79,102.84 55.66,102.71 55.43,102.71 55.22,102.91 55.22,103.07 55.47,103.32 v4(55.47,103.38)
MAA8: length 61.2
  TOP w0.102: v4(76.71,98.81) 77.04,98.81 77.17,98.68 77.17,98.33 77.04,98.2 GPU1.J14 ; v4(56.22,103.37) 56.49,103.1 56.49,102.92 56.74,102.67 57.09,102.67 57.16,102.6 57.63,102.6 57.68,102.65 58.96,102.65 59.15,102.84 59.15,105.03 58.85,105.33 58.36,105.33 MEM1.T8 ; MEM2.T8 53.21,98.65 53.11,98.75 52.75,98.75 52.64,98.85 52.64,99.08 52.75,99.18 53.11,99.18 53.21,99.28 53.21,99.69 53.34,99.82 54.55,99.82 54.68,99.94 54.68,101.01 54.78,101.11 55.16,101.11 55.26,101.01 55.26,100.87 55.4,100.74 55.78,100.74 v4(55.86,100.82)
  L3 w0.127: v4(56.32,101.64) 56.44,101.76 56.95,101.76 57.07,101.64 57.07,101.1 57.17,101.01 57.63,101.01 57.75,101.13 57.75,101.23 58.14,101.61 58.14,102.01 58.3,102.17 58.83,102.17 58.97,102.03 58.97,101.41 58.85,101.29 58.5,101.29 58.27,101.06 58.27,100.71 58.4,100.58 60.94,100.58 62.09,99.43 62.47,99.43 62.75,99.16 63.27,99.16 63.55,99.43 64.15,99.43 64.25,99.33 67.09,99.33 67.22,99.2 67.22,98.68 67.35,98.56 67.69,98.56 67.83,98.7 67.83,99.59 67.96,99.72 69.77,99.72 69.9,99.59 69.9,99.15 70.02,99.02 71.67,99.02 72.08,99.43 72.54,99.43 73.5,98.47 74.4,98.47 74.59,98.28 76.56,98.28 76.71,98.44 v4(76.71,98.81)
  L4 w0.127: v4(56.22,103.37) 56.22,102.31 56.32,102.21 v4(56.32,101.64) 56.23,101.56 56.23,100.92 56.14,100.82 v4(55.86,100.82)
  BOTTOM w0.102: v4(56.22,103.37) 56.42,103.37 56.55,103.49 56.55,103.68 56.42,103.81 54.63,103.81 54.42,104.02 54.14,104.02 53.9,104.27 53.9,104.54 53.72,104.72 52.98,104.72 52.86,104.84 52.86,105.01 52.98,105.13 53.45,105.13 53.57,105.25 53.57,105.55 53.45,105.68 MEM3.T8 ; v4(55.86,100.82) 55.93,100.82 56.16,100.59 56.86,100.59 56.93,100.66 56.93,100.66 57.25,100.98 58.14,100.98 v2(58.59,100.53) 58.59,99.9 58.69,99.8 58.86,99.8 58.96,99.69 58.96,99.49 58.86,99.39 58.52,99.39 58.4,99.27 58.4,99.1 58.52,98.98 59.02,98.98 59.14,98.86 59.14,98.7 59.02,98.58 58.69,98.58 58.59,98.48 58.59,98.19 MEM4.T8
MAA9: length 53.1
  TOP w0.102: MEM1.R3 54.15,106.61 54.55,106.61 54.65,106.51 54.65,106.12 54.85,105.92 54.87,105.92 55.14,105.64 v4(55.14,105.49) ; MEM2.R3 57.21,97.15 57.11,97.25 56.93,97.25 56.82,97.35 56.82,97.72 57.09,97.99 57.09,99.1 56.99,99.21 56.71,99.21 56.44,98.94 v4(56.44,98.69) ; GPU1.K14 77.5,98.2 77.39,98.09 v4(77.39,97.77)
  L3 w0.127: v4(58.56,101.75) 58.53,101.73 58.53,101.69 58.36,101.52 58.36,101.47 58.02,101.13 58.02,100.47 58.15,100.35 60.85,100.35 61.99,99.2 62.38,99.2 62.66,98.93 62.99,98.93 63.12,98.8 63.12,98.37 63.24,98.24 63.52,98.24 63.64,98.37 63.64,99.06 63.77,99.19 64.02,99.19 64.15,99.06 64.15,98.46 64.27,98.33 64.53,98.33 64.66,98.46 64.66,98.88 64.77,99 65.04,99 65.16,98.88 65.16,98.46 65.29,98.33 65.54,98.33 65.67,98.46 65.67,98.86 65.81,99 66.71,99 66.89,98.82 66.89,98.55 67.21,98.23 67.68,98.23 67.68,98.23 67.87,98.23 67.96,98.32 67.96,98.51 68.22,98.76 68.42,98.76 68.55,98.64 68.55,98.29 68.67,98.16 68.93,98.16 69.05,98.29 69.05,98.52 69.18,98.65 69.55,98.65 69.7,98.8 71.9,98.8 72.01,98.91 72.01,99.04 72.16,99.19 72.46,99.19 72.72,98.93 72.72,98.62 72.8,98.54 73.11,98.54 73.41,98.24 74.31,98.24 74.5,98.05 74.99,98.05 75.14,97.9 75.51,97.9 75.66,98.05 75.96,98.05 76.11,97.9 76.56,97.9 76.75,98.09 77.07,98.09 v4(77.39,97.77)
  L4 w0.127: v4(56.44,98.69) 56.46,98.69 58.56,100.78 v4(58.56,101.75) 58.51,101.79 58.51,102.96 57.16,104.31 57.16,105.01 56.91,105.25 56.57,105.25 56.25,104.94 55.83,104.94 55.29,105.49 v4(55.14,105.49)
  BOTTOM w0.102: v4(56.44,98.69) 56.32,98.69 56.12,98.9 55.92,98.9 55.63,99.18 55.29,99.18 55.2,99.09 55.17,99.09 54.93,98.85 54.93,98.82 54.72,98.61 54.72,97.98 54.4,97.66 54.4,97.46 54.01,97.08 MEM4.R3 ; v4(55.14,105.49) 55.35,105.69 55.77,105.69 55.84,105.77 56.18,105.77 56.25,105.69 56.66,105.69 56.99,106.02 57.26,106.02 57.37,106.14 57.37,106.37 57.26,106.48 MEM3.R3 ; v4(58.56,101.75) 58.67,101.75 58.77,101.85 58.85,101.85 59.31,102.31 v2(59.31,102.41)
MAA10: length 59.7
  TOP w0.102: v4(55.86,109.75) 56.03,109.92 56.94,109.92 57.18,109.68 MEM1.L7 ; MEM2.L7 54.01,93.34 54.11,93.24 54.58,93.24 54.75,93.07 v4(54.75,92.84) ; v4(76.94,96.46) 77,96.4 GPU1.J11
  L3 w0.127: v4(76.94,96.46) 76.94,96.6 76.81,96.73 75.43,96.73 75.41,96.74 74.3,96.74 74.17,96.87 73.5,96.87 72.98,97.39 66.43,97.39 66.11,97.06 63.45,97.06 62.54,97.97 62.21,97.97 61.62,98.55 61.62,98.86 61.04,99.43 60.77,99.43 v4(60.58,99.62)
  L4 w0.127: v4(55.86,109.75) 56.39,109.75 57.39,108.75 57.62,108.75 57.75,108.63 57.75,108.54 57.88,108.41 61.22,108.41 61.35,108.28 61.35,102.1 61.48,101.97 61.98,101.97 62.11,101.85 62.11,100.8 61.63,100.32 61.63,100.05 61.2,99.62 v4(60.58,99.62) 60.12,99.16 59.64,99.16 58.86,98.38 58.86,97.03 58.63,96.81 58.25,96.81 58.25,96.8 58.01,96.8 57.33,96.13 57.33,94.85 57.03,94.55 55.1,94.55 54.83,94.27 53.27,94.27 53.14,94.15 53.14,93.87 53.27,93.74 53.95,93.74 54.06,93.64 54.06,93.42 53.95,93.32 53.15,93.32 53.05,93.22 53.05,92.94 53.15,92.84 53.43,92.84 53.44,92.84 53.78,92.84 53.79,92.84 v4(54.75,92.84)
  BOTTOM w0.102: v4(60.58,99.62) 60.58,99.65 60.66,99.72 v2(61.45,99.72) ; v4(55.86,109.75) 55.82,109.71 55,109.71 54.72,109.99 54.33,109.99 MEM3.L7 ; v4(54.75,92.84) 55.75,93.41 56.02,93.51 56.39,93.62 MEM4.L7
MAA11: length 52.4
  TOP w0.102: MEM2.R7 54.76,97.57 54.76,98.08 55.34,98.66 v4(55.34,98.68) ; MEM1.R7 57.25,106.48 57.38,106.35 57.38,106.21 57.25,106.08 56.89,106.08 56.77,105.95 56.77,104.86 v4(56.74,104.83) ; v4(76.57,97.47) 76.57,97.18 76.75,97 GPU1.J13
  L3 w0.127: v4(76.57,97.47) 76.57,97.06 76.47,96.96 75.52,96.96 75.43,97.05 74.75,97.05 74.63,97.18 74.63,97.39 74.5,97.52 74.3,97.52 74.17,97.39 74.17,97.21 74.06,97.1 73.61,97.1 73.48,97.22 73.48,97.71 72.9,98.29 72.55,98.29 72.42,98.16 72.42,97.75 72.3,97.62 72.04,97.62 71.92,97.75 71.92,98.42 71.79,98.55 71.26,98.55 70.93,98.23 70.6,98.23 70.28,98.55 69.89,98.55 69.78,98.44 69.78,98.19 69.78,98.13 69.59,97.93 69.53,97.93 69.52,97.93 68.94,97.93 68.66,97.66 68.21,97.66 67.96,97.91 67.96,97.93 67.48,97.93 67.28,97.73 66.64,97.73 66.52,97.86 66.52,98.15 66.52,98.15 66.52,98.53 66.39,98.66 66.16,98.66 66.06,98.57 66.06,97.53 65.94,97.4 65.68,97.4 65.56,97.53 65.56,97.87 65.43,98 65.18,98 65.05,97.87 65.05,97.53 64.92,97.41 64.67,97.41 64.54,97.53 64.54,97.84 64.41,97.97 64.16,97.97 64.03,97.84 64.03,97.44 63.91,97.31 63.65,97.31 63.52,97.44 63.52,97.87 63.4,98 63.09,98 62.71,98.37 62.43,98.37 60.76,100.04 60.41,100.04 60.17,99.8 60.17,99.62 60.04,99.5 59.77,99.5 59.64,99.62 59.64,99.95 59.51,100.08 59.24,100.08 59.11,99.95 59.11,99.62 58.99,99.5 58.71,99.5 58.58,99.62 58.58,99.9 58.45,100.03 58.18,100.03 58.05,99.9 58.05,99.69 57.92,99.56 57.63,99.56 57.29,99.89 57.29,100.32 v4(57.54,100.57)
  L4 w0.127: v4(56.74,104.83) 56.74,104.13 57.98,102.89 57.98,101.01 v4(57.54,100.57) 57.54,100.09 56.56,99.11 56.15,99.11 55.92,98.87 55.92,98.57 55.79,98.45 55.46,98.45 55.34,98.57 v4(55.34,98.68)
  BOTTOM w0.102: v4(56.74,104.83) 56.41,104.83 56.29,104.95 55.51,104.95 55.43,104.88 54.89,104.88 54.35,105.42 54.35,106.15 MEM3.R7 ; MEM4.R7 56.84,97.19 56.84,97.87 56.43,98.28 56.23,98.28 56.15,98.36 56.08,98.36 55.8,98.64 55.6,98.64 55.56,98.68 55.34,98.68 v4(55.34,98.68)
MAA12: length 55
  TOP w0.102: MEM2.N7 54.54,95.22 54.89,95.57 55.52,95.57 55.89,95.19 v4(55.95,95.19) ; GPU1.H11 76.15,95.8 v4(75.66,95.3) ; v4(54.92,108.14) 55.15,107.91 55.8,107.91 56.08,108.19 56.42,108.19 56.53,108.07 56.94,108.07 56.94,108.08 MEM1.N7
  L3 w0.127: v4(75.66,95.3) 75.11,95.3 74.68,95.74 73.34,95.74 73.09,95.98 71.48,95.98 71.29,96.17 70.3,96.17 69.87,96.6 66.83,96.6 66.48,96.25 62.86,96.25 61.95,97.16 61.81,97.16 61.12,97.85 61.12,98.02 60.86,98.28 60.68,98.28 60.15,98.81 57.33,98.81 56.88,99.26 56.43,99.26 56.33,99.16 56.2,99.16 56.1,99.06 55.75,99.06 55.61,99.2 55.28,99.2 55.16,99.07 53.9,99.07 52.46,100.5 v4(52.46,100.89)
  L4 w0.127: v4(55.95,95.19) 55.94,95.19 55.52,95.61 54.97,95.61 54.84,95.74 54.84,97.11 53.91,98.05 53.91,99.44 53.78,99.57 53.23,99.57 53.1,99.7 53.1,99.95 53.23,100.08 53.78,100.08 53.91,100.21 53.91,100.76 53.78,100.89 v4(52.46,100.89) 52.46,101.42 52.21,101.67 52.21,105.63 52.66,106.07 52.66,106.25 54.55,108.14 v4(54.92,108.14)
  BOTTOM w0.102: v2(52.16,101.74) 52.46,101.43 v4(52.46,100.89) ; MEM3.N7 54.01,108.39 54.5,108.87 54.89,108.87 55.19,108.58 55.19,108.41 v4(54.92,108.14) ; v4(55.95,95.19) 55.95,95.18 56.19,94.94 56.94,94.94 MEM4.N7
MAA13: length 54.1
  TOP w0.102: v4(56.57,100.19) 56.65,100.19 56.71,100.13 56.96,100.13 57.31,99.78 57.31,98.61 57.4,98.52 57.4,97.81 MEM2.T3 ; v4(55.09,104.47) 54.39,104.47 54.26,104.6 54.26,104.95 54.39,105.08 54.53,105.08 54.66,105.21 54.66,105.55 54.53,105.68 MEM1.T3 ; GPU1.G20 75.12,103.28 v4(75.12,103.48)
  L3 w0.127: v4(54.96,102.56) 54.79,102.56 54.16,101.93 53.6,101.93 53.45,101.78 53.45,101.55 54.39,100.61 55.33,100.61 55.43,100.72 55.43,101.03 55.33,101.13 55.04,101.13 54.87,101.3 54.87,101.78 55.44,102.36 55.44,102.72 55.66,102.94 56.4,102.94 56.88,103.42 59.53,103.42 59.73,103.62 64.79,103.62 65,103.84 70.62,103.84 70.71,103.75 71.43,103.75 71.45,103.76 74.42,103.76 74.7,103.48 v4(75.12,103.48)
  L4 w0.127: v4(55.09,104.47) 55.29,104.47 55.48,104.65 55.48,104.91 55.35,105.04 54.2,105.04 54.07,104.91 54.07,104.61 54.2,104.49 54.43,104.49 54.55,104.36 54.55,103.95 54.18,103.58 54.18,103.08 54.7,102.56 v4(54.96,102.56) 54.96,102.51 54.85,102.41 54.85,100.06 55.18,99.73 55.57,99.73 56.03,100.19 v4(56.57,100.19)
  BOTTOM w0.102: v2(53.72,101.74) 54.14,101.74 v4(54.96,102.56) ; v4(55.09,104.47) 55.23,104.61 55.46,104.61 55.59,104.75 55.93,104.75 56.03,104.65 56.3,104.65 56.32,104.64 56.35,104.64 56.56,104.43 56.91,104.43 57.15,104.67 57.15,104.69 57.21,104.75 MEM3.T3 ; v4(56.57,100.19) 56.36,100.39 55.7,100.39 55.54,100.55 55.2,100.55 54.97,100.32 54.97,100.2 54.01,99.25 MEM4.T3
MAA14: length 48.9
  TOP w0.102: v4(55.76,104.34) 56.04,104.34 56.15,104.23 56.73,104.23 57.21,104.71 MEM1.T7 ; v4(75.71,98.7) 75.71,98.94 75.59,99.06 75.07,99.06 74.95,98.93 74.95,98.63 74.79,98.47 74.79,98.33 74.95,98.17 74.95,98.03 75.07,97.91 75.21,97.91 75.4,98.1 GPU1.G14 ; v4(55.92,99.48) 55.81,99.36 55.38,99.36 54.01,97.99 MEM2.T7
  L3 w0.127: v4(57.56,101.65) 57.46,101.65 57.34,101.78 57.34,102.29 57.45,102.4 57.92,102.4 58.16,102.64 58.53,102.64 58.53,102.64 58.75,102.43 59.02,102.43 59.24,102.64 59.58,102.64 59.71,102.52 59.71,102.28 59.4,101.97 59.33,101.97 59.2,101.84 59.2,101.32 59.07,101.18 59.07,100.94 59.2,100.81 59.56,100.81 59.76,101.01 60.25,101.01 60.44,100.81 60.84,100.81 61.03,100.81 61.15,100.7 61.54,100.7 61.76,100.47 61.76,100.08 62.18,99.66 62.57,99.66 62.85,99.39 63.16,99.39 63.54,99.76 64.15,99.76 64.25,99.66 67.44,99.66 67.67,99.9 67.67,100.41 67.77,100.51 68.09,100.51 68.19,100.41 68.19,100.19 68.32,100.06 68.54,100.06 69.45,100.06 69.45,100.06 70.17,100.06 70.17,100.06 70.61,100.06 70.85,100.3 71.21,100.3 71.38,100.13 71.88,100.13 72.02,99.98 72.02,99.78 72.14,99.66 72.4,99.66 72.51,99.78 72.51,100 72.64,100.13 73.01,100.13 73.13,100 73.13,99.16 73.44,98.86 73.71,98.86 73.87,98.7 74.1,98.7 74.26,98.86 74.47,98.86 74.59,98.73 74.59,98.64 74.72,98.51 75.05,98.51 75.17,98.63 75.17,98.86 75.31,99 75.59,99 75.71,98.87 v4(75.71,98.7)
  L4 w0.127: v4(55.92,99.48) 56.05,99.35 56.48,99.35 56.99,99.86 56.99,100.7 57.28,100.99 57.61,100.99 57.74,101.11 57.74,101.52 57.61,101.65 v4(57.56,101.65) 57.56,102.94 56.16,104.34 v4(55.76,104.34)
  BOTTOM w0.102: MEM3.T7 54.01,104.75 54.52,104.25 54.52,104.24 54.72,104.04 55.63,104.04 55.76,104.17 v4(55.76,104.34) ; MEM4.T7 57.22,97.62 57.35,97.75 57.35,98.47 56.87,98.94 56.87,99.35 56.75,99.48 v4(55.92,99.48)
MAA_BA0: length 60.2
  TOP w0.102: MEM1.M2 53.33,109 53.56,109 53.68,108.87 53.68,108.74 53.88,108.55 53.88,108.55 53.97,108.53 54.12,108.53 54.6,108.78 55.89,108.78 55.93,108.74 56.37,108.74 56.47,108.84 56.67,108.84 56.8,108.72 v4(56.8,108.51) ; v4(55.32,95.11) 55.66,94.77 56.13,94.77 56.13,94.77 57.67,94.77 MEM2.M2 ; v4(60.84,101.58) 60.37,101.11 v1(60.37,100.88) ; v4(77.59,98.72) 77,99.31 GPU1.J16
  L3 w0.127: v4(77.59,98.72) 77.63,98.72 77.74,98.83 77.74,99.3 77.54,99.5 75.72,99.5 75.45,99.77 75.45,100.18 75.25,100.39 74.62,100.39 74.5,100.27 74.5,100.14 74.38,100.02 73.77,100.02 73.64,100.14 73.64,100.46 73.51,100.59 71.57,100.59 71.28,100.88 70.68,100.88 70.55,100.75 70.55,100.64 70.42,100.52 70.17,100.52 70.04,100.64 70.04,100.75 69.91,100.88 69.66,100.88 69.53,100.75 69.53,100.64 69.41,100.52 69.15,100.52 69.03,100.64 69.03,100.75 68.9,100.88 68.63,100.88 68.34,101.18 67.06,101.18 66.93,101.05 66.93,100.44 66.81,100.32 64.25,100.32 64.24,100.32 62.77,100.32 62.65,100.44 62.65,101.06 62.48,101.23 61.69,101.23 61.49,101.43 61.49,101.68 61.34,101.83 60.98,101.83 60.84,101.69 v4(60.84,101.58)
  L4 w0.127: v4(56.8,108.51) 57.22,108.1 59.88,108.1 61,106.98 61,102.13 60.84,101.97 v4(60.84,101.58) 61.3,101.58 61.43,101.45 61.43,101.13 61.3,101 60.88,101 60.75,100.88 60.75,100.31 60.48,100.04 60.2,100.04 59.41,99.26 59.41,99.25 58.63,98.47 58.63,97.95 58.5,97.83 58.11,97.83 57.98,97.7 57.98,97.15 57.01,96.18 57.01,95.21 56.58,94.78 55.66,94.78 v4(55.32,95.11)
  BOTTOM w0.102: MEM4.M2 52.99,94.42 52.86,94.55 52.86,94.74 52.99,94.87 53.34,94.87 53.47,95 53.75,95 53.88,94.87 54.13,94.87 54.67,95.41 55.19,95.41 55.32,95.28 v4(55.32,95.11) ; v4(56.8,108.51) 56.88,108.43 57.44,108.43 57.56,108.56 57.56,109.21 57.7,109.35 58.15,109.35 58.33,109.53 58.5,109.53 58.68,109.35 58.68,109.21 58.48,109.02 58.48,109.01 58.36,108.88 MEM3.M2
MAA_BA1: length 57.5
  TOP w0.102: v4(56.02,96.08) 55.97,96.08 55.58,96.47 55.12,96.47 54.3,95.65 53.64,95.65 MEM2.N8 ; v4(56.27,107.74) 56.27,107.65 56.39,107.52 56.99,107.52 57.08,107.61 57.45,107.61 57.56,107.73 57.56,108.11 57.67,108.21 57.88,108.21 MEM1.N8 ; GPU1.L15 78.9,98.6 79,98.5 79,98.44 79,98.44 79,98.06 79,98.06 79,98.03 78.9,97.93 78.46,97.93 78.36,98.02 v4(78.36,98.08)
  L3 w0.127: v4(59.82,101.79) 59.82,101.51 60.05,101.27 60.41,101.27 60.61,101.07 61.52,101.07 62.6,99.99 67.01,99.99 67.3,100.28 67.3,100.71 67.43,100.84 68.35,100.84 68.5,100.68 68.5,100.42 68.63,100.29 69.54,100.29 69.54,100.29 70.07,100.29 70.07,100.29 70.52,100.29 70.77,100.54 71.29,100.54 71.47,100.36 73.26,100.36 73.38,100.23 73.38,99.28 73.57,99.09 74.55,99.09 74.71,99.24 74.71,99.95 74.83,100.08 75.09,100.08 75.21,99.95 75.21,99.37 75.34,99.24 76.99,99.24 77.17,99.06 77.17,98.32 77.29,98.19 77.56,98.19 77.81,97.95 77.81,97.6 77.95,97.46 78.24,97.46 78.36,97.59 v4(78.36,98.08)
  L4 w0.127: v4(56.02,96.08) 57.36,97.42 57.36,98.23 59.48,100.36 59.48,100.5 59.61,100.63 60.06,100.63 60.18,100.75 60.18,101.02 60.06,101.14 59.57,101.14 59.44,101.26 59.44,101.67 59.57,101.79 v4(59.82,101.79) 59.78,101.82 59.78,104.57 59.87,104.66 59.87,106.54 59.44,106.98 57.46,106.98 56.7,107.74 v4(56.27,107.74)
  BOTTOM w0.102: v2(60.56,100.73) 60.08,100.73 59.75,101.07 59.75,101.72 v4(59.82,101.79) ; v4(56.02,96.08) 56.47,96.08 56.87,95.68 57.55,95.68 MEM4.N8 ; MEM3.N8 53.56,107.74 55.53,107.74 55.54,107.74 56,107.74 56.01,107.74 v4(56.27,107.74)
MAA_BA2: length 56.2
  TOP w0.102: GPU1.G11 75.4,95.81 v4(75.87,96.28) ; MEM1.M3 54.14,109 54.78,109 54.92,109.15 v4(54.92,109.29) ; MEM2.M3 55.16,94.42 v4(54.75,94.83) ; v1(52.43,102.54) v4(51.59,102.54)
  L3 w0.127: v4(75.87,96.28) 75.48,95.89 74.85,95.89 74.73,96.02 73.82,96.02 72.69,97.14 69.94,97.14 69.81,97.01 66.63,97.01 66.27,96.65 63.29,96.65 62.38,97.56 62.04,97.56 60.41,99.19 57.28,99.19 57.2,99.27 56.97,99.49 56.63,99.49 56.62,99.5 56.49,99.5 56.1,99.9 55.75,99.9 55.52,99.67 55.26,99.67 55.2,99.73 55.2,99.73 54.9,100.03 54.43,100.03 51.92,102.54 v4(51.59,102.54)
  L4 w0.127: v4(54.92,109.29) 54.92,108.87 54.52,108.47 54.34,108.47 54.04,108.76 53.86,108.76 53.68,108.58 53.68,108.4 53.98,108.11 53.98,107.93 52.41,106.36 51.76,106.36 51.52,106.12 51.52,102.62 v4(51.59,102.54) 51.59,100.96 51.93,100.63 51.93,97.47 54.57,94.83 v4(54.75,94.83)
  BOTTOM w0.102: v4(54.92,109.29) 55.77,108.84 55.96,108.74 56,108.72 56.12,108.72 56.2,108.73 56.45,108.83 56.62,108.9 56.69,108.92 56.82,108.93 MEM3.M3 ; v4(54.75,94.83) 55,94.83 55.16,94.67 55.16,94.48 55.03,94.36 54.08,94.36 MEM4.M3
MCLK: length 4.9
  TOP w0.102: U109.80 136.61,47.72 v1(136.11,47.22) 136.08,47.18 136.08,45.26 135.68,44.87 RN3.1
MCT_R: length 4.2
  BOTTOM w0.508: v3(63.03,13.72) 62.14,13.72 62.01,13.84 XF1.4 ; v3(63.03,10.16) 61.88,10.16 61.76,10.03 60.99,10.03
  vias: v1(63.13,11.56)
MCT_R_1: length 4.5
  TOP w0.508: R79612.1 66.05,12.93 v3(66.35,13.23)
  BOTTOM w0.508: C3131.1 66.35,14.96 v2(66.35,14.27) v3(66.35,13.23)
MDA0: length 39.2
  TOP w0.127: GPU1.K27 77.8,108.6 77.78,108.62 77.78,108.74 77.46,109.06 v3(77.46,112.35)
  L3 w0.165: v3(77.46,112.35) 77.46,113.74 71.3,119.89 54.93,119.89 54.15,119.11 54.15,116.04 54.46,115.73 54.46,115.31 54.81,114.95 v4(54.81,114.85)
  BOTTOM w0.127: v4(54.81,114.85) 54.81,114.76 54.19,114.14 53.85,114.14 53.39,113.68 MEM3.F8 ; v2(77.63,113.16) 77.46,112.98 v3(77.46,112.35)
MDA1: length 38.6
  TOP w0.127: GPU1.J29 77,109.75 76.58,110.17 76.58,111.49 v3(76.83,111.74) 76.94,111.85 76.94,113.14 v1(77.02,113.21)
  L3 w0.165: v4(55.57,115.37) 55.33,115.61 55.33,115.67 54.87,116.13 54.87,117.89 55.43,118.44 55.43,119.08 55.62,119.27 56.4,119.27 56.56,119.11 56.56,118.86 56.73,118.7 57.06,118.7 57.22,118.86 57.22,119.11 57.54,119.42 69.38,119.42 69.69,119.11 69.69,118.65 69.82,118.52 70.23,118.52 70.35,118.65 70.35,119.11 70.52,119.27 71.29,119.27 76.93,113.63 76.93,111.83 v3(76.83,111.74)
  BOTTOM w0.127: v4(55.57,115.37) 55.57,114.91 54.34,113.68 MEM3.F7
MDA2: length 38.5
  TOP w0.127: 74.89,113.69 73.67,113.69 73.54,113.57 73.54,113.07 v4(73.57,113.04) ; 74.89,113.69 75.93,113.69 76.05,113.57 76.05,113.2 75.93,113.07 74.33,113.07 74.2,112.95 74.2,112.69 74.45,112.44 74.45,111.92 74.58,111.79 74.81,111.79 74.94,111.92 74.94,112.32 75.18,112.57 75.85,112.57 75.95,112.46 75.95,112.19 75.95,112.19 75.95,112.15 75.98,112.12 75.98,111.21 75.86,111.09 75.86,110.34 GPU1.H30 ; 74.89,113.69 v1(74.89,114.1)
  L3 w0.165: v4(57.62,112.48) 57.62,112.57 57.75,112.69 58.24,112.69 58.36,112.82 58.73,112.82 58.86,112.69 58.86,112.37 58.98,112.25 59.66,112.25 60.05,112.64 61.08,112.64 61.17,112.73 61.85,112.73 62.01,112.89 62.01,113.58 62.18,113.75 62.51,113.75 62.67,113.58 62.67,112.89 62.84,112.73 63.17,112.73 63.33,112.89 63.33,113.58 63.5,113.75 63.83,113.75 63.99,113.58 63.99,112.89 64.16,112.73 64.49,112.73 64.65,112.89 64.65,113.58 64.82,113.75 65.15,113.75 65.31,113.58 65.31,112.89 65.48,112.73 65.81,112.73 65.97,112.89 65.97,113.58 66.14,113.75 66.47,113.75 66.64,113.58 66.64,112.89 66.8,112.73 67.13,112.73 67.3,112.89 67.3,113.58 67.46,113.75 67.79,113.75 67.96,113.58 67.96,112.89 68.12,112.73 68.56,112.73 68.97,113.13 73.48,113.13 v4(73.57,113.04)
  BOTTOM w0.127: MEM3.H3 57.22,112.08 v4(57.62,112.48) ; v4(73.57,113.04) 73.15,113.46 v2(72.88,113.46)
MDA3: length 37.6
  TOP w0.127: GPU1.H32 76.23,110.83 76.23,112.25 76.36,112.37 v3(76.4,112.37)
  L3 w0.165: v3(76.4,112.37) 76.4,113.53 71.79,118.14 69.66,118.14 68.85,118.95 58.63,118.95 57.85,118.17 56.2,118.17 55.86,117.84 55.58,117.84 55.45,117.71 55.45,117.33 55.58,117.2 56.11,117.2 56.38,116.93 56.99,116.93 57.59,116.34 57.59,115.09 57.46,114.96 57.05,114.96 56.7,115.32 56.7,116.06 56.57,116.18 55.76,116.18 55.63,116.06 v4(55.63,116)
  BOTTOM w0.127: v2(76.16,113.15) 76.4,112.92 v3(76.4,112.37) ; MEM3.E3 57.21,114.67 56.64,115.25 56.64,116.04 56.52,116.16 55.76,116.16 55.63,116.03 v4(55.63,116)
MDA4: length 37.8
  TOP w0.127: GPU1.G29 75.52,109.48 75.52,109.12 75.37,108.97 v4(75.14,108.97) ; v1(61.03,112.9) 60.33,112.9 v4(60.14,113.09)
  L3 w0.165: v4(75.14,108.97) 75.57,109.4 75.57,109.63 75.37,109.83 74.78,109.83 74.22,110.39 74.22,113.18 74.09,113.31 74.09,113.4 73.74,113.74 71.99,113.74 71.86,113.87 71.86,114.38 71.65,114.58 71.48,114.58 71.35,114.71 71.35,115.22 71.73,115.61 71.73,115.84 71.34,116.23 70.77,116.23 70.64,116.11 70.64,113.87 70.52,113.74 69.8,113.74 69.68,113.87 69.68,116.11 69.55,116.23 69.14,116.23 69.02,116.11 69.02,113.8 68.79,113.57 68.51,113.57 67.95,114.13 67.37,114.13 67.2,114.29 67.2,114.42 67.04,114.58 66.71,114.58 66.54,114.42 66.54,114.29 66.38,114.13 66.05,114.13 65.88,114.29 65.88,114.42 65.72,114.58 65.39,114.58 65.22,114.42 65.22,114.29 65.06,114.13 64.73,114.13 64.56,114.29 64.56,114.42 64.4,114.58 64.07,114.58 63.9,114.42 63.9,114.29 63.74,114.13 61.96,114.13 60.92,113.09 v4(60.14,113.09)
  BOTTOM w0.127: v4(60.14,113.09) 60.46,113.09 60.58,112.96 60.58,112.63 60.46,112.5 59.97,112.5 59.85,112.37 59.85,112.09 59.72,111.97 59.39,111.97 59.26,112.09 59.26,112.33 59.14,112.46 58.44,112.46 MEM3.G2
MDA5: length 37.5
  TOP w0.127: v4(75.49,111.87) 74.98,111.35 74.98,110.86 75.06,110.78 75.06,109.66 GPU1.F28
  L3 w0.165: v4(60.16,114.53) 60.16,114.64 60.5,114.97 60.5,116.77 60,117.27 60,117.61 60.15,117.76 62.89,117.76 63.06,117.59 63.06,116.03 63.15,115.94 63.57,115.94 63.72,116.08 63.72,117.59 63.88,117.76 64.21,117.76 64.38,117.59 64.38,116.67 64.5,116.55 64.59,116.55 64.92,116.55 65.04,116.67 65.04,117.59 65.2,117.76 65.53,117.76 65.7,117.59 65.7,116.67 65.83,116.55 66.24,116.55 66.36,116.67 66.36,117.59 66.52,117.76 66.85,117.76 67.02,117.59 67.02,117.26 67.19,117.1 67.52,117.1 67.68,117.26 67.68,117.59 67.85,117.76 71.63,117.76 75.49,113.89 v4(75.49,111.87)
  BOTTOM w0.127: v2(76.14,111.31) 76.05,111.31 v4(75.49,111.87) ; v4(60.16,114.53) 59.69,114.06 58.4,114.06 MEM3.F2
MDA6: length 36.8
  TOP w0.127: GPU1.F32 74.6,111.32 v4(73.63,112.29)
  L3 w0.165: v4(53.61,111.67) 53.61,112.18 54.15,112.73 54.84,112.73 54.89,112.78 55.25,112.78 55.28,112.75 55.88,112.75 56.33,112.31 56.33,112.2 57.18,111.36 57.18,110.7 57.43,110.44 57.79,110.44 58.14,110.79 58.96,110.79 59.2,111.02 59.7,111.02 59.87,110.85 59.87,110.52 60,110.39 61.17,110.39 61.35,110.57 62.33,110.57 62.5,110.41 62.5,109.9 62.66,109.73 62.99,109.73 63.16,109.9 63.16,110.27 63.28,110.39 63.69,110.39 63.82,110.27 63.82,109.9 63.98,109.73 64.31,109.73 64.48,109.9 64.48,110.32 64.6,110.44 65.01,110.44 65.14,110.32 65.14,109.9 65.3,109.73 65.63,109.73 65.8,109.9 65.8,110.29 65.93,110.42 66.33,110.42 66.46,110.29 66.46,109.9 66.62,109.73 66.95,109.73 67.12,109.9 67.12,110.29 67.25,110.42 67.65,110.42 67.78,110.29 67.78,109.9 67.94,109.73 68.94,109.73 69.07,109.86 69.07,110.44 69.19,110.57 72.14,110.57 72.27,110.44 72.27,109.48 72.4,109.35 73.5,109.35 73.63,109.48 73.63,109.76 73.5,109.88 73.04,109.88 72.88,110.05 72.88,110.38 73.04,110.55 73.5,110.55 73.63,110.67 v4(73.63,112.29)
  BOTTOM w0.127: v4(53.61,111.67) 53.61,111.69 MEM3.H8 ; v4(73.63,112.29) 73.59,112.25 v2(73.59,111.48)
MDA7: length 37.4
  TOP w0.127: GPU1.F30 74.19,110.41 74.19,111.13 72.95,112.37 v4(72.95,112.63) 72.83,112.76 v1(72.83,113.52)
  L3 w0.165: v4(55.53,113.48) 55.56,113.45 56.01,113.45 56.65,112.81 56.93,112.81 57.13,112.6 57.13,112.33 57.41,112.05 58.16,112.05 58.23,112.12 58.59,112.12 58.82,111.89 59.7,111.89 60.08,111.5 60.45,111.5 60.94,111.99 62.16,111.99 62.92,111.23 63.16,111.23 63.32,111.4 63.32,112.22 63.45,112.35 63.85,112.35 63.98,112.22 63.98,111.4 64.15,111.23 64.48,111.23 64.64,111.4 64.64,112.22 64.77,112.35 65.17,112.35 65.3,112.22 65.3,111.4 65.47,111.23 65.8,111.23 65.96,111.4 65.96,112.22 66.09,112.35 66.5,112.35 66.62,112.22 66.62,111.4 66.79,111.23 67.12,111.23 67.28,111.4 67.28,112.2 67.41,112.32 67.82,112.32 67.94,112.2 67.94,111.4 68.11,111.23 68.59,111.23 68.86,111.51 68.86,112.45 69.17,112.75 69.48,112.75 69.7,112.53 70.06,112.53 70.29,112.76 70.69,112.76 70.82,112.63 70.82,112.32 70.95,112.2 71.35,112.2 71.48,112.32 71.48,112.68 71.61,112.81 72.83,112.81 72.95,112.68 v4(72.95,112.63)
  BOTTOM w0.127: v4(55.53,113.48) 55.56,113.44 56.14,113.44 56.27,113.31 56.27,112.68 56.14,112.55 55.78,112.55 55.53,112.81 54.9,112.81 54.82,112.73 54.64,112.73 54.43,112.52 54.13,112.52 54.01,112.41 MEM3.H7
MDA8: length 34.6
  TOP w0.127: v4(69.4,111.84) 70.94,111.84 71.71,111.07 71.71,110.77 72.05,110.43 72.57,110.43 GPU1.C30
  BOTTOM w0.127: v4(69.4,111.84) v2(69.4,114.22) 69.4,114.41 62.25,121.56 54.36,121.56 51.42,118.61 51.42,116.31 52.02,115.71 53.4,115.71 53.83,115.28 MEM3.D7
MDA9: length 36.4
  TOP w0.127: v4(74.2,108.77) 74.57,108.4 GPU1.F27
  BOTTOM w0.127: v4(74.2,108.77) v2(73.44,109.53) 71.37,111.6 69.77,111.6 69.59,111.42 69.09,111.42 68.62,111.9 68.62,113.69 68.12,114.19 68.12,115.16 64.31,118.97 64.13,118.97 63.96,118.8 63.78,118.8 63.6,118.98 63.6,119.16 63.77,119.33 63.77,119.51 63.59,119.69 63.41,119.69 63.25,119.53 63.07,119.53 62.89,119.71 62.89,119.89 63.05,120.05 63.05,120.23 62.87,120.41 62.69,120.41 62.43,120.15 62.25,120.15 62.08,120.33 62.08,120.51 62.33,120.77 62.33,120.95 62.09,121.19 54.49,121.19 52,118.7 52,118.34 52.32,118.02 52.56,118.02 52.76,117.82 52.76,117.58 52.8,117.55 52.8,116.21 52.92,116.08 MEM3.C8
MDA10: length 36.6
  TOP w0.127: GPU1.A28 72.08,109.08 71.59,109.08 70.87,109.8 70.87,110.31 70.21,110.97 70.21,111.13 v4(70.21,111.13)
  BOTTOM w0.127: MEM3.B8 53.21,117.17 53.59,117.55 53.59,118.65 53.27,118.97 53.27,119.29 54.7,120.72 61.13,120.72 64.17,117.68 64.35,117.68 64.53,117.87 64.71,117.87 64.89,117.69 64.89,117.51 64.7,117.32 64.7,117.14 64.88,116.96 65.06,116.96 65.25,117.15 65.43,117.15 65.61,116.97 65.61,116.79 65.42,116.61 65.42,116.43 65.6,116.25 65.78,116.25 66.07,116.54 66.25,116.54 66.43,116.36 66.43,116.18 66.14,115.89 66.14,115.71 66.32,115.53 66.5,115.53 66.79,115.82 66.97,115.82 67.15,115.64 67.15,115.46 66.86,115.17 66.86,114.99 67.1,114.74 67.1,114.54 66.55,113.98 66.55,113.8 66.73,113.62 66.91,113.62 67.46,114.18 67.64,114.18 68,113.82 68,113.48 67.88,113.35 67.44,113.35 67.32,113.23 67.32,112.97 67.44,112.84 67.88,112.84 68,112.72 68,111.79 68.71,111.08 70.16,111.08 v4(70.21,111.13) 71.04,111.13 v2(71.45,110.72)
MDA11: length 35
  TOP w0.127: GPU1.C28 73,108.87 72.87,108.74 72.34,108.74 72.34,108.74 72.06,108.74 72.06,108.74 71.3,108.74 70.46,109.58 70.46,109.94 70.45,109.95 v4(70.45,110.08)
  BOTTOM w0.127: MEM3.A7 53.88,117.81 53.88,119.32 54.88,120.31 61.05,120.31 65.19,116.17 65.19,115.83 65.32,115.7 65.41,115.7 65.54,115.57 65.54,115.32 65.41,115.19 65.32,115.19 65.19,115.06 65.19,114.81 65.32,114.68 66.07,114.68 66.2,114.56 66.2,114.3 66.07,114.17 65.32,114.17 65.19,114.05 v2(65.19,113.59) 65.19,113.42 65.65,112.96 65.83,112.96 66.25,113.39 66.43,113.39 66.61,113.21 66.61,113.03 66.19,112.6 66.19,112.42 66.37,112.24 66.55,112.24 66.93,112.63 67.11,112.63 67.29,112.45 67.29,112.27 66.91,111.88 66.91,111.7 67.09,111.52 67.27,111.52 67.45,111.71 67.6,111.71 67.81,111.5 67.81,111.35 67.63,111.16 67.63,110.98 67.89,110.72 70.04,110.72 70.8,110.72 70.95,110.57 70.95,110.29 70.74,110.08 v4(70.45,110.08)
MDA12: length 36
  TOP w0.102: GPU1.E27 73.33,107.93 72.46,107.93 72.43,107.91 72.3,107.87 72.22,107.87 72.08,107.87 71.99,107.9 71.92,107.93 71.78,107.93 71.71,107.99 70.82,107.99 70.81,108.01 v4(69.85,108.01)
  BOTTOM w0.127: MEM3.A3 58.27,118.73 60.09,118.73 60.46,118.37 60.46,118.19 60.22,117.95 60.22,117.77 60.4,117.59 60.58,117.59 60.82,117.83 61,117.83 61.17,117.65 61.17,117.47 60.94,117.23 60.94,117.05 61.12,116.87 61.3,116.87 61.53,117.11 61.71,117.11 61.89,116.93 61.89,116.75 61.65,116.51 61.65,116.33 61.83,116.15 62.01,116.15 62.25,116.39 62.43,116.39 62.8,116.02 62.8,112.13 63,111.94 63,109.27 v2(63.73,108.54) 63.73,108.44 63.86,108.31 65.33,108.31 65.46,108.18 65.46,107.62 65.59,107.5 65.84,107.5 65.97,107.62 65.97,108.18 66.09,108.31 66.35,108.31 66.48,108.18 66.48,107.62 66.6,107.5 66.86,107.5 66.98,107.62 66.98,108.18 67.11,108.31 67.36,108.31 67.49,108.18 67.49,107.62 67.62,107.5 67.87,107.5 68,107.62 68,108.18 68.13,108.31 68.38,108.31 68.51,108.18 68.51,107.62 68.63,107.5 68.89,107.5 69.02,107.62 69.02,108.46 69.37,108.82 69.75,108.82 70.11,109.17 70.29,109.17 70.56,108.9 70.56,108.72 v4(69.85,108.01)
MDA13: length 36.2
  TOP w0.127: v4(75.79,108) 75.79,107.98 75.42,107.6 GPU1.G26
  BOTTOM w0.127: v4(75.79,108) 75.79,107.12 75.67,106.99 75.04,106.99 74.48,107.55 74.48,108.1 74.35,108.23 73.94,108.23 73.63,108.53 73.36,108.53 73.06,108.23 73.06,108.23 72.71,108.23 72.58,108.35 72.58,108.89 72.45,109.02 72.2,109.02 72.07,108.89 72.07,108.35 71.95,108.23 71.69,108.23 71.57,108.35 71.57,108.89 71.44,109.02 71.18,109.02 71.06,108.89 71.06,108.35 70.93,108.23 70.66,108.23 70.03,107.59 70.03,106.46 69.9,106.33 69.13,106.33 69,106.46 69,106.99 68.87,107.12 68.62,107.12 68.49,106.99 68.49,106.46 68.37,106.33 68.11,106.33 67.98,106.46 67.98,106.99 67.86,107.12 67.6,107.12 67.48,106.99 67.48,106.46 67.35,106.33 67.1,106.33 66.97,106.46 66.97,106.96 66.84,107.09 66.59,107.09 66.46,106.96 66.46,106.46 66.33,106.33 65.99,106.33 64.81,107.51 64.81,107.76 64.67,107.9 63.61,107.9 62.66,108.85 62.66,109.61 62.45,109.82 62.45,112.47 62.22,112.7 v2(62.22,113.3) 62.22,114.76 59.67,117.31 58.38,117.31 MEM3.A2
MDA14: length 36
  TOP w0.102: GPU1.D26 73.07,107.27 72.55,107.27 72.46,107.3 72.42,107.3 72.25,107.33 71.94,107.33 71.82,107.22 71.78,107.17 71.35,107.17 71.02,107.5 v4(70.87,107.5)
  BOTTOM w0.127: v4(70.87,107.5) 70.87,104.7 70.75,104.57 70.75,103.79 70.62,103.66 70.35,103.66 70.22,103.79 70.22,104.25 70.1,104.37 69.84,104.37 69.72,104.25 69.72,103.71 69.59,103.59 69.35,103.59 69.21,103.73 69.21,104.25 69.08,104.37 68.83,104.37 68.7,104.25 68.7,103.59 68.57,103.46 68.32,103.46 68.19,103.59 68.19,104.25 68.06,104.37 67.81,104.37 67.68,104.25 67.68,103.59 67.56,103.46 67.3,103.46 67.18,103.59 67.18,104.25 67.05,104.37 66.79,104.37 66.67,104.25 66.67,103.59 66.54,103.46 66.2,103.46 66.07,103.59 66.07,105.28 64.41,106.94 62.91,106.94 v2(61.65,108.2) 61.65,108.82 61.97,109.14 61.97,109.32 61.76,109.54 61.58,109.54 61.32,109.28 61.14,109.28 60.72,109.7 60.72,110.22 60.51,110.43 60.51,111.54 60.89,111.92 60.89,113.21 60.63,113.47 60.63,115 60.46,115.16 59.81,115.16 59.53,115.45 59.2,115.45 58.97,115.67 58.42,115.67 MEM3.C2
MDA15: length 36
  TOP w0.127: GPU1.F25 74.03,107.37 v4(73.92,107.37)
  BOTTOM w0.127: v4(73.92,107.37) 73.92,107.43 73.7,107.65 v2(72.6,107.65) 72.58,107.65 72.23,108 70.78,108 70.45,107.67 70.45,105 70.19,104.73 69.73,104.73 69.6,104.86 69.6,105.85 69.47,105.97 69.22,105.97 69.09,105.85 69.09,104.86 68.97,104.73 68.71,104.73 68.59,104.86 68.59,105.85 68.46,105.97 68.2,105.97 68.08,105.85 68.08,104.86 67.95,104.73 67.7,104.73 67.57,104.86 67.57,105.82 67.44,105.95 67.19,105.95 67.06,105.82 67.06,104.86 66.93,104.73 66.59,104.73 66.41,104.91 66.41,105.42 64.55,107.28 63.7,107.28 62.32,108.66 62.32,109.47 61.99,109.79 61.99,112.2 61.18,113.01 61.18,115.03 61.18,115.03 61.18,115.03 61.18,115.46 60.3,116.33 59.41,116.33 59.26,116.49 57.62,116.49 MEM3.C3
MDA16: length 35.9
  TOP w0.102: MEM1.A2 53.67,118.14 53.67,119.6
  TOP w0.127: 53.67,119.6 55.72,121.65 v1(57.08,121.65) 57.31,121.42 61.27,121.42 61.55,121.42 61.55,121.42 62.18,121.42 68.48,115.12 68.48,113.77 68.35,113.64 68.2,113.64 68.08,113.51 68.08,113.26 68.2,113.13 68.35,113.13 68.48,113 68.48,112.75 68.35,112.62 68,112.62 67.87,112.5 67.87,112.24 68,112.11 68.35,112.11 68.48,111.99 68.48,111.73 68.35,111.61 68,111.61 67.87,111.48 67.87,111.23 68,111.1 68.35,111.1 68.48,110.97 68.48,110.72 68.35,110.59 68,110.59 67.87,110.46 67.87,110.21 68,110.08 68.35,110.08 68.48,109.96 68.48,109.7 68.35,109.57 68,109.57 67.87,109.45 67.87,109.19 68,109.07 68.35,109.07 68.48,108.94 68.48,108.25 69.93,106.8 70.8,106.8 70.87,106.73 71.96,106.73 71.97,106.73 72.13,106.73 GPU1.A25
