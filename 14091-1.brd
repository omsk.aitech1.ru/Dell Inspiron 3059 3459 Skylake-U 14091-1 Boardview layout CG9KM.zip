# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S_TXOC+: length 38.2
  TOP w0.102: 48.45,63.09 v1(48.8,63.09) ; 48.45,63.09 48.45,62.31 48.57,62.18 49.64,62.18 49.77,62.31 49.77,62.99 50.05,63.27 50.43,63.27 50.55,63.4 50.55,64.06 50.83,64.34 51.27,64.34 51.54,64.06 51.54,62.91 51.67,62.78 52.59,62.78 52.72,62.9 SCA1.88 ; 48.45,63.09 48.45,64.93 46.13,67.24 46.13,82.91 44.74,84.31 44.74,85.2 43.7,86.23 43.7,86.52 43.97,86.79 43.97,87.86 43.7,88.13 43.34,88.13 42.97,88.5 LVDS1.22
S_TXOC-: length 38.2
  TOP w0.102: 47.85,65.16 v1(47.61,64.92) ; 47.85,65.16 48.19,64.82 48.19,62.2 48.47,61.93 49.74,61.93 50.02,62.2 50.02,62.89 50.15,63.02 50.53,63.02 50.81,63.29 50.81,63.96 50.93,64.08 51.16,64.08 51.29,63.96 51.29,62.8 51.57,62.52 52.59,62.52 52.71,62.4 SCA1.89 ; 47.85,65.16 45.88,67.13 45.88,82.8 44.48,84.2 44.48,85.09 43.45,86.13 43.45,86.62 43.72,86.89 43.72,87.75 43.59,87.87 43.34,87.87 42.97,87.5 LVDS1.23
SA0_DIMA: length 8.9
  TOP w0.152: DIMM1.197 128.87,129.35 127.54,128.02 v4(127.54,127.64)
  BOTTOM w0.152: v4(127.54,127.64) 127.54,128.02 127.9,128.37 v2(127.9,128.4) 127.92,128.4 129.7,130.18 R1201.2
SA0_DIMB: length 4
  TOP w0.152: v4(145.12,129.29) 145.18,129.35 DIMM2.197
  BOTTOM w0.152: R1301.2 146.15,129.78 145.55,130.38 v2(145.35,130.38) 145.12,130.15 v4(145.12,129.29)
SA1_DIMA: length 5.1
  TOP w0.152: DIMM1.201 129.58,128.15 v4(129.07,127.64)
  BOTTOM w0.152: v2(129.69,128.45) 129.07,127.82 v4(129.07,127.64) 128.81,127.38 R1202.2
SA1_DIMB: length 6.1
  TOP w0.152: v3(144.1,127.39) 144.87,128.15 DIMM2.201
  BOTTOM w0.152: R1302.2 145.46,127.94 144.66,127.94 v3(144.1,127.39) 144.06,127.43 v2(143.11,127.43)
SATA__RXN0_C: length 9.5
  TOP w0.102: C149.2 17.98,147.3 17.98,146.83 17.6,146.45 15.8,146.45 13.15,143.8 12.28,143.8 HDD1.5
  BOTTOM w0.102: HDD1.5 v2(12.56,143)
SATA__RXN1_C: length 9.9
  TOP w0.102: C118.2 13.32,173.68 12.16,173.68 9.69,176.15 9.69,178.14 9.03,178.8 8.68,178.8 ODD1.5
  BOTTOM w0.102: ODD1.5 v2(8.96,178)
SATA__RXP0_C: length 9.2
  TOP w0.102: C151.2 17.77,147.3 17.77,146.92 17.51,146.67 15.71,146.67 13.06,144.01 12.28,144.01 HDD1.6
  BOTTOM w0.102: HDD1.6 v2(12.48,144.98)
SATA__RXP1_C: length 10.1
  TOP w0.102: C119.2 13.06,174.33 12.99,174.26 12.99,173.96 12.92,173.89 12.24,173.89 9.9,176.24 9.9,178.23 9.12,179.01 8.68,179.01 ODD1.6
  BOTTOM w0.102: ODD1.6 v2(8.88,179.98)
SATA__TXN0_C: length 15.7
  TOP w0.102: HDD1.3 11.27,140.73 11.01,140.46 10.6,140.46 10.18,140.04 10.18,137.76 10.87,137.07 12.59,137.07 14.94,139.42 17.81,139.42 18.32,139.93 C142.2
  BOTTOM w0.102: HDD1.3 v2(12.56,141.02)
SATA__TXN1_C: length 8.9
  TOP w0.102: ODD1.3 8.68,175.2 9.03,175.2 12.5,171.74 12.5,171 12.88,170.62 13.27,170.62 C115.2
  BOTTOM w0.102: ODD1.3 v2(8.96,176.02)
SATA__TXP0_C: length 15.7
  TOP w0.102: C141.2 17.43,140.61 17.56,140.49 17.98,140.49 18.11,140.36 18.11,140.02 17.72,139.64 14.85,139.64 12.5,137.29 10.96,137.29 10.4,137.85 10.4,139.95 10.69,140.25 10.97,140.25 11.11,140.11 11.11,139.65 11.3,139.46 HDD1.2
  BOTTOM w0.102: HDD1.2 v2(12.5,139.04)
SATA__TXP1_C: length 9
  TOP w0.102: C114.2 13.17,170.4 12.79,170.4 12.28,170.91 12.28,171.65 8.94,174.99 8.68,174.99 ODD1.2
  BOTTOM w0.102: ODD1.2 v2(8.9,174.04)
SATA_LED_N: length 173.2
  TOP w0.102: 75.23,143.78 75.86,144.41 CPU1.H1
  TOP w0.254: v3(22.69,15.13) 22.7,15.13 Q9646.4 ; 75.23,143.78 73.85,142.39 73.85,140.3 R1615.2 71.63,138.08 59.21,138.08 54.89,133.76 44.86,133.76 43.24,132.13 42.25,132.13 41.41,131.29 40.1,131.29 v3(39.57,131.83)
  L3 w0.254: v3(39.57,131.83) 38.94,132.46 37.87,132.46 37.47,132.87 35.06,132.87 30.51,128.32 30.51,43.14 26.04,38.67 26.04,27.46 v3(26.07,27.43)
  BOTTOM w0.254: v3(22.69,15.13) 23.15,15.59 v2(23.15,18.95) 23.02,19.08 23.02,25.11 R1754.1 24.02,26.11 24.61,26.11 25.93,27.43 v3(26.07,27.43)
SATA_LED_N_C_1: length 11
  TOP w0.254: R80201.2 28.05,15.13 Q9646.3 24.83,15.13 23.9,16.05 v1(22.23,16.05) 22.13,15.95 22.13,14.16 22.47,13.82 23.72,13.82 Q9646.6
SATA_RXN0_C_N: length 2.9
  TOP w0.102: L604.1 18.15,149.83 17.93,149.61 17.93,148.91 C149.1 18.84,148.53 v1(19.29,148.08)
SATA_RXN1_C_N: length 2.7
  TOP w0.102: L602.1 15.39,173.52 15.16,173.76 14.76,173.76 C118.1 v1(14.45,172.45)
SATA_RXP0_C_N: length 2.8
  TOP w0.102: v1(16.47,148.13) 16.86,148.53 C151.1 17.72,148.81 17.72,149.58 17.47,149.83 L604.4
SATA_RXP1_C_N: length 2.9
  TOP w0.102: v1(14.13,175.34) 14.45,175.02 C119.1 14.81,173.97 15.16,173.97 15.39,174.2 L602.4
SATA_TXN0_C_N: length 2.8
  TOP w0.102: L603.1 18.28,143.22 18.07,143 18.07,142.18 C142.1 19.02,141.92 v1(19.31,141.63)
SATA_TXN1_C_N: length 2.9
  TOP w0.102: v1(15.92,171.93) L601.4 15.39,170.77 15.18,170.57 14.78,170.57 C115.1
SATA_TXP0_C_N: length 2.8
  TOP w0.102: v1(16.44,141.86) 16.5,141.92 C141.1 17.85,142.34 17.85,143 17.6,143.25 L603.4
SATA_TXP1_C_N: length 2.7
  TOP w0.102: L601.1 15.39,170.09 15.13,170.35 14.78,170.35 C114.1 v1(14.45,169.01)
SATAHDR_RX_DN0: length 71.3
  TOP w0.102: v4(75.38,155.12) 75.06,155.45 CPU1.F20 ; 17.92,152.81 17.92,155.05 20.87,158 55.46,158 58.74,154.72 61.56,154.72 61.69,154.6 61.69,154.42 v3(61.45,154.18) ; 17.92,152.81 17.92,151.64 18.15,151.41 L604.2 ; 17.92,152.81 v1(18.27,152.81)
  L3 w0.127: v4(75.38,155.12) 75.34,155.12 74.8,155.66 71.19,155.66 67.62,159.23 66.15,159.23 65.28,158.36 65.28,156.05 64.68,155.45 61.98,155.45 61.67,155.13 61.67,154.39 v3(61.45,154.18)
SATAHDR_RX_DN1: length 80.9
  TOP w0.102: L602.2 17.41,173.52 17.52,173.63 18.24,173.63 18.47,173.41 18.47,165.99 19.45,165.01 19.45,164.59 ; v3(66.96,161.67) 66.45,162.18 65.64,162.18 64.89,161.43 60.52,161.43 59.9,160.81 59.9,158.75 59.46,158.31 56.92,158.31 55.98,159.25 21.55,159.25 19.45,161.34 19.45,164.59 ; 19.45,164.59 v1(19.08,164.59) ; CPU1.G21 75.71,156.6 v4(76.08,156.97)
  L3 w0.127: v3(66.96,161.67) 67.13,161.84 67.13,162.62 67.77,163.27 71.33,163.27 74.61,159.99 75.29,159.99 76.08,159.21 v4(76.08,156.97)
SATAHDR_RX_DP0: length 71.6
  TOP w0.102: v1(19.08,157.02) 19.34,156.77 ; 19.34,156.77 20.78,158.22 55.55,158.22 58.83,154.94 61.65,154.94 61.91,154.68 61.91,154.23 61.96,154.18 v3(62.34,154.18) ; 19.34,156.77 17.71,155.14 17.71,151.66 17.47,151.43 L604.3 ; CPU1.E20 74.41,155.19 74.48,155.12 v4(74.73,155.12)
  L3 w0.127: v3(62.34,154.18) 62.06,154.18 61.93,154.31 61.93,155.02 62.09,155.18 64.79,155.18 65.54,155.94 65.54,158.25 66.26,158.97 67.51,158.97 71.08,155.4 74.61,155.4 74.73,155.27 v4(74.73,155.12)
SATAHDR_RX_DP1: length 80.5
  TOP w0.102: 18.69,169.9 18.69,166.08 19.67,165.1 19.67,161.43 21.64,159.46 56.06,159.46 57,158.52 59.37,158.52 59.68,158.84 59.68,160.9 60.43,161.65 64.8,161.65 65.55,162.39 66.54,162.39 66.81,162.13 67.55,162.13 v3(67.6,162.18) ; 18.69,169.9 v1(19.03,169.9) ; 18.69,169.9 18.69,173.5 18.33,173.85 17.85,173.85 17.79,173.91 17.79,174.12 17.7,174.2 L602.3 ; v4(75.38,156.95) 75.38,156.68 75.19,156.49 CPU1.F21
  L3 w0.127: v4(75.38,156.95) 75.47,156.95 75.81,157.3 75.81,159.1 75.18,159.73 74.5,159.73 71.22,163 67.89,163 67.44,162.56 67.44,162.33 v3(67.6,162.18)
SATAHDR_TX_DN0: length 69.4
  TOP w0.089: CPU1.B21 71.89,156.56 arc(71.8,156.51) 71.69,156.49 71.53,156.49 71.32,156.28 70.23,156.28 70.06,156.11 69.73,156.11 69.72,156.1 69.69,156.1
  TOP w0.102: v1(21.88,157.02) 21.88,157.38 ; 21.88,157.38 55.2,157.38 59.18,153.4 64.33,153.4 67.03,156.1 69.69,156.1 ; 21.88,157.38 21.19,157.38 19.17,155.36 19.17,149.77 20.35,148.59 20.35,147.29 18.28,145.22 L603.2
SATAHDR_TX_DN1: length 69.3
  TOP w0.089: CPU1.D21 73.16,157.06 73.01,157.16 72.58,157.16 72.46,157.22 72.21,157.22 72.08,157.16 71.93,157.16 71.81,157.22 71.8,157.22 71.79,157.22 71.41,157.22 71.12,156.93 69.65,156.93 69.63,156.95 69.61,156.95
  TOP w0.102: v1(18.7,161.85) 18.45,161.6 ; 18.45,161.6 21.2,158.84 55.81,158.84 59.08,155.56 62.09,155.56 62.6,155.05 64.68,155.05 66.58,156.95 69.61,156.95 ; 18.45,161.6 18.07,161.98 18.07,170.36 17.83,170.6 17.55,170.6 17.37,170.77 L601.3
SATAHDR_TX_DP0: length 69.3
  TOP w0.089: 69.69,156.31 69.72,156.31 69.73,156.3 69.98,156.3 70.15,156.47 71.24,156.47 71.54,156.77 CPU1.A21
  TOP w0.102: 18.96,154.81 18.96,155.45 21.1,157.59 55.29,157.59 59.27,153.62 64.24,153.62 66.94,156.31 69.69,156.31 ; 18.96,154.81 v1(18.6,154.81) ; 18.96,154.81 18.96,149.68 20.14,148.5 20.14,147.38 17.6,144.85 L603.3
SATAHDR_TX_DP1: length 69.2
  TOP w0.089: CPU1.C21 72.99,156.57 72.91,156.49 72.74,156.49 72.64,156.58 72.64,156.9 72.57,156.97 72.44,157.03 72.25,157.03 72.12,156.98 72.07,156.97 71.92,156.97 71.79,157.03 71.49,157.03 71.2,156.74 69.65,156.74 69.63,156.73 69.61,156.73
  TOP w0.102: 17.85,168.83 17.85,161.89 19.24,160.5 21.12,158.62 55.72,158.62 58.99,155.35 62,155.35 62.51,154.83 64.77,154.83 66.67,156.73 69.61,156.73 ; 17.85,168.83 17.85,170.27 17.74,170.38 17.58,170.38 17.29,170.09 L601.2 ; 17.85,168.83 v1(17.48,168.83)
SB3V: length 973
  TOP w0.254: 97.29,130.84 R1115.1 R1109.1 ; 97.29,130.84 99.42,130.84 100.01,130.24 100.01,128.82 R80039.1 R1837.1 ; 97.29,130.84 93.4,130.84 92.64,130.07 92.64,129.51 92.44,129.31 92.44,127.89 ; PR5218.1 22.7,148.46 PR5212.1 21.5,147.57 v3(20.99,147.07) 19.46,145.54 19.46,144.88 19.82,144.53 19.82,142.27 20.38,141.71 20.38,140.63 R80159.2 ; R6702.1 85.76,61.21 85,60.45 v3(81.19,60.45) ; R80160.2 34.96,137.79 v3(35.59,137.16) ; R80202.1 R80201.1 28.86,12.24 29.75,11.35 29.75,9.4 v5(30.01,9.14) ; v3(164.12,168.53) 163.8,168.85 R80245.2 R80244.2 ; R5216.1 111.11,23.23 111.11,20.21 112.27,19.05 113.32,19.05 v3(114.59,17.78) ; R80253.2 80.3,222.82 v3(80.3,225.55) ; PR5246.1 85.11,123.06 88.43,123.06 PU5302.9 89.7,122.11 PR5257.1 ; R8513.1 21.56,186.82 R8511.1 19.86,187.25 18.73,187.25 18.12,186.64 16.85,186.64 14.74,184.53 v3(14.38,184.53) ; v3(146.59,55.75) 146.72,55.88 R8514.1 ; v3(155.54,26.48) PR4509.1
  TOP w0.305: v3(46.58,8.59) R775.1 46.45,9.27 44.86,9.27 C579.1 ; R9909.1 48.1,224.71 48.1,225.23 v3(47.91,225.43) ; R731.1 37.56,21.97 35.59,21.97 34.15,23.42 33.92,23.42 33.21,24.13 ; v3(32.42,24.13) 33.21,24.13 ; 33.21,24.13 34.04,24.96 34.04,26.02 R742.1 ; v3(41.44,225.43) 41.1,225.09 41.1,224.65 R9929.1 ; R80040.1 106.84,119 v3(107.09,118.75)
  TOP w0.381: R1824.1 85.76,132.31 85,131.55 R1135.1 84.87,131.44 v3(83.98,131.44) ; R80133.2 R80134.2 68.36,142.24 v3(68.49,142.11) ; R2091.1 146.4,33.08 v3(146.72,33.4) ; v3(80.04,136.27) 79.98,136.21 R1124.1 78.33,136.02 R1108.1 ; v3(51.34,79.88) 51.4,79.82 R531.1 ; v3(70.57,139.6) 70.57,139.73 70.2,140.09 R1127.1 ; R1838.1 159.99,118.55 v3(160.18,118.75) ; R80132.2 75.42,140.2 v3(75.42,139.73) ; v3(35.59,137.16) v3(35.59,131.57)
  TOP w0.508: R79691.1 42.9,118.24 v3(42.32,118.24) ; v3(26.58,31.75) 26.83,31.75 27.91,30.67 R1758.2 ; v5(63.15,67.31) 66.2,70.36 v3(66.58,70.36) ; MEJ1.1 110.4,112.01 114.71,112.01 115.48,111.25 115.48,110.62 ; R378.1 33.75,4.64 34.07,4.32 36.86,4.32 v3(37.37,4.83) ; v3(72.44,131.84) 75.17,131.84 77.44,134.11 R1123.1 R1108.1 ; v3(37.63,129.29) R341.2 ; R79934.1 R337.1 147.29,77.6 v3(146.59,77.6) ; v3(148.62,39.5) 148.55,39.42 148.55,35.23 v3(146.72,33.4)
  L3 w0.254: v3(14.38,184.53) 14.38,184.4 13.2,183.22 13.2,154.9 20.99,147.12 v3(20.99,147.07)
  L3 w0.305: v3(81.44,217.81) 81.44,224.41 v3(80.3,225.55) 79.62,226.23 59.06,226.23 58.42,225.59 50.34,225.59 49.94,225.98 48.34,225.98 47.91,225.55 v3(47.91,225.43) 47.35,225.98 41.97,225.98 41.44,225.45 v3(41.44,225.43)
  L3 w0.381: v3(114.59,17.78) 113.57,16.76 113.57,10.31
  L3 w0.508: v3(51.34,79.88) 52.59,78.64 52.59,74.81 54.37,73.03 62.26,73.03 64.93,70.36 v3(66.58,70.36) ; v3(70.57,139.6) 70.57,139.75 71.18,140.36 74.79,140.36 v3(75.42,139.73)
  L3 w0.762: v5(41.94,4.83) 41.94,5.08 45.45,8.59 v3(46.58,8.59) 48.72,8.59 49.82,7.49 v3(49.82,7.21)
  L3 w1.016: v5(95.41,10.41) 96.3,9.53 99.22,9.53 99.52,9.22 107.98,9.22 109.07,10.31 116.84,10.31 120.7,6.45 128.43,6.45 130.95,3.94 139.2,3.94 144.76,9.5 147.73,9.5 149.26,11.03 v5(149.26,11.18)
  L4 w0.254: v3(146.59,77.6) 147.73,78.74 147.73,80.39 150.86,83.52 153.47,83.52 154.84,82.15 157.24,82.15 157.89,82.8 157.89,86.26 v3(158.63,87) ; v3(81.06,67.31) 81.03,67.34 63.18,67.34 v5(63.15,67.31) ; v3(69.38,191.13) 69.38,192.43 75.61,198.67 78.87,198.67 79.19,198.98 80.8,198.98 83.47,201.65 83.47,203.33 81.44,205.36 v3(81.44,217.81)
  L4 w0.381: v3(41.44,225.43) 40.84,224.83 34.71,224.83 34.07,225.47 34.07,225.63 33.3,226.4 23.87,226.4 22.26,224.79 14.05,224.79 12.77,223.51 12.77,217.94 15.14,215.57 15.14,185.16 14.51,184.53 v3(14.38,184.53) ; v3(117.64,104.65) 117.64,103.8 115.15,101.32 107.63,101.32 v3(106.46,102.49) ; v3(20.99,147.07) 21.46,147.54 23.94,147.54 29.99,141.48 30.94,141.48 35.26,137.16 v3(35.59,137.16) ; v3(83.98,131.44) 84.74,131.44 89.19,127 v3(94.78,127) ; v3(157.64,100.33) 157.73,100.42 157.73,107.86 v3(157.13,108.46) 157.13,108.84 160.18,111.89 v3(160.18,118.75)
  L4 w0.508: v3(42.32,118.24) 42.4,118.16 42.4,95.63 40.52,93.75 40.52,93.2 41.14,92.58 v3(41.18,92.58) 40.52,91.92 40.52,85.47 46.11,79.88 v3(51.34,79.88) ; v3(72.44,131.84) 72.07,131.47 71.51,131.47 47.12,131.47 44.23,134.37 38.26,134.37 35.59,137.03 v3(35.59,137.16) ; v3(26.58,31.75) 26.4,31.75 25.92,31.26 25.92,29.54 29.33,26.12 30.95,26.12 32.42,24.66 v3(32.42,24.13) ; v3(37.37,4.83) 37.37,4.95 37.9,5.49 41.28,5.49 v5(41.94,4.83) ; v3(35.59,131.57) 35.69,131.47 35.69,131.3 36.79,130.2 36.88,130.2 37.63,129.46 v3(37.63,129.29) 37.8,129.29 43.26,123.83 44.48,123.83 45.25,123.06 v3(45.25,122.17)
  L4 w0.762: v3(37.37,4.83) 32.19,4.83 29.78,7.24 29.78,8.92 v5(30.01,9.14)
  L4 w1.016: v5(138.21,105.66) 139.58,105.66 143.42,101.83 152.97,101.83 154.47,100.33 v3(157.64,100.33)
  BOTTOM w0.254: v3(158.63,87) 163.74,87 v3(165.26,88.52) ; v3(81.19,60.45) 80.68,60.96 80.68,62.1 80.93,62.36 80.93,67.18 v3(81.06,67.31) ; 131.92,51.88 R253.1 130.91,49.53 R79930.2 ; R80167.2 R80168.2 145.42,57.68 146.59,56.52 v3(146.59,55.75) 146.59,53.83 145.27,52.5 136.93,52.5 R1993.2 135.22,52.58 134.15,52.58 133.89,52.32 ; R80109.2 158.34,109.66 v3(157.13,108.46)
  BOTTOM w0.305: R79927.1 74.95,70.15 70.81,70.15 70.21,69.56 70.21,69.02 69.69,68.5 64.29,68.5 63.15,67.37 v5(63.15,67.31)
  BOTTOM w0.381: v3(72.44,131.84) 72.8,132.21 72.8,132.84 70.65,135 v2(70.65,137.57) 70.65,139.52 v3(70.57,139.6) 70.57,140.03 v3(68.49,142.11) ; Q9644.E 109.95,120.84 108.75,119.63 v2(108.64,119.63) 107.9,119.63 107.09,118.83 v3(107.09,118.75) ; 81.63,140.02 R1822.1 ; 81.63,140.02 81.38,139.76 R1137.1 ; 81.63,140.02 82,139.65 v3(82.08,139.65) ; R1137.1 80.55,138.73 80.64,138.65 80.64,136.87 v3(80.04,136.27) ; R1137.1 R1832.2 ; PR5106.1 v3(81.44,217.81)
  BOTTOM w0.508: R80248.1 171.42,153.48 v3(171.74,153.16) ; 155.35,27.05 149,33.4 v3(146.72,33.4) ; v3(106.46,102.49) 106.46,108.58 103.97,111.07 103.97,122.3 100.32,125.95 v2(98.2,125.95) 95.66,125.95 94.78,126.83 v3(94.78,127) 94.33,127 R80035.1 R1833.2 ; v3(80.04,136.27) 80.55,136.27 81.11,135.71 81.11,133.36 81.9,132.57 v2(81.9,132.56) 81.9,132.56 83.15,131.32 83.85,131.32 v3(83.98,131.44) ; v3(41.18,92.58) 41.24,92.65 R79689.1 ; Q9601.D 63.13,67.28 v5(63.15,67.31) ; 27.4,31.75 v3(26.58,31.75) 26.4,31.75 25.92,32.24 25.92,33.63 26.58,34.29 R1734.1 ; 27.4,31.75 R1731.1 ; 27.4,31.75 R1733.1 ; v5(30.01,9.14) 28.74,10.41 R1785.1 R1752.1 29.12,11.43 30.89,13.21 30.89,16.76 v2(31.8,17.67) 32.35,18.22 32.35,23.94 32.42,24 v3(32.42,24.13) 32.48,24.19 R755.2 ; v3(107.09,118.75) 107.09,117.98 110.34,114.74 110.34,111.95 MEJ1.1 ; v3(42.32,118.24) 43.09,118.24 45.25,120.4 v3(45.25,122.17) ; v3(148.62,39.5) 144.53,39.5 v2(142.7,41.33) 142.25,41.78 140.98,41.78 139.84,42.93 137.15,42.93 134.27,45.8 134.27,51.18 133.64,51.82 ; R79806.1 v3(51.34,79.88)
  BOTTOM w1.016: v5(167.57,98.42) 165.92,96.77 160.69,96.77 157.64,99.82 v3(157.64,100.33) ; v5(95.41,10.41) 91.22,10.41 87.66,6.86 87.66,4.06 86.9,3.3 v2(69.63,3.3) 56.55,3.3 53.88,5.97 50.83,5.97
  vias: v2(132.85,62.59) v2(159.32,25.98) v5(148.37,205.99) v5(149.39,205.99) v5(150.4,205.99) v5(150.53,12.7) v5(150.53,11.56) v5(156.85,27.05) v5(157.77,27.05) v5(158.68,27.05) v5(165.26,202.69) v5(165.26,201.68)
SB3V_EN: length 8.3
  BOTTOM w0.102: C1700.1 144.32,8.26 144.43,8.26 144.64,8.05 145.38,8.05 145.44,8.11 U54.3 ; C1700.1 144.65,8.97 145.38,8.97 145.44,8.91 U54.5 ; C1700.1 144.13,9.07 143.81,9.38 v2(143.59,9.38) 143.54,9.38 143.16,9 R1980.1 142.4,8.45 PR5431.2
SB5_33_CT1: length 2.9
  BOTTOM w0.102: U54.12 149.43,8.11 v2(149.92,7.62) 150.46,7.62 C1929.1
SB5_33_CT2: length 2.8
  BOTTOM w0.102: C1928.1 150.67,9.32 v2(149.89,9.32) 149.69,9.32 149.28,8.91 U54.10
SB5V: length 913.5
  TOP w0.254: PR5306.1 122.97,80.34 v3(122.87,80.44)
  TOP w0.305: 24.42,161.29 25.42,161.29 25.56,161.43 PU5003.4
  TOP w0.381: v3(147.48,111) 147.48,111.82 R117.1 ; v3(29.95,202.55) 30.82,202.55 31.91,201.46 PC4616.1
  TOP w0.406: U704.3 38.7,141.6 38.39,141.91 37.71,141.91 37.24,141.45 v3(37.24,141.35) ; U706.3 v3(49.24,144.15)
  TOP w0.508: v3(164.5,211.33) 164.37,211.33 149.58,226.12 111.93,226.12 110.78,227.27 92.17,227.27 v3(91.85,226.95) ; v3(107.98,109.73) 107.98,111.51 106.59,112.9 104.21,112.9 100.65,116.46 88.62,116.46 81.23,123.85 80.55,123.85 80.45,123.75 v3(80.27,123.75) ; R250.2 143.92,38.35 144.56,37.72 146.46,37.72 146.97,37.21 146.97,36.07 146.36,35.46 146.36,34.49 v3(145.74,33.87) ; v3(24.29,160.4) 23.66,160.4 23.27,160.78 PC5004.1 24.42,161.29 ; PR4639.1 32.29,211.2 v3(32.16,211.33)
  TOP w0.762: v3(168.54,100.46) 159.8,100.46 158.4,101.85 v3(156.37,101.85) 155.61,101.85 154.08,103.38 v3(154.08,108.33)
  L3 w0.254: v3(136.69,108.71) 139.48,105.92 139.48,104.27 138.34,103.12 138.34,82.68 137.32,81.66 137.32,76.7 134.28,73.66 124.87,73.66 122.72,75.82 122.72,80.24 122.87,80.39 v3(122.87,80.44)
  L3 w0.381: v3(29.95,202.55) 29.73,202.55 28.61,201.42 28.61,200.18 26.68,198.25 26.68,189.33 24.93,187.58 22.05,187.58 19.15,184.68 19.15,168.02 22.32,164.85 24.16,164.85 25.43,163.58 25.43,161.54 v3(24.29,160.4) 22.39,158.5 22.39,144.52 25.55,141.35 v3(37.24,141.35)
  L3 w0.508: v3(154.08,108.33) 153.7,108.71 149.77,108.71 v3(147.48,111) v3(134.78,111) 125.89,111 124.37,109.47 122.59,109.47 120.18,111.89 108.36,111.89 107.98,111.51 v3(107.98,109.73) ; v3(91.85,226.95) 89.95,225.04 84.11,225.04 83.47,224.41 v3(83.47,217.81) ; v3(29.95,202.55) 29.95,203.13 27.34,205.74 27.34,206.52 25.45,208.41 v3(25.18,208.41)
  L4 w0.381: v3(32.16,211.33) 30.68,209.85 26.62,209.85 v3(25.18,208.41)
  L4 w0.406: v3(49.24,144.15) 45.75,144.15 43.7,142.09 42.83,142.09 42.1,141.35 v3(37.24,141.35)
  L4 w0.508: v5(148.5,4.7) 148.85,4.34 148.85,3.38 147.58,2.11 24.9,2.11 22.13,4.88 22.13,13.46 22.03,13.56 22.03,15.41 23.61,16.99 28.37,16.99 29.65,18.27 29.65,18.44 v3(29.75,18.54) ; v3(154.08,108.33) 155.48,108.33 158.86,111.71 158.86,121.64 160.91,123.7 164.5,123.7 166.47,125.67 167.49,125.67 169.03,127.21 169.03,148.55 170.24,149.76 170.24,154.45 169.8,154.89 168.58,154.89 163.42,160.06 163.42,202.51 164.68,203.77 165.83,203.77 166.72,204.67 166.72,209.16 164.78,211.11 164.72,211.11 v3(164.5,211.33) ; v3(80.27,123.75) 80.27,124.6 78.89,125.98 77.86,125.98 75.95,127.88 75.95,128.92 73.37,131.5 73.37,131.94 70.7,134.61 62.25,134.61 62.16,134.52 56.46,134.52 56.07,134.12 56.07,134.11 55.26,133.3 48.06,133.3 45.65,135.7 38.55,135.7 37.24,137.01 v3(37.24,141.35)
  L4 w0.635: v3(145.74,33.87) 144.67,32.8 130.75,32.8 129.99,32.05 129.99,30.89 129.07,29.97 126.3,29.97 124.37,28.04 124.37,19.94 123.62,19.19 123.62,9.9 124.39,9.13 127.78,9.13 129.83,11.18 144.56,11.18 149.28,6.45 v5(149.28,6.43)
  BOTTOM w0.203: v3(29.95,202.55) 29.63,202.55 29.43,202.35 PU4601.18
  BOTTOM w0.254: v3(136.69,108.71) 136.69,109.09 v2(135.8,109.98) v3(134.78,111)
  BOTTOM w0.305: U9628.1 160.19,103.52 160.05,103.38
  BOTTOM w0.406: CN3.1 82.43,123.83 80.53,123.83 80.45,123.75 v3(80.27,123.75)
  BOTTOM w0.457: PR4652.1 25.81,207.77 v3(25.18,208.41)
  BOTTOM w0.508: v2(48.43,144.15) v3(49.24,144.15) ; 160.05,103.38 158.47,101.79 C12365.1 156.43,101.79 v3(156.37,101.85) ; R79726.1 R389.1 31.35,19.76 30.13,18.54 v3(29.75,18.54) 29.75,18.24 R735.1 R724.1 27.76,17.53 v2(26.78,18.51) 25.59,18.51 R1759.1 ; PR5118.2 85.29,217.81 v3(83.47,217.81) 83.41,217.74 PR5105.2
  BOTTOM w0.635: v3(168.54,100.46) 168.54,94.89 169.83,93.6 169.83,88.27 171.46,86.64 171.46,84.96 170.98,84.48 170.98,75.31 166.66,70.99 166.66,68.58 165.51,67.44 165.51,61.72 167.62,59.61 167.62,36.14 163.01,31.52 151.91,31.52 v2(149.77,33.66) 149.01,34.42 146.29,34.42 v3(145.74,33.87)
  vias: v1(137.96,42.8)
SCALAR_ACK: length 134.9
  TOP w0.102: R80173.1 66.57,81.66 63.98,79.07 62.99,79.07 60.62,76.7 SCA1.53 60.62,74.43 v3(60.49,74.3) ; v4(78.01,144.02) 77.85,144.18 CPU1.M1 ; v3(81.47,126.03) 81.18,126.03 79.13,123.98 73.29,123.98 72.78,123.47 72.78,122.64 70.7,120.56 66.17,120.56 63.04,123.7 v3(46.52,123.7)
  L3 w0.127: v3(46.52,123.7) 46.52,122.76 44.23,120.48 44.23,115 42.65,113.42 42.65,91.58 44.83,89.41 44.83,87.48 50.83,81.47 52.19,81.47 54.11,79.55 57.59,79.55 59.47,77.67 59.47,75.31 v3(60.49,74.3)
  BOTTOM w0.102: v3(81.47,126.03) 79.28,126.03 76.82,128.49 v2(76.82,133.35) 76.82,133.81 78.14,135.13 78.14,141.12 77.58,141.68 77.58,143.59 v4(78.01,144.02)
SCALAR_EN: length 88.8
  TOP w0.102: U109.120 143.77,59.77 143.19,60.35 143.12,60.35 142.32,61.15 142.32,62.29 142.69,62.66 142.97,62.66 143.92,63.62 v1(143.92,66.47) 143.72,66.67 v3(143.04,66.67)
  L4 w0.127: v3(76.74,71.5) 81.14,75.9 89.24,75.9 89.99,75.15 89.99,71.39 92.72,68.66 93.25,68.66 97.75,68.66 101.23,65.18 101.94,65.18 102.24,64.88 127.66,64.88 130.48,67.7 137.05,67.7 137.79,66.97 138.43,66.97 138.43,66.97 140.95,66.97 141.13,67.14 141.96,67.14 142.43,66.67 v3(143.04,66.67)
  BOTTOM w0.102: R79809.2 R79927.2 76.17,70.93 v3(76.74,71.5)
SCALAR_EN_G: length 5
  BOTTOM w0.102: R79809.1 75.28,68.64 74.89,68.25 v2(74.61,68.25) 74.61,68.57 73.48,69.7 72.92,69.7 72.55,69.32 PQ5007.2
SCALAR_MUTE: length 130.5
  TOP w0.102: R79188.2 v3(71.69,73.66) 70.93,72.9 SCA1.35
  L4 w0.127: v3(71.69,73.66) 74.3,76.28 89.4,76.28 90.37,75.3 90.37,71.55 92.88,69.04 97.91,69.04 101.39,65.56 102.1,65.56 102.39,65.27 127.51,65.27 130.33,68.08 137.21,68.08 137.95,67.35 140.79,67.35 140.96,67.53 142.12,67.53 142.5,67.14 151.96,67.14 155.65,63.46 157.78,63.46 158.71,64.39 v3(158.78,64.39)
  BOTTOM w0.102: v3(158.78,64.39) 159.16,64.39 v2(165.51,58.04) 166.83,56.72 166.83,41.96 166.28,41.4 Q9627.2
SCALAR_OUT_L: length 9.1
  TOP w0.203: C12192.1 68.74,77.6 v1(68.49,77.85) 67.75,78.59 66.07,78.59 64.62,77.14 SCA1.45
SCALAR_OUT_L_C: length 98.9
  TOP w0.203: v3(157.13,64.52) 157.31,64.34 157.31,64.27 157.51,64.07 157.51,63.5 157.25,63.24 U9615.2 ; C12192.2 v3(73.19,77.6)
  L4 w0.203: v3(73.19,77.6) 73.74,78.16 84.44,78.16 84.95,78.66 89.31,78.66 91.75,76.23 91.75,73.95 93.14,72.57 97.52,72.57 103.44,66.65 126.93,66.65 129.75,69.47 138.26,69.47 138.46,69.67 150.32,69.67 150.66,69.34 153.53,69.34 157.13,65.74 v3(157.13,64.52)
  BOTTOM w0.203: v2(157.13,63.7) v3(157.13,64.52)
SCALAR_OUT_R: length 9.9
  TOP w0.203: SCA1.46 64.12,77.46 65.83,79.17 68.18,79.17 68.87,78.49 v1(70.14,78.49) C12193.1
SCALAR_OUT_R_C: length 100.2
  TOP w0.203: U9615.10 158.67,63.74 v3(157.89,64.52) ; C12193.2 73.19,78.49 v3(74.07,77.6)
  L4 w0.203: v3(157.89,64.52) 157.39,64.01 156.92,64.01 154.85,66.08 154.85,67.01 153.11,68.75 150.27,68.75 149.93,69.09 138.7,69.09 138.5,68.88 129.99,68.88 127.18,66.07 102.73,66.07 102.43,66.36 101.72,66.36 96.1,71.98 94.4,71.98 92.9,71.98 91.17,73.71 91.17,75.92 89.92,77.17 74.51,77.17 v3(74.07,77.6)
  BOTTOM w0.203: v2(157.89,65.48) v3(157.89,64.52)
SCALAR_PC_SW1: length 5.8
  BOTTOM w0.152: Q9602.E 70.13,65.44 71.86,63.7 71.86,62.98 R9601.2 v2(72.33,61.26)
SCALAR_PC_SW2: length 5.4
  BOTTOM w0.152: R9602.2 R9603.1 72.33,65.01 71.61,65.74 v2(71.02,65.74) 69.44,67.32 Q9602.B
SCALAR_PC_SW3: length 7.2
  BOTTOM w0.152: Q9602.C 67.36,66.6 v2(66.1,66.6) 65.8,66.9 64.46,66.9 R9605.1 64.42,65.85 R9604.1 64.36,64.71 C12171.1 63.43,64.64 Q9601.G
SCALAR_PC_SW4: length 5.3
  BOTTOM w0.152: PQ5007.5 72.55,66.29 v2(73.19,65.65) ; PQ5007.6 71.9,66.26 72.5,65.65 v2(73.19,65.65) ; v2(73.19,65.65) 73.22,65.62 R9603.2
SCALAR_PC_SW5: length 9.7
  BOTTOM w0.152: PQ5007.3 73.2,68.29 73.06,68.15 65.88,68.15 v2(65.49,67.75) R9605.2
SCALAR_SIO_PU: length 63.2
  TOP w0.102: v3(128.43,46.61) 127.99,47.05 R277.1 127.03,47.05 126.89,46.91 126.89,45.07 127.17,44.78 128.13,44.78 128.24,44.89 R318.1 ; R1946.1 R317.2 142.27,71.06 ; 142.27,71.06 142.27,72.53 142.88,73.14 145.21,73.14 145.7,72.64 v3(146.59,72.64) ; 142.27,71.06 R79820.2 ; R316.2 147.04,68.52 v3(146.59,68.07)
  L3 w0.127: v3(146.59,72.64) 147.06,72.17 147.06,68.54 v3(146.59,68.07) 144.38,65.86 144.38,60.96 143.33,59.91 140.24,59.91 136.59,56.26 135.64,56.26 134.65,55.27 v3(134.65,54.1) 133.76,53.21 133.76,47.09 132.82,46.14 128.9,46.14 v3(128.43,46.61)
  BOTTOM w0.102: R79940.2 133.54,55.05 R305.2 132.33,55.08 R304.1 132.24,54.66 132.54,54.36 133.26,54.36 133.73,53.88 RN6.1 134.22,53.67 v3(134.65,54.1) 135.14,53.62 v2(135.14,53.31) 134.84,53.01 RN6.2
SD_CD#: length 22.2
  TOP w0.102: MEMCD1.11 168.22,133.03 171.86,136.68 171.86,145.03 v4(175.42,148.59)
  BOTTOM w0.102: U14.30 175.38,148.55 v4(175.42,148.59) 175.45,148.59 175.85,149 v2(176.11,149)
SD_CLK_C_1: length 23.3
  TOP w0.102: MEMCD1.5 164.85,147.22 164.73,147.09 164.73,146.57 164.63,146.47 163.33,146.47 163.23,146.37 163.23,146.17 163.33,146.06 164.63,146.06 164.73,145.96 164.73,145.52 164.85,145.39 165.31,145.39 165.41,145.49 165.41,146.41 165.53,146.53 165.7,146.53 165.82,146.41 165.82,145.49 165.92,145.39 166.12,145.39 166.23,145.49 166.23,146.41 166.34,146.53 166.51,146.53 166.63,146.41 166.63,145.49 166.73,145.39 166.94,145.39 167.04,145.49 167.04,146.34 167.16,146.46 167.33,146.46 167.44,146.34 167.44,145.54 167.59,145.39 168.08,145.39 v4(168.31,145.16)
  BOTTOM w0.102: R79846.2 C12376.1 167.97,141.03 166.98,142.02 v2(166.98,142.52) 166.98,144.6 167.55,145.16 v4(168.31,145.16)
SD_CMD: length 24.8
  TOP w0.102: v4(168.31,144.4) 168.74,144.83 169,144.83 169.13,144.7 169.13,141.43 169,141.3 166.91,141.3 166.78,141.17 166.78,140.87 166.91,140.74 169,140.74 169.13,140.61 169.13,140.34 169,140.21 168.21,140.21 168.08,140.08 168.08,139.83 168.21,139.7 169,139.7 169.13,139.57 169.13,137.72 169,137.59 168.69,137.59 168.56,137.72 168.56,138.96 168.44,139.09 168.1,139.09 167.98,138.96 167.98,138.23 167.85,138.1 167.57,138.1 167.45,138.23 167.45,138.79 167.32,138.91 167.07,138.91 166.94,138.79 166.94,138.18 166.84,138.07 166.02,138.07 165.9,138.2 165.9,138.71 166.02,138.84 166.28,138.84 166.41,138.96 MEMCD1.2
  BOTTOM w0.102: v2(167.52,144.4) v4(168.31,144.4) 168.82,143.89 R79847.2
SD_DAT0: length 21.1
  TOP w0.089: v3(169.58,152.65) 169.17,153.06 168,153.06 167.16,152.22 MEMCD1.7
  BOTTOM w0.089: v3(169.58,152.65) 168.88,152.65 C12378.1 168.33,152.82 168.11,152.82 167.89,152.6 167.89,149.72 166.38,148.21 166.38,141.2 167.17,140.41 ; v2(167.42,140.67) 167.17,140.41 ; 167.17,140.41 167.95,139.62 168.3,139.62 R79845.2
SD_DAT1: length 21.9
  TOP w0.089: v3(169.58,153.42) 167.67,153.42 167.24,153.85 MEMCD1.8
  BOTTOM w0.089: 166.03,145.29 166.03,148.35 167.55,149.86 167.55,152.74 167.97,153.16 168.37,153.16 C12379.1 168.75,153.42 v3(169.58,153.42) ; 166.03,145.29 v2(165.67,145.29) ; 166.03,145.29 166.03,141.34 166.03,141.06 167.81,139.28 168.28,139.28 R79844.2
SD_DAT2: length 23.5
  TOP w0.102: v4(168.31,146.69) 168.31,148.26 168.74,148.69 169.76,148.69 170.39,148.06 170.39,136.01 169.1,134.72 MEMCD1.9
  BOTTOM w0.102: R79849.2 169.01,146.94 C12380.1 168.44,146.81 v4(168.31,146.69) 168.28,146.69 v2(167.65,147.32)
SD_DAT3: length 24.9
  TOP w0.102: MEMCD1.1 166.41,135.86 166.53,135.74 166.88,135.74 166.98,135.84 166.98,136.17 167.08,136.27 167.39,136.27 167.49,136.17 167.49,135.84 167.59,135.74 167.89,135.74 168,135.84 168,136.37 168.12,136.5 168.38,136.5 168.5,136.37 168.5,135.84 168.6,135.74 169.3,135.74 169.43,135.86 169.43,148.26 169.3,148.39 168.87,148.39 168.74,148.26 168.74,146.35 v4(168.31,145.92)
  BOTTOM w0.102: R79848.2 C12381.1 v4(168.31,145.92) v2(167.52,145.92)
SD_LN0_M: length 4.4
  BOTTOM w0.089: U14.25 173.38,148.26 173.41,148.29 173.41,148.38 172.09,149.71 172.09,150.4 171.91,150.58 171.57,150.58 171.48,150.49 TP9911.1
SD_LN0_P: length 5
  BOTTOM w0.089: TP9910.1 171.48,151.01 171.57,150.92 172.05,150.92 172.43,150.54 172.43,149.85 173.76,148.52 173.76,148.29 173.79,148.26 U14.26
SD_LN1_M: length 5.9
  BOTTOM w0.089: TP9913.1 168.84,148.93 168.88,148.9 170.52,148.9 171.99,147.42 171.99,146.68 172.13,146.54 U14.23
SD_LN1_P: length 6.3
  BOTTOM w0.089: U14.22 172.05,146.14 171.65,146.54 171.65,147.28 170.38,148.55 168.74,148.55 168.57,148.72 168.05,148.72 TP9912.1
SD_RCOMP: length 4.1
  TOP w0.203: CPU1.AB7 83.2,148.06 v4(83.4,148.26)
  BOTTOM w0.203: v4(83.4,148.26) 83.4,148.24 82.71,147.55 v2(82.71,146.63) 82.71,146.58 82.58,146.46 R1901.1
SD_VDD2: length 5.3
  BOTTOM w0.203: U14.13 174.59,142.4
  BOTTOM w0.254: C311.1 172.73,139.32 173.26,139.85 173.35,139.85 C312.2 173.69,140.2 v2(173.69,140.97) 173.69,141.17 174.59,142.07 174.59,142.4
SD_WAKE#_IC: length 6.2
  BOTTOM w0.102: R80189.2 178.66,151.19 179.23,150.62 179.23,148.84 v2(178.44,148.06) 178.01,147.63 U14.32
SD_WAKE_N: length 181.2
  TOP w0.102: v3(70.36,146.26) 70.36,146.77 71.53,147.94 72.07,147.94 CPU1.B7
  L4 w0.127: v3(70.36,146.26) 71.92,144.7 71.92,141.99 73.02,140.88 73.02,135.37 75.09,133.3 75.09,131.67 76.51,130.25 77.29,129.47 77.29,128.44 77.79,127.94 78.82,127.94 83.82,122.94 85.97,122.94 87.69,121.21 112.45,121.21 120.18,113.49 120.18,109.74 121.41,108.51 124.74,108.51 125.46,107.78 142.69,107.78 147.06,103.42 151.74,103.42 153.07,104.74 153.07,108.65 158.28,113.85 158.28,122.2 161.38,125.31 163.36,125.31 166.76,128.71 166.76,149.32 168.57,151.13 v3(169.58,151.13)
  BOTTOM w0.102: R80189.1 178.6,152.53 175.98,155.14 172.96,155.14 v2(171.97,154.16) 171.76,154.37 R80248.2 170.09,153.73 170.09,151.64 v3(169.58,151.13)
SD_WP: length 14.8
  TOP w0.102: MEMCD1.10 171.58,155.66 v4(176.31,150.94)
  BOTTOM w0.102: v4(176.31,150.94) 176.31,151.43 177.04,152.16 v2(177.23,152.16) 177.33,152.06 R79851.2
SDIN: length 18.4
  TOP w0.102: R9502.2 75.85,54.66 74.96,55.55 v3(74.96,55.63) ; v3(61.5,56.13) 61.62,56.01 SCA1.116
  L4 w0.127: v3(74.96,55.63) 74.84,55.75 70.35,55.75 69.12,56.98 63.11,56.98 62.26,56.13 v3(61.5,56.13)
  BOTTOM w0.102: v2(75.09,56.52) 75.09,55.75 v3(74.96,55.63)
SDIN_1: length 3.1
  TOP w0.102: U9501.5 75.85,56.87 v1(75.55,56.57) 75.57,56.54 75.57,55.71 R9502.1
SDOUT: length 16.5
  TOP w0.102: R9506.1 71.53,59.56 v3(71.28,59.82) ; SCA1.117 62.12,57.03 v3(61.63,57.53)
  L4 w0.127: v3(71.28,59.82) 70.77,59.31 70.01,59.31 67.98,57.28 63.03,57.28 62.81,57.06 62.1,57.06 v3(61.63,57.53)
  BOTTOM w0.102: v3(71.28,59.82) 71.28,59.87 v2(70.49,60.66)
SDREG2:
  vias: v2(171.43,148.82)
SENSE_A: length 25
  TOP w0.102: v3(165.51,60.38) 165.51,61.07 R80174.2 ; v3(167.55,77.6) 167.09,78.05 166.35,78.05 166.15,77.85 U6.34
  L3 w0.102: v3(167.55,77.6) 167.09,78.05 166.59,78.05 166.33,77.79 166.33,73.61 167.06,72.88 168.13,71.81 168.13,68.41 165.51,65.79 v3(165.51,60.38)
  BOTTOM w0.102: v3(165.51,60.38) 165.51,60.6 v2(164.87,61.24)
SENSE_A_C: length 3.6
  TOP w0.102: Q9643.D 165.39,65.21 v1(165.39,63.22) R80174.1
SENSE_B: length 12.5
  TOP w0.102: v3(166.78,77.6) 166.64,77.45 U6.33 ; v3(169.07,70.74) 169.45,71.12 169.45,71.44 R266.2 R267.2
  L3 w0.102: v3(166.78,77.6) 166.71,77.52 166.71,73.55 168.36,71.9 168.36,71.45 v3(169.07,70.74)
  BOTTOM w0.102: v3(166.78,77.6) v2(166.78,76.78)
SER_IRQ_R: length 5.6
  TOP w0.102: U109.36 128.15,61.77 127.95,61.98 v1(127.16,61.98) 127.1,61.91 R80131.1 R264.1
SERIRQ_CPU: length 181.3
  TOP w0.089: CPU1.AY11 93.13,150.87 93.46,150.54 94.6,150.54 95.74,149.4
  TOP w0.102: v3(125.51,60.96) 125.45,61.02 R80131.2 ; 95.74,149.4 97.35,149.4 98.16,148.59 98.97,148.59 99.41,148.15 99.41,145.29 98.98,144.86 98.98,143.05 R2032.2 100.81,141.22 v1(101.25,141.22) 104.17,138.3 104.17,127 102.75,125.58 102.75,118.2 104.85,116.1 126.01,116.1 129.59,112.52 135.38,112.52 141.82,106.09 141.82,99.36 v3(140.88,98.42) ; R79704.2 96.45,48.55 97.33,48.55 97.53,48.55 99.09,46.99 104.43,46.99 109,51.56 111.54,51.56 112.05,52.07 112.05,55.5 v3(111.03,56.52)
  L3 w0.127: v3(111.03,56.52) 111.29,56.77 121.69,56.77 125.51,60.59 v3(125.51,60.96) 126.35,61.8 126.35,64.93 130.63,69.22 134.91,69.22 137.7,72.01 137.7,74.8 138.41,75.51 138.41,79.12 138.41,80.98 139.61,82.17 139.61,97.16 v3(140.88,98.42)
SHDN_MUTE_AP_CTL: length 4
  TOP w0.102: R9554.1 71.56,74.68 v1(71.43,74.55) 70.29,73.4 SCA1.36
SIDE_USB3_RX0+: length 10.1
  TOP w0.102: SSUSB1.6 174.12,114.05 174.02,113.95 173.66,113.95 173.08,114.54 169.09,114.54 168.96,114.67 U3.2 U3.9 167.1,114.67 166.97,114.54 166.51,114.54 166.26,114.28 165.84,114.28 165.6,114.51 L5.3
SIDE_USB3_RX0-: length 10.1
  TOP w0.102: SSUSB1.5 174.12,113.63 174.02,113.73 173.57,113.73 172.99,114.32 169.09,114.32 168.96,114.19 U3.1 U3.10 167.12,114.19 166.99,114.32 166.6,114.32 166.35,114.07 165.84,114.07 165.6,113.83 L5.2
SIDE_USB3_RX1+: length 11.8
  TOP w0.102: L57.3 165.48,95.46 165.71,95.23 166.21,95.23 166.46,95.49 166.84,95.49 166.97,95.62 U5.9 U5.2 168.84,95.62 168.97,95.49 169.67,95.49 170.49,94.67 170.49,93.7 170.98,93.22 173.01,93.22 173.78,92.45 174.02,92.45 174.12,92.55 SSUSB2.6
SIDE_USB3_RX1-: length 11.8
  TOP w0.102: SSUSB2.5 174.12,92.13 174.02,92.23 173.69,92.23 172.92,93 170.89,93 170.28,93.61 170.28,94.58 169.58,95.27 168.97,95.27 168.84,95.14 U5.1 U5.10 167,95.14 166.87,95.27 166.55,95.27 166.3,95.02 165.71,95.02 165.48,94.78 L57.2
SIDE_USB3_TX0+: length 12.5
  TOP w0.102: L4.3 165.6,116.67 165.84,116.44 166.28,116.44 166.66,116.06 166.99,116.06 167.12,116.19 U3.6 U3.5 168.96,116.19 169.09,116.06 170.32,116.06 171.23,116.97 171.23,118.62 171.61,119 172.63,119 173.57,119.95 174.02,119.95 174.12,120.05 SSUSB1.9
SIDE_USB3_TX0-: length 12.5
  TOP w0.102: L4.2 165.6,115.99 165.84,116.22 166.19,116.22 166.57,115.84 166.97,115.84 167.1,115.71 U3.7 U3.4 168.96,115.71 169.09,115.84 170.41,115.84 171.44,116.88 171.44,118.53 171.7,118.78 172.72,118.78 173.66,119.73 174.02,119.73 174.12,119.63 SSUSB1.8
SIDE_USB3_TX1+: length 10.7
  TOP w0.102: SSUSB2.9 174.12,98.55 174.02,98.45 173.33,98.45 172.94,98.06 171.04,98.06 169.97,96.99 168.98,96.99 168.84,97.14 U5.5 U5.6 166.99,97.14 166.86,97.01 166.53,97.01 166.14,97.39 165.71,97.39 165.48,97.62 L56.3
SIDE_USB3_TX1-: length 10.7
  TOP w0.102: L56.2 165.48,96.94 165.71,97.17 166.05,97.17 166.44,96.79 166.84,96.79 166.97,96.66 U5.7 U5.4 168.84,96.66 168.95,96.77 170.06,96.77 171.13,97.84 173.03,97.84 173.42,98.23 174.02,98.23 174.12,98.13 SSUSB2.8
SIO_AGND: length 27.6
  TOP w0.203: U109.84 138.21,47.86 ; 137.81,47.86 U109.83
  TOP w0.508: v3(141.13,46.74) 141.19,46.67 R79939.2 141.19,45.72 142.21,45.72 R259.2 C181.2 142.08,44.7 C183.2 ; C179.2 R80250.2 R252.2 C12385.2 145,46.42 v3(144.81,46.61)
  L3 w0.508: v3(141.13,46.74) 141,46.74 138.46,44.2 v3(138.46,43.94)
  L4 w0.508: v3(141.13,46.74) 144.69,46.74 v3(144.81,46.61)
  BOTTOM w0.254: R651.1 138.27,44.13 v3(138.46,43.94) 137.98,43.94 136.88,45.05 v2(136.88,45.97) 136.88,46.77 137.72,47.61 R399.1
  BOTTOM w0.508: C184.2 141.82,47.56 R400.1 141.77,47.37 v3(141.13,46.74)
SIO_AMD SVID_EN: length 10.1
  TOP w0.102: U109.26 133.01,65.41 132.8,65.62 132.8,66.1 133.42,66.73 134.42,66.73 v1(134.48,66.78) 136.02,66.78 139.35,70.1 R296.1
SIO_ATXPG: length 27.4
  TOP w0.102: R80149.1 150.66,73.6 R80150.1 R290.1 153.4,71.74 153.4,69.24 v1(153.22,69.06) 153.22,68.48 v3(152.94,68.2) ; U109.16 137.01,66.11 138.97,68.07 v3(139.23,68.07)
  L4 w0.127: v3(139.23,68.07) 139.69,68.54 149.12,68.54 149.46,68.2 v3(152.94,68.2)
SIO_AVCC3: length 0.5
  TOP w0.203: U109.96 143.54,49.02
  vias: v1(146.44,47.5)
SIO_CE_N: length 18.2
  TOP w0.102: U109.27 132.61,63.79 134.55,61.85 v3(135.67,61.85)
  BOTTOM w0.102: U9602.1 140.88,53.98 139.73,55.12 137.05,55.12 136.74,55.44 136.74,56.08 136.25,56.57 136.25,58.85 v2(135.72,59.39) 135.72,59.74 136.13,60.15 136.13,60.77 135.64,61.26 135.31,61.26 R308.1 134.97,61.85 v3(135.67,61.85)
SIO_CLK_DB: length 8.9
  TOP w0.102: RN7.2 122.92,55.7 123.6,55.02 123.84,55.02 124.16,54.69 124.16,54.67 124.43,54.41 125.57,54.41 126.25,55.08 126.25,56.02 v1(126.77,56.55) 127.19,56.97 U109.48
SIO_COPEN#: length 10.3
  TOP w0.102: U109.65 129.93,49.02 128.99,49.96 126.67,49.96 125.68,48.97 122.49,48.97 v1(122.21,48.69) 122.17,48.65 121.29,48.65 R303.1
SIO_DAT_DB: length 8.4
  TOP w0.102: U109.49 127.58,56.57 126.47,55.46 126.47,54.99 125.67,54.18 123.83,54.18 v1(123.63,54.38) 122.96,55.05 RN7.1
SIO_DEBUG_RX: length 4.2
  TOP w0.102: R79947.1 147.1,62.36 TP104.1 146.34,61.59 146.34,61.21 145.69,60.57 U109.122
SIO_DEBUG_TX: length 3.7
  TOP w0.102: R79946.1 147.28,61.34 TP103.1 146.1,60.17 U109.121
SIO_GREEN: length 158.6
  TOP w0.203: 134.21,63.56 U109.23
  TOP w0.254: 134.21,63.56 135.36,62.41 135.86,62.41 136.71,61.56 136.71,58.7 135.14,57.12 135.14,54.38 v3(135.42,54.1) ; 24.67,14.48 Q9646.5 ; 24.67,14.48 24.67,13.46 24.29,13.08 v3(23.27,13.08) ; 24.67,14.48 Q9646.2 26.55,14.48 v1(26.83,14.2) 26.94,14.31 R80202.2
  L3 w0.254: v3(135.42,54.1) 135.08,53.77 135.08,51.28 134.21,50.41 134.21,46.9 133,45.69 125.48,45.69 v3(122.72,42.93)
  L4 w0.254: v3(122.72,42.93) 124.14,41.5 124.14,38.9 123.72,38.48 119.29,38.48 116.37,35.56 114.34,35.56 104.8,26.01 93.27,26.01 91.35,27.94 64.8,27.94 56.65,19.78 45.91,19.78 45.17,20.52 43.34,20.52 42.36,19.55 37.36,19.55 34.91,17.09 33.49,17.09 31.18,14.79 24.98,14.79 v3(23.27,13.08)
SIO_GREEN_PWM: length 155.7
  TOP w0.203: U109.15 137.41,63.69 137.99,63.12
  TOP w0.254: 137.99,63.12 138.21,63.12 138.72,62.61 138.72,57.15 v3(137.19,55.63)
  L3 w0.254: v3(123.48,42.93) 125.84,45.29 133.17,45.29 135.49,47.61 135.49,52.53 137.19,54.23 v3(137.19,55.63)
  L4 w0.254: v3(123.48,42.93) 124.54,41.86 124.54,38.73 123.79,37.97 119.41,37.97 116.49,35.05 114.46,35.05 105.02,25.61 93.04,25.61 91.12,27.53 65.03,27.53 56.88,19.38 45.68,19.38 44.94,20.12 43.51,20.12 42.53,19.14 37.59,19.14 35.09,16.64 33.6,16.64 30.5,13.53 30.5,12.63 28.91,11.03 23.77,11.03 v3(23.15,10.41)
  BOTTOM w0.254: R723.2 24.35,9.78 v2(23.81,9.78) 23.78,9.78 v3(23.15,10.41)
SIO_GREEN_PWM_C_1: length 12.6
  TOP w0.254: Q9646.1 25.61,13.13 26.17,12.57 v3(26.17,8.38)
  BOTTOM w0.254: v3(26.17,8.38) 25.89,8.66 25.53,8.66 v2(25.43,8.76) 25.33,8.86 25.33,9.5 25.88,10.05 R723.1 25.88,11.59 Q1212.G 26.61,11.43 R1752.2 R729.1
SIO_HDD_LED: length 158
  TOP w0.102: v3(137.96,55.63) 137.96,55.88 139.05,56.97 139.05,63.04 139.01,63.08 U109.11
  L3 w0.127: v3(120.05,42.67) 121.06,41.66 124,41.66 126.49,44.15 133.64,44.15 136.63,47.14 136.63,52.05 139.19,54.61 139.19,55.92 138.92,56.19 138.38,56.19 137.96,55.76 v3(137.96,55.63)
  L4 w0.127: v3(24.42,26.67) 27.34,23.75 29.37,23.75 31.36,21.76 39.19,21.76 40.29,22.86 42.42,22.86 52.45,32.89 70.14,32.89 71.29,31.74 91.06,31.74 94.75,28.05 98.85,28.05 108.87,38.07 108.87,39.2 110.57,40.89 117,40.89 117.93,41.82 118.25,41.82 118.25,41.82 118.88,41.82 118.88,41.82 118.97,41.82 119.83,42.67 v3(120.05,42.67)
  BOTTOM w0.102: v3(24.42,26.67) 24.58,26.67 25.52,27.6 25.52,28.98 24.76,29.73 R1753.1 24.96,30.28 25.56,30.28 v2(25.84,30.56) 25.31,31.09 R1757.2
SIO_HDD_LED_1: length 3.2
  BOTTOM w0.102: Q1214.B 23.97,28.13 v2(23.66,28.45) 23.6,28.5 23.6,29.81 R1753.2
SIO_HOLD#: length 2.9
  BOTTOM w0.102: R311.1 140.09,60.49 v2(140.09,60.2) 140.09,60.04 139.61,59.56 U9602.7
SIO_INT#: length 71
  TOP w0.102: v3(90.2,57.29) 89.82,57.67 89.82,58.13 89.7,58.26 U4101.39 ; R80210.1 v3(149.64,49.78)
  L4 w0.127: v3(149.64,49.78) 149,49.78 147.61,51.18 138.43,51.18 137.83,50.58 137.83,50.29 136.68,49.15 136.3,49.15 135.2,48.04 103.02,48.04 102.07,48.04 95.5,54.61 95.5,55.05 95.08,55.47 94.35,55.47 91.79,58.03 90.94,58.03 v3(90.2,57.29)
  BOTTOM w0.102: v2(89.44,57.7) 89.78,57.7 90.19,57.29 v3(90.2,57.29) 89.76,56.84 R80211.1
SIO_INT_C: length 4.1
  TOP w0.102: R80210.2 147.14,50.44 146.9,50.44 v1(146.61,50.73) 145.58,51.77 U109.100
SIO_LVDS_BL_ADJ: length 133.6
  TOP w0.165: v3(46.52,23.5) 45.63,22.61 R131.2 ; v3(139.23,65.91) 139.41,65.73 U109.10 139.41,63.31 139.43,63.29 139.43,56.34 v3(138.72,55.63)
  L3 w0.165: v3(138.72,55.63) 138.72,54.7 136.23,52.22 136.23,47.3 133.48,44.55 126.33,44.55 123.84,42.06 122.19,42.06 v3(121.57,42.67)
  L4 w0.165: v3(46.52,23.5) 47.13,24.11 47.13,26.43 52.72,32.02 69.29,32.02 71.45,29.86 91.63,29.86 94.26,27.24 99.28,27.24 105.74,33.7 106.77,33.7 109.84,36.77 109.84,39.03 110.9,40.08 120.64,40.08 121.27,40.72 121.27,42.37 v3(121.57,42.67)
  BOTTOM w0.165: v2(139.61,66.8) 139.23,66.42 v3(139.23,65.91) 137.38,64.07 R79932.1
SIO_MAIN_VCC3: length 3.6
  TOP w0.203: 139.48,46.61 139.61,46.74 v1(139.61,47.07) 139.61,47.37 140.21,47.98 U109.89
  TOP w0.508: 139.48,46.61 139.23,46.35 R286.1
SIO_MEM_EVENT_L: length 5.1
  TOP w0.102: U109.53 127.85,54.97 126.98,54.1 v3(126.91,54.1)
  BOTTOM w0.102: v3(126.91,54.1) 126.91,54.76 v2(127.13,54.99) 128.37,54.99 R279.2
SIO_PCIRSTIN#: length 6.4
  TOP w0.102: U109.128 144.56,65.61 v1(145.45,66.5) 146.41,67.46 147.31,67.46 R316.1
SIO_PSON_D: length 5.8
  TOP w0.152: R323.1 130.61,43.59 v1(129.24,43.59) 129.2,43.62 Q8.D
SIO_PSON_N: length 8.4
  TOP w0.102: Q8.G 128.56,45.53 R318.2 128.81,46.11 v1(129.48,46.79) 129.82,47.12 131.07,47.12 131.68,47.73 132.16,47.73 132.39,47.96 133.55,47.96 133.81,48.22 U109.73
SIO_SCI#: length 158.6
  TOP w0.102: CPU1.L6 77.83,147.41 v4(78.13,147.72) ; v3(134.4,71.5) 132.77,69.88 132.61,69.88 R79928.1
  L3 w0.127: v3(92.11,71.37) 92.58,71.84 98.84,71.84 103.47,67.21 117.86,67.21 122.56,62.51 124.52,62.51 124.75,62.74 124.75,64.8 130.18,70.23 133.13,70.23 v3(134.4,71.5)
  BOTTOM w0.102: v4(78.13,147.72) 78.13,145.81 76.11,143.78 76.11,139.76 R802.1 75.8,138.29 75.8,136 74.79,134.98 74.79,129.8 75.73,128.86 75.73,127.06 77,125.79 77,125.13 83.71,118.41 93.04,118.41 98.35,113.11 101.81,113.11 102.45,112.47 102.45,91.87 97.26,86.69 v2(97.26,82.88) 97.26,80.89 98.08,80.07 98.08,73.67 96.25,71.83 92.57,71.83 v3(92.11,71.37)
SIO_SCK: length 5.7
  BOTTOM w0.102: U9602.6 138.34,59.61 v2(138.87,60.15) 139.54,60.82 C197.1 R294.2 139.67,62.99 R312.1
SIO_SCK_R: length 6.7
  TOP w0.102: v3(137.7,61.98) 136.93,62.74 135.54,62.74 134.61,63.67 U109.22
  BOTTOM w0.102: v3(137.7,61.98) 138.46,61.98 v2(138.59,62.1) R294.1
SIO_SI: length 9.8
  TOP w0.102: v3(137.7,61.09) 138.16,61.54 138.16,62.19 137.38,62.97 137.38,62.97 135.69,62.97 135.01,63.65 U109.21
  BOTTOM w0.102: U9602.5 137.07,59.92 v2(136.79,60.2) 136.69,60.3 R313.1 137.51,61.28 v3(137.7,61.09)
SIO_SMB2_CLK: length 7.6
  TOP w0.102: U109.63 126.95,50.97 126.92,51 126.23,51 126.13,51.1 123.99,51.1 v1(123.86,50.98) 122.83,50.98 R306.2 R80209.2
SIO_SMB2_DATA: length 7.7
  TOP w0.102: U109.62 127.98,51.37 127.97,51.36 126.65,51.36 126.33,51.68 v1(126.05,51.68) 125.5,51.68 125.38,51.56 122.91,51.56 R307.2 R80208.2
SIO_SMCLK0: length 113.3
  TOP w0.102: R79633.2 40.09,20.75 v3(40.04,20.7) ; U109.60 127.98,52.17 127.87,52.27 127.36,52.27 v3(126.91,51.82)
  L4 w0.127: v3(40.04,20.7) 40.89,21.55 46.85,21.55 48.17,20.23 56.46,20.23 64.62,28.38 91.54,28.38 93.46,26.46 99.61,26.46 106.07,32.92 111.07,32.92 113.83,35.67 113.83,38.23 114.71,39.12 v3(122.84,39.12)
  BOTTOM w0.102: v3(126.91,51.82) 126.91,50.29 127.36,49.84 RN5.3 v2(127.83,45.9) 127.83,45.5 122.84,40.51 v3(122.84,39.12)
SIO_SMDAT0: length 117.2
  TOP w0.102: v3(127.67,51.82) 127.72,51.77 U109.61 ; v3(39.28,20.7) 39.07,20.9 R79634.2
  L4 w0.127: v3(123.6,39.12) 123.04,39.68 111.07,39.68 110.24,38.86 110.24,36.61 106.94,33.3 105.91,33.3 99.45,26.84 93.74,26.84 91.82,28.77 71.09,28.77 68.23,31.62 52.89,31.62 47.53,26.27 47.53,23.85 45.66,21.97 40.55,21.97 v3(39.28,20.7)
  BOTTOM w0.102: v3(127.67,51.82) 127.67,50.65 RN5.4 128.31,50.49 128.43,50.37 128.43,49.4 128.89,48.95 v2(128.89,48.23) 128.89,46.06 123.6,40.77 v3(123.6,39.12)
SIO_SO: length 18.4
  TOP w0.102: v3(135.67,60.58) 133.43,60.58 131.02,58.17 U109.45
  BOTTOM w0.102: v3(135.67,60.58) R309.1 134.84,60.52 135.16,60.2 135.16,58.42 v2(135.52,58.06) 135.75,57.84 135.75,56.69 136.43,56.01 136.43,55.42 136.96,54.89 138.69,54.89 139.61,53.98 U9602.2
SIO_UART1_RX: length 97.6
  TOP w0.102: v3(59.22,80.64) 58.71,80.14 R9553.2 ; R317.1 141.22,68.86 v1(140.81,68.86) 139.25,68.86 v3(136.3,65.91) 136.61,65.6 U109.17
  L4 w0.127: v3(136.3,65.91) 134.64,64.25 131.19,64.25 129.81,62.87 127.91,62.87 126.84,63.93 101.9,63.93 101.59,64.25 100.89,64.25 97.47,67.67 91.47,67.67 88.97,70.17 85.17,70.17 83.08,72.26 78.53,72.26 77.04,70.78 73,70.78 72.87,70.9 69.87,70.9 60.86,79.92 59.94,79.92 v3(59.22,80.64)
SIO_UART1_RX_R: length 3.5
  TOP w0.102: SCA1.59 57.62,76.77 v1(58.58,77.72) 58.71,77.85 R9553.1
SIO_UART1_TX: length 96.7
  TOP w0.102: U109.18 136.21,65.27 135.57,65.91 v3(135.54,65.91) 136,66.37 136.13,66.37 139.35,69.6 140.94,69.6 R79820.1 ; R9555.2 59.72,80.39 v3(59.98,80.64)
  L4 w0.127: v3(135.54,65.91) 134.13,64.5 131.08,64.5 129.7,63.12 128.04,63.12 126.97,64.19 102.01,64.19 101.69,64.5 101,64.5 97.58,67.92 91.57,67.92 89.07,70.42 85.28,70.42 83.18,72.52 78.42,72.52 76.94,71.03 73.11,71.03 72.29,71.84 69.37,71.84 67.66,73.55 61.04,80.18 60.45,80.18 v3(59.98,80.64)
  BOTTOM w0.102: v2(136.03,66.74) 135.54,66.25 v3(135.54,65.91)
SIO_UART1_TX_R: length 4.2
  TOP w0.102: SCA1.58 58.12,76.63 58.45,76.96 59.09,76.96 v1(59.85,77.72) 59.85,78.23 59.72,78.36 R9555.1
SIO_VCORE: length 4.2
  TOP w0.203: 127.92,63.12 128.07,62.97 U109.33
  TOP w0.508: v1(125.05,63.53) 125.88,63.53 C12151.1 C191.1 127.68,63.36 127.92,63.12
SIO_VIN1: length 9.3
  TOP w0.203: U109.94 142.21,48.24 142.49,47.96 142.58,47.96
  TOP w0.254: 142.58,47.96 143.14,47.96 143.26,47.83 144.89,47.83 145.96,46.76 145.96,46.66 v3(145.98,46.63)
  BOTTOM w0.254: R80216.2 R80215.1 147.8,46.75 v2(147.53,46.48) 146.29,46.48 146.13,46.63 v3(145.98,46.63)
SIO_VIN3: length 8.9
  TOP w0.203: 143.25,46.84 142.72,47.37 142.15,47.37 141.41,48.11 U109.92
  TOP w0.508: R250.1 144.11,41.91 C179.1 144.11,43.62 v1(144.05,43.69) 144.11,43.75 R252.1 144.11,45.97 143.25,46.84
SIO_VIN4: length 6.2
  TOP w0.203: U109.91 141.01,48.02 v1(142.3,46.74)
  TOP w0.508: v1(142.3,46.74) 142.3,46.69 142.5,46.48 142.53,46.48 142.97,46.04 142.97,46.01 143.1,45.89 R259.1 C181.1 R255.1
SIO_VIN5: length 6.4
  TOP w0.203: 140.32,46.61 140.61,46.9 U109.90
  TOP w0.508: 140.32,46.61 140.3,46.6 R79939.1 140.3,44.84 v1(140.27,44.81) 140.27,44.78 140.3,44.74 C183.1 R79937.1
SIO_VREF: length 8.6
  TOP w0.203: v3(138.59,46.74) 138.67,46.81 138.67,47.07 139.81,48.21 U109.88
  TOP w0.254: v3(138.59,46.74) 138.59,46.61 138.21,46.23 C188.1
  BOTTOM w0.254: R404.2 140.27,47.13 v2(140.27,46.74) 139.73,47.27 R397.2 138.91,46.79 138.64,46.79 v3(138.59,46.74) 138.59,46.48 138.27,46.16 R658.2
SIO_WP#: length 8.1
  BOTTOM w0.102: R310.1 134.63,59.32 134.63,57.2 v2(134.81,57.02) 134.96,56.87 135.2,56.87 136.18,55.89 136.18,55.35 136.92,54.61 137.83,54.61 138.34,54.1 U9602.3
SIO_WRST#: length 6.2
  TOP w0.102: v3(131.22,57.66) 130.77,57.2 130.23,57.2 130.07,57.37 U109.47
  BOTTOM w0.102: v3(131.22,57.66) 131.22,58.09 v2(130.74,58.57) 129.94,59.37 C12152.1 R79944.2
SIO_YELLOW: length 140.1
  TOP w0.203: 131.01,62.23 U109.31
  TOP w0.254: v3(130.46,52.83) 131.35,52.83 133.89,55.37 133.89,56.52 136.3,58.93 136.3,60.96 135.95,61.32 131.93,61.32 131.01,62.23 ; Q68.G 36.16,20.26 v3(35.97,20.07) ; Q68.G 37.59,20.99 R731.2 ; Q68.G 36.13,21.02 R1761.2
  L3 w0.254: v3(130.46,52.83) 130.46,51.94 122.59,44.07 122.21,44.07 v3(120.81,42.67)
  L4 w0.254: v3(35.97,20.07) 37.27,21.36 39.3,21.36 40.46,22.52 42.56,22.52 52.53,32.49 69.81,32.49 70.9,31.39 90.91,31.39 94.6,27.7 98.99,27.7 105.45,34.16 106.58,34.16 109.38,36.96 109.38,39.22 110.71,40.55 119.19,40.55 120.81,42.17 v3(120.81,42.67)
  BOTTOM w0.254: v3(120.81,42.67) v2(120.81,41.71)
SKEW1: length 19.9
  TOP w0.102: R1688.1 68.8,134.11 70.07,134.11 R1687.2 70.31,133.97 71.78,133.97 72.01,133.73 v1(74.07,133.73) 74.07,133.77 77.92,137.62 78.94,137.62 79.66,138.34 79.66,142.88 80.42,143.64 80.42,144.61 CPU1.U1
SKEW2: length 22.1
  TOP w0.089: 79.92,143.64 80.24,143.96 80.24,144.79 80.3,144.92 80.3,145.14 CPU1.U2
  TOP w0.102: R80180.2 R80181.1 68.04,134.37 72.17,134.37 v1(72.25,134.29) 74.18,134.29 77.74,137.85 78.84,137.85 79.43,138.44 79.43,143.15 79.92,143.64
SKEW3: length 25.3
  TOP w0.089: 79.54,143.76 80.06,144.29 80.06,144.83 80.11,144.93 80.11,145.48 80.5,145.87 CPU1.U3
  TOP w0.102: R1685.1 R1684.2 v1(65.57,134.49) 65.92,134.85 74.42,134.85 77.64,138.07 78.75,138.07 79.18,138.51 79.18,143.41 79.54,143.76
SKTOCC#: length 12
  TOP w0.102: CPU1.A65 71.39,181.55 70.11,182.82 70.11,187.46 70.09,187.48 70.09,190.46 71.14,191.52 TP402.1
SLEEVE: length 38.8
  TOP w0.203: 168.4,77.05 U6.32
  TOP w0.762: Q28.D 169.51,86.93 v3(170.34,86.11) ; v3(176.06,84.45) 176.12,84.52 Q24.1 176.94,84.49 176.94,83.66 175.53,82.25 175.53,78.46 180.21,73.79 181.9,73.79 UHS1.4
  L3 w0.762: v3(171.86,76.96) 174.15,76.96 175.42,78.23 175.42,83.82 v3(176.06,84.45) 175.5,85.01 171.43,85.01 v3(170.34,86.11)
  vias: v1(168.56,77.22)
SLEEVE_G: length 25.6
  TOP w0.102: v3(152.69,84.71) 151.67,83.69 Q31.C 150.72,82.68 R319.2 149.26,82.61 R322.1 ; v3(156.88,84.45) 156.42,84.91 156.42,87.17 v1(156.8,87.55) 158.4,89.15 160.56,89.15 161.12,89.71 163.28,89.71 163.74,89.26 164.39,89.26 164.67,88.97 165.07,88.97 165.07,88.98 165.71,88.98 165.83,89.1 166.21,89.1 167.08,88.23 Q28.G
  L4 w0.102: v3(156.88,84.45) 156.62,84.71 v3(152.69,84.71)
SLP_A_N: length 2.9
  TOP w0.102: CPU1.AN16 88.6,153.61 v4(88.92,153.29)
  BOTTOM w0.102: TP9916.1 87.83,153.69 88.44,153.69 88.85,153.29 v4(88.92,153.29)
SLP_LAN_N: length 3
  TOP w0.102: v4(91.74,153.29) 92.35,153.29 CPU1.AW15
  BOTTOM w0.102: v4(91.74,153.29) 92.89,153.29 93.66,152.52 TP1704.1
SLP_S0_N: length 153.5
  TOP w0.102: R80127.1 22.28,139.22 22.44,139.06 24.29,139.06 v3(24.93,139.7) ; v4(90.22,151.46) 90.55,151.14 CPU1.AT11
  L4 w0.127: v3(24.93,139.7) 30.38,139.7 35.28,134.8 35.28,133.32 36.85,131.74 36.85,131.58 43.86,124.57 65.01,124.57 67.18,126.75 71,126.75 82.62,115.13 101.06,115.13 105.06,111.12 v3(106.97,111.12) ; v3(107.86,135.25) 106.27,135.25 94.78,146.75 94.78,148.73 92.31,151.2 91.39,151.2 91.23,151.04 90.64,151.04 v4(90.22,151.46)
  BOTTOM w0.102: v3(106.97,111.12) 106.97,111.45 105.47,112.95 105.47,121.5 109.84,125.87 109.84,133.27 v2(108.96,134.15) v3(107.86,135.25)
