# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_BS2: length 57.5
  TOP w0.089: v4(100.67,178.72) 99.98,178.02 97.56,178.02 95.88,176.34 94.23,176.34 94.1,176.38 93.89,176.38 93.69,176.33 93.29,176.33 CPU1.AY55
  TOP w0.165: DIMM1.79 131.87,164.75 133.64,166.52 v4(133.64,168.4)
  L3 w0.089: v4(100.67,178.72) 101.14,179.18 102.44,179.18 102.58,179.32 102.79,179.32 102.94,179.18 103.15,179.18 103.29,179.32 103.51,179.32 103.65,179.18 103.88,179.18 104.4,179.71
  L3 w0.216: 104.4,179.71 116.36,179.71 127.15,168.91 130.05,168.91 131.95,167 134.62,167 134.84,167.22 134.84,167.65 134.62,167.87 133.92,167.87 133.64,168.15 v4(133.64,168.4)
  BOTTOM w0.102: v2(134.4,167.61) 134.4,167.69 133.69,168.4 v4(133.64,168.4)
M_A_CAS#: length 58.2
  TOP w0.165: v4(132.71,154.3) 133.18,153.82 134.17,153.82 134.3,153.7 134.3,153.09 134.17,152.96 132.52,152.96 132.29,153.19 132.29,153.82 132.16,153.95 DIMM1.115 ; CPU1.AU48 91.6,172.03 91.71,172.15 91.71,172.44 91.61,172.54 v4(91.52,172.54)
  L3 w0.089: 104.17,169.04 103.92,169.04 101.74,171.22 96.05,171.22 95.91,171.08 95.91,170.68 95.79,170.56 95.18,170.56 93.78,171.96 91.73,171.96 91.52,172.17 v4(91.52,172.54)
  L3 w0.216: v4(132.71,154.3) 132.71,154.43 132.58,154.56 129.4,154.56 129.4,154.56 128.11,154.56 126.72,154.56 117.91,163.37 112.24,169.04 104.17,169.04
  BOTTOM w0.102: v4(132.71,154.3) 132.46,154.04 v2(132.46,153.46)
M_A_CKE0: length 59.1
  TOP w0.089: CPU1.BA56 93.7,176.6 93.97,176.78 94.21,176.87 95.9,176.87 97.42,178.38 98.23,178.38 v4(98.62,178.76)
  TOP w0.165: DIMM1.73 133.13,166.55 133.26,166.68 133.26,167.24 133.13,167.37 130.44,167.37 130.31,167.49 130.31,168.28 130.44,168.4 v4(132.11,168.4)
  L3 w0.089: 104.45,180.2 104.26,180.2 103.8,179.74 102.27,179.74 102.18,179.65 102.18,179.45 102.09,179.36 101.92,179.36 101.83,179.45 101.83,179.65 101.74,179.74 101.55,179.74 101.46,179.65 101.46,179.54 101.37,179.45 101.19,179.45 101.1,179.54 101.1,179.72 101,179.83 100.84,179.83 100.74,179.72 100.74,179.29 100.65,179.2 100.47,179.2 100.38,179.29 100.38,179.73 100.28,179.83 100.13,179.83 100.02,179.73 100.02,179.29 99.94,179.2 99.76,179.2 99.67,179.29 99.67,179.71 99.54,179.83 99.37,179.83 99.24,179.71 99.24,179.29 99.15,179.2 98.97,179.2 98.89,179.29 98.89,179.72 98.78,179.83 98.62,179.83 98.51,179.72 98.51,178.87 v4(98.62,178.76)
  L3 w0.216: v4(132.11,168.4) 131.38,168.4 130.22,169.56 127.96,169.56 117.33,180.2 104.45,180.2
  BOTTOM w0.165: v4(132.11,168.4) 132.8,167.72 v2(132.8,167.59)
M_A_CKE1: length 58.4
  TOP w0.089: CPU1.BB56 95.89,176.6 97.49,178.2 98.83,178.2 v4(99.35,178.73)
  TOP w0.165: DIMM1.74 137.87,166.25 v4(137.4,165.79)
  L3 w0.089: v4(99.35,178.73) 98.96,178.33 98.43,178.33 98.2,178.56 98.2,179.83 98.49,180.12 103.65,180.12 104.22,180.7 104.53,180.7
  L3 w0.216: v4(137.4,165.79) 137.4,166.62 134.83,169.19 131.33,169.19 130.46,170.06 128.17,170.06 117.53,180.7 104.53,180.7
  BOTTOM w0.102: v4(137.4,165.79) 137.4,165.27 v2(138.03,164.64)
M_A_CLK0: length 59.8
  TOP w0.102: v4(134.04,157.3) 134.04,157.7 133.78,157.96 133.78,158.06 133.78,158.37 133.53,158.62 132.88,158.62 132.4,158.15 DIMM1.101 ; v4(90.22,174.3) 90.23,174.3 90.55,174.62 CPU1.AT53
  L3 w0.089: 102.78,171.7 102.61,171.87 97.52,171.87 95.6,173.8 95.16,173.8 94.95,174 94.95,174.39 94.85,174.5 94.7,174.5 94.6,174.39 94.6,174 94.4,173.8 94.06,173.8 93.86,174 93.86,174.52 93.76,174.62 93.61,174.62 93.51,174.52 93.51,174 93.31,173.8 91.39,173.8 91.3,173.89 90.63,173.89 v4(90.22,174.3)
  L3 w0.127: 102.78,171.7 102.78,171.7 103.68,170.8 112.84,170.8 127.41,156.23 133.27,156.23 133.78,156.73 133.78,156.84 134.04,157.1 v4(134.04,157.3)
  BOTTOM w0.102: v2(134.2,156.51) 134.04,156.67 v4(134.04,157.3)
M_A_CLK1: length 60.2
  TOP w0.102: v4(136.64,157.27) 136.64,157.43 137.18,157.98 138.16,157.98 138.28,157.85 DIMM1.102 ; v4(90.26,175.24) 90.28,175.24 90.55,175.51 CPU1.AT55
  L3 w0.127: v4(136.64,157.27) 136.19,156.83 135.72,156.83 135.44,157.11 135.44,157.56 134.97,158.03 132.16,158.03 131.93,157.81 127.49,157.81 113.32,171.97 104.29,171.97 103.71,172.55 98.04,172.55 94.56,176.02 90.71,176.02 90.44,175.75 90.44,175.43 v4(90.26,175.24)
  BOTTOM w0.102: v4(136.64,157.27) 136.38,157.02 v2(136.38,156.43)
M_A_CLK#0: length 59.9
  TOP w0.102: CPU1.AU53 91.57,174.78 91.7,174.65 91.7,174.43 91.57,174.3 v4(90.93,174.3) ; v4(133.3,157.31) 133.3,157.71 133.57,157.96 133.57,158.07 133.57,158.28 133.44,158.41 132.96,158.41 132.55,158 132.55,157.92 132.18,157.55 DIMM1.103
  L3 w0.089: v4(90.93,174.3) 91.15,174.53 91.32,174.53 91.38,174.46 91.38,174.08 91.47,173.99 93.23,173.99 93.32,174.08 93.32,174.6 93.53,174.82 93.84,174.82 94.05,174.6 94.05,174.08 94.14,173.99 94.32,173.99 94.41,174.08 94.41,174.47 94.62,174.69 94.93,174.69 95.15,174.47 95.15,174.08 95.23,173.99 95.54,173.99 95.68,173.99 97.6,172.06 102.8,172.06 102.95,171.91
  L3 w0.127: v4(133.3,157.31) 133.38,157.31 133.51,157.18 133.51,156.84 133.16,156.49 127.52,156.49 112.95,171.07 103.79,171.07 102.95,171.91
  BOTTOM w0.102: v2(133.59,158.14) 133.3,157.86 v4(133.3,157.31)
M_A_CLK#1: length 60.3
  TOP w0.102: CPU1.AU55 91.2,175.51 90.93,175.24 v4(90.91,175.24) ; DIMM1.104 138.57,157.25 138.05,157.76 137.27,157.76 137.09,157.58 137.09,157.45 v4(137.27,157.27)
  L3 w0.127: v4(137.27,157.27) 136.56,156.56 135.61,156.56 135.17,157 135.17,157.45 134.86,157.76 132.27,157.76 132.2,157.69 132.04,157.54 127.38,157.54 113.21,171.7 104.18,171.7 103.6,172.28 97.93,172.28 94.45,175.76 90.82,175.76 90.71,175.64 90.71,175.44 v4(90.91,175.24)
  BOTTOM w0.102: v4(137.27,157.27) 137.27,156.89 v2(137.65,156.51)
M_A_CS#0: length 63.8
  TOP w0.165: v4(90.89,169.76) 90.89,169.85 91.2,170.16 CPU1.AU45 ; DIMM1.114 137.36,154.25 137.04,153.93 136.4,153.93 135.24,155.09 135.06,155.09 134.54,154.57 134.54,154.39 135.91,153.03 135.91,152.8 v4(135.51,152.4)
  L3 w0.089: 104.17,166.5 102.18,168.49 93.65,168.49 93,169.14 92.67,169.14 91.65,170.16 91.07,170.16 90.89,169.98 v4(90.89,169.76)
  L3 w0.216: v4(135.51,152.4) 135.51,151.77 135.29,151.55 134.53,151.55 134.21,151.88 133.8,151.88 133.8,151.88 131.82,151.88 131.36,151.41 125.91,151.41 115.63,161.7 110.83,166.5 104.17,166.5
  BOTTOM w0.102: v4(135.51,152.4) 135.25,152.14 v2(135.25,151.56)
M_A_CS#1: length 65.3
  TOP w0.165: v4(133.29,151.39) 133.77,151.87 136.15,151.87 136.28,151.74 136.28,148.87 136.15,148.74 135.31,148.74 135.19,148.87 135.19,150.6 134.98,150.8 132.41,150.8 132.29,150.93 132.29,151.86 132.18,151.96 132.17,151.96 131.98,152.15 DIMM1.121 ; v4(91.53,169.71) 91.2,169.38 CPU1.AU43
  L3 w0.089: v4(91.53,169.71) 91.71,169.71 92.59,168.83 92.86,168.83 93.47,168.22 101.94,168.22 104.16,166
  L3 w0.216: v4(133.29,151.39) 133.27,151.36 132,151.36 131.55,150.92 125.71,150.92 115.42,161.21 115.42,161.21 110.63,166 104.16,166
  BOTTOM w0.102: v2(133.29,150.6) v4(133.29,151.39)
M_A_DQ0: length 69.9
  TOP w0.089: CPU1.AL71 87.49,185.91 87.07,186.33 87.07,187.76 v4(87.76,188.45)
  TOP w0.102: v4(136.56,189.36) 136.56,189.59 136.96,189.99 138.21,189.99 138.55,189.65 DIMM1.4
  L3 w0.127: v4(87.76,188.45) 87.08,189.14 87.08,193.83 87.08,194.11 91.95,198.98 121.02,198.98 131.12,188.88 136.38,188.88 136.56,189.05 v4(136.56,189.36)
  BOTTOM w0.102: v4(136.56,189.36) 136.56,188.82 v2(136.3,188.57)
M_A_DQ1: length 70.6
  TOP w0.089: 87.94,186.05 87.96,186.03 87.96,185.23 87.89,185.09 87.89,184.89 87.94,184.77 87.94,184.57 87.87,184.36 87.87,184.02 87.49,183.51 CPU1.AL68
  TOP w0.102: v4(87.73,187.18) 87.56,187.01 87.56,186.42 87.93,186.05 87.94,186.05 ; v4(134.27,189.36) 133.67,188.75 DIMM1.7
  L3 w0.127: v4(134.27,189.36) 128.8,194.83 126.16,194.83 121.27,199.72 91.71,199.72 86.39,194.4 86.39,193.55 86.39,193.54 86.39,188.56 87.73,187.22 v4(87.73,187.18)
  BOTTOM w0.102: v4(134.27,189.36) 134.27,188.82 v2(134.02,188.57)
M_A_DQ2: length 71
  TOP w0.102: DIMM1.16 138.45,186.05 138.2,185.81 136.98,185.81 v4(135.9,184.73) ; v4(88.82,182.7) 88.72,182.8 CPU1.AN68
  L3 w0.127: v4(88.82,182.7) 88.82,182.91 88.69,183.03 87.76,183.03 87.64,183.16 87.64,183.72 87.76,183.85 88.83,183.85 90.24,185.25 90.24,188.82 89.93,189.13 89.93,193.14 93.07,196.28 119.68,196.28 130.46,185.5 135.14,185.5 v4(135.9,184.73)
  BOTTOM w0.102: v4(135.9,184.73) 135.72,184.91 v2(135.72,185.5)
M_A_DQ3: length 71.1
  TOP w0.089: v4(89.64,187.11) 89.48,187.11 89.23,186.86 89.23,185.94 89.37,185.8 89.37,184.83 89.15,184.61 89,184.41 CPU1.AN69
  TOP w0.102: v4(133.93,186.36) 133.32,185.75 DIMM1.17
  L3 w0.127: v4(133.93,186.36) 134,186.36 134.12,186.49 134.12,186.54 134.38,186.81 134.75,186.81 135.07,186.49 135.31,186.49 135.54,186.72 135.54,187.29 135.42,187.41 130.36,187.41 130.36,187.41 130.07,187.41 120.18,197.31 92.64,197.31 88.9,193.56 88.9,192.71 88.9,192.71 88.9,189.45 88.43,188.98 88.43,186.82 88.55,186.69 89.32,186.69 89.51,186.88 89.51,186.88 89.64,187.01 v4(89.64,187.11)
  BOTTOM w0.102: v2(133.2,185.6) 133.93,186.34 v4(133.93,186.36)
M_A_DQ4: length 71
  TOP w0.089: v4(87.81,189.1) 86.89,188.19 86.89,186.25 87.23,185.91 87.23,185.06 87.28,184.87 CPU1.AL70
  TOP w0.102: v4(137.83,189.36) 137.83,189.23 138.01,189.05 DIMM1.6
  L3 w0.127: v4(137.83,189.36) 138.19,189.36 138.32,189.23 138.32,188.62 138.16,188.46 131.06,188.46 120.87,198.64 92.09,198.64 87.42,193.97 87.42,189.49 v4(87.81,189.1)
  BOTTOM w0.102: v2(137.57,188.57) 137.83,188.82 v4(137.83,189.36)
M_A_DQ5: length 71.1
  TOP w0.089: v4(87.76,187.82) 87.25,187.3 87.25,186.44 87.78,185.9 87.78,185.27 87.71,185.12 87.71,184.88 87.76,184.74 87.76,184.6 87.7,184.39 87.7,184.22 CPU1.AL69
  TOP w0.102: DIMM1.5 132.74,189.35 v4(132.75,189.36)
  L3 w0.127: v4(87.76,187.82) 86.73,188.84 86.73,193.69 86.73,194.26 91.85,199.38 121.11,199.38 126.5,193.98 128.51,193.98 131,191.49 131,191.01 130.64,190.65 130.64,190.47 130.82,190.29 131,190.29 131.84,191.13 132.02,191.13 132.2,190.95 132.2,190.77 131.45,190.02 131.45,189.84 131.63,189.66 131.81,189.66 132.61,190.46 132.79,190.46 133.15,190.09 133.15,189.74 132.77,189.36 v4(132.75,189.36)
  BOTTOM w0.102: v4(132.75,189.36) 132.75,188.82 v2(132.49,188.57)
M_A_DQ6: length 70.5
  TOP w0.089: v4(89.61,187.74) 89.05,187.18 89.05,185.49 89.19,185.36 89.19,185.03 CPU1.AN70
  TOP w0.102: v4(137.25,184.74) 137.25,184.85 137.86,185.45 DIMM1.18
  L3 w0.127: v4(137.25,184.74) 137.49,184.97 137.49,184.97 137.7,185.18 138.67,185.18 138.79,185.31 138.79,185.73 138.67,185.86 133.2,185.86 133.19,185.86 133.18,185.86 130.63,185.86 119.87,196.62 92.92,196.62 89.58,193.28 89.58,193 89.58,189.07 90.02,188.63 90.02,188.15 v4(89.61,187.74)
  BOTTOM w0.102: v2(138.21,183.95) 138,183.95 137.25,184.7 v4(137.25,184.74)
M_A_DQ7: length 69.5
  TOP w0.089: v4(89.6,188.43) 89.7,188.43 89.82,188.55 89.82,189.99 89.7,190.12 89,190.12 88.87,189.99 88.87,185.65 88.82,185.6 CPU1.AN71
  TOP w0.102: DIMM1.15 131.21,186.36 v4(132.66,186.36)
  L3 w0.127: v4(132.66,186.36) 132.66,187.06 132.54,187.18 132.37,187.18 132.37,187.18 131.86,187.18 131.74,187.06 131.74,186.54 131.61,186.41 131.36,186.41 131.23,186.54 131.23,187.06 131.1,187.18 130.85,187.18 130.72,187.06 130.72,186.64 130.59,186.51 130.34,186.51 130.21,186.64 130.21,187.06 130.09,187.18 129.81,187.18 120.03,196.96 92.78,196.96 89.24,193.42 89.24,192.85 89.24,189.49 88.68,188.92 88.68,187.58 88.81,187.45 89.07,187.45 89.19,187.58 89.19,187.92 89.44,188.16 89.47,188.16 89.6,188.29 v4(89.6,188.43)
  BOTTOM w0.102: v2(131.83,186.36) v4(132.66,186.36)
M_A_DQ8: length 66.5
  TOP w0.089: CPU1.AR70 89.95,184.77 89.95,184.98 90.07,185.1 90.08,185.14 90.11,185.24 90.11,185.47 90.1,185.47 90.1,185.96 90.13,185.99 90.13,186 90.27,186.15 90.27,186.17 90.28,186.18 90.28,188.42 91.04,189.18 v4(91.04,189.23)
  TOP w0.102: DIMM1.22 138.44,184.25 138.08,183.9 136.6,183.9 v4(135.9,183.2)
  L3 w0.127: v4(91.04,189.23) 91.93,190.12 93.23,190.12 93.69,189.66 96.4,189.66 99.62,192.88 105.88,192.88 107.44,194.44 111.41,194.44 111.79,194.06 111.79,192.79 111.92,192.66 112.33,192.66 112.46,192.79 112.46,193.71 112.59,193.84 112.84,193.84 112.97,193.71 112.97,192.76 113.09,192.63 113.35,192.63 113.47,192.76 113.47,193.55 113.6,193.68 113.83,193.68 113.98,193.52 113.98,192.71 114.11,192.58 121.15,192.58 130.09,183.64 135.45,183.64 v4(135.9,183.2)
  BOTTOM w0.102: v4(135.9,183.2) 135.9,183.64 v2(135.61,183.93)
M_A_DQ9: length 67.2
  TOP w0.102: v4(89.34,183.63) 89.6,183.36 CPU1.AR68 ; DIMM1.24 139.39,183.66 137.47,183.66 137.22,183.41 v4(137.22,183.19)
  L3 w0.127: v4(89.34,183.63) 90.45,184.75 90.45,188.91 90.27,189.09 90.27,192.84 93.05,195.62 119.56,195.62 130.01,185.18 134.91,185.18 135.18,184.91 135.18,184.83 136.37,183.64 136.77,183.64 v4(137.22,183.19)
  BOTTOM w0.102: v2(136.96,183.97) 136.96,183.44 137.22,183.19 v4(137.22,183.19)
M_A_DQ10: length 64.8
  TOP w0.089: v4(92.67,188.15) 92.67,188.21 92.54,188.34 91.73,188.34 91.6,188.21 91.6,187.7 91.83,187.47 91.83,186.25 91.6,186.01 91.6,186 91.25,185.65 91.25,185.52 91.17,185.44 CPU1.AU71
  TOP w0.102: DIMM1.36 136.97,180.05 136.56,180.47 v4(136.56,180.97)
  L3 w0.127: v4(92.67,188.15) 92.67,188.06 92.79,187.94 92.84,187.94 93.07,187.71 96.98,187.71 99.96,190.69 99.96,190.72 100.09,190.84 120.52,190.84 129.08,182.28 131.61,182.28 132.24,181.65 135.09,181.65 135.69,182.25 139.02,182.25 139.15,182.12 139.15,181.33 139.02,181.2 138.23,181.2 138.01,181.42 137.01,181.42 136.75,181.16 136.75,181.1 136.62,180.97 v4(136.56,180.97)
  BOTTOM w0.102: v4(136.56,180.97) 136.56,180.44 v2(136.3,180.19)
M_A_DQ11: length 66.7
  TOP w0.089: v4(92.62,188.78) 93.1,188.3 93.1,185.9 92.87,185.67 92.87,185.15 92.28,184.55 92.2,184.37 92.2,184.22 92.24,184.08 92.24,183.87 91.77,183.41 91.19,183.41 CPU1.AU68
  TOP w0.102: DIMM1.34 138.15,180.65 v4(137.83,180.97)
  L3 w0.127: v4(137.83,180.97) 140.24,180.97 140.37,181.1 140.37,182.5 140.24,182.63 135.75,182.63 134.99,181.87 132.48,181.87 131.73,182.63 129.22,182.63 120.66,191.19 99.81,191.19 96.93,188.3 93.16,188.3 92.85,188.62 92.68,188.78 v4(92.62,188.78)
  BOTTOM w0.102: v2(137.57,180.19) 137.83,180.44 v4(137.83,180.97)
M_A_DQ12: length 65.5
  TOP w0.089: 90.08,188.45 90.08,186.24 89.85,186 CPU1.AR71
  TOP w0.102: DIMM1.23 133.96,183.95 v4(134.73,184.73) ; v4(91.03,189.88) 90.86,189.88 90.08,189.1 90.08,188.45
  L3 w0.127: v4(91.03,189.88) 91.03,192.63 93.33,194.94 113.87,194.94 114.22,194.58 114.22,193.86 114.35,193.73 114.61,193.73 114.73,193.86 114.73,194.58 114.86,194.71 115.11,194.71 115.24,194.58 115.24,193.91 115.37,193.78 115.62,193.78 115.75,193.91 115.75,194.44 115.88,194.56 116.24,194.56 116.37,194.44 116.37,193.8 116.66,193.51 120.71,193.51 130.18,184.04 134.04,184.04 v4(134.73,184.73)
  BOTTOM w0.102: v2(134.41,185.5) 134.41,185.05 v4(134.73,184.73)
M_A_DQ13: length 67.3
  TOP w0.089: v4(91.04,188.55) 90.56,188.07 90.56,186.18 90.3,185.92 90.3,185.28 90.25,185.07 90.25,184.63 90.12,184.37 90.07,184.3 CPU1.AR69
  TOP w0.102: DIMM1.21 132.24,184.55 132.51,184.28 132.92,184.28 v4(133.37,184.73)
  L3 w0.127: v4(91.04,188.55) 91.04,188.64 90.61,189.07 90.61,192.7 93.19,195.28 116.36,195.28 116.72,194.93 116.72,194.14 116.84,194.01 117.1,194.01 117.23,194.14 117.23,194.93 117.35,195.05 117.61,195.05 117.73,194.93 117.73,194.19 117.86,194.07 118.11,194.07 118.24,194.19 118.24,194.93 118.37,195.05 118.62,195.05 118.75,194.93 118.75,194.21 118.88,194.08 119.13,194.08 119.26,194.21 119.26,194.93 119.38,195.05 119.65,195.05 130.41,184.29 132.93,184.29 v4(133.37,184.73)
  BOTTOM w0.102: v2(131.81,184.81) 132.16,185.17 132.93,185.17 v4(133.37,184.73)
M_A_DQ14: length 64.9
  TOP w0.089: v4(92.67,187.52) 92.08,186.93 92.08,186.23 91.43,185.58 91.43,185.23 91.37,184.97 CPU1.AU70
  TOP w0.102: DIMM1.33 132.72,180.95 v4(132.75,180.97)
  L3 w0.127: v4(92.67,187.52) 92.81,187.52 93.12,187.2 93.12,186.06 92.62,185.55 92.62,183.77 94.14,182.25 95.41,182.25 96.82,183.65 96.82,184.99 96.69,185.11 95.71,185.11 95.59,185.24 95.59,185.52 95.71,185.65 96.69,185.65 96.82,185.77 96.82,186.03 96.69,186.16 95.54,186.16 95.41,186.28 95.41,186.54 95.54,186.66 96.69,186.66 96.82,186.79 96.82,187.06 100.26,190.5 120.37,190.5 129.8,181.07 132.65,181.07 v4(132.75,180.97)
  BOTTOM w0.102: v4(132.75,180.97) 132.75,180.44 v2(132.49,180.19)
M_A_DQ15: length 65.5
  TOP w0.089: CPU1.AU69 91.45,184.37 91.48,184.44 91.48,184.64 91.62,185.23 91.62,185.49 92.28,186.14 92.28,186.5 v4(92.66,186.88)
  TOP w0.102: DIMM1.35 133.89,180.35 134.15,180.6 v4(134.15,180.97)
  L3 w0.127: v4(92.66,186.88) 92.24,186.45 92.24,185.8 92.11,185.68 91.63,185.68 91.5,185.55 91.5,185.3 91.63,185.17 92.11,185.17 92.24,185.04 92.24,184.79 92.11,184.66 91.65,184.66 91.52,184.53 91.52,184.28 91.65,184.15 92.11,184.15 92.24,184.03 92.24,183.84 94.05,182.03 95.7,182.03 97.12,183.45 97.12,186.88 100.4,190.16 120.23,190.16 129.86,180.53 133.7,180.53 v4(134.15,180.97)
  BOTTOM w0.102: v4(134.15,180.97) 134.15,180.44 v2(133.89,180.19)
M_A_DQ16: length 54.3
  TOP w0.089: CPU1.BB65 94.49,181.56 94.57,181.63 95.31,181.63
  TOP w0.102: 95.31,181.63 96.4,182.72 96.4,184.16 97.46,185.23 97.46,185.24 98.36,186.13 100.28,186.13 100.4,186.26 100.4,186.64 100.28,186.77 v4(100.18,186.77) ; v4(132.75,178.69) 132.77,178.71 132.77,178.89 132.52,179.15 DIMM1.39
  L3 w0.127: v4(132.75,178.69) 132.75,178.98 132.62,179.11 129.06,179.11 119.69,188.48 110.97,188.48 110.72,188.24 110.72,187.93 110.6,187.81 110.34,187.81 110.22,187.93 110.22,188.39 110.09,188.52 109.84,188.52 109.71,188.39 109.71,187.92 109.59,187.81 109.32,187.81 109.2,187.92 109.2,188.42 109.07,188.54 108.82,188.54 108.69,188.42 108.69,188 108.57,187.87 108.31,187.87 108.18,188 108.18,188.39 108.06,188.52 107.8,188.52 107.68,188.39 107.68,187.93 107.55,187.81 107.3,187.81 107.17,187.93 107.17,188.32 107.02,188.47 101.67,188.47 100.18,186.97 v4(100.18,186.77)
  BOTTOM w0.102: v4(132.75,178.69) 131.83,178.69 v2(131.81,178.71)
M_A_DQ17: length 56.6
  TOP w0.089: v4(99.54,186.76) 99.58,186.76 99.7,186.89 99.7,187.2 99.58,187.32 98.9,187.32 98.86,187.29 97.53,187.29 96.81,186.56 96.81,185.34 95.85,184.38 95.85,183.63 95.34,183.12 95.1,183.12 94.83,182.85 94.83,182.63 94.66,182.46 94.21,182.46 94.14,182.48 93.84,182.48 93.84,182.48 93.67,182.31 93.67,182.14 93.66,182.13 93.51,181.98 93.43,181.96 92.93,181.96 92.53,181.56 CPU1.AW65
  TOP w0.102: DIMM1.41 132.12,178.55 132.42,178.26 133.71,178.26 v4(134.15,178.69)
  L3 w0.127: v4(134.15,178.69) 134.28,178.69 134.5,178.91 134.5,179.32 134.37,179.45 129.2,179.45 119.73,188.93 101.63,188.93 99.54,186.83 v4(99.54,186.76)
  BOTTOM w0.102: v2(133.89,177.85) 133.89,178.44 v4(134.15,178.69)
M_A_DQ18: length 57.9
  TOP w0.089: v4(98.84,184.77) 98.39,184.32 98,184.32 97.19,183.51 97.19,182.5 95.13,180.44 94.78,180.44 94.55,180.67 94.18,180.67 94.17,180.66 94.07,180.63 93.19,180.63 93.15,180.67 92.88,180.67 92.62,180.52 CPU1.AW63
  TOP w0.102: v4(134.15,175.39) 133.71,174.95 DIMM1.53
  L3 w0.127: v4(98.84,184.77) 98.42,184.35 97.52,184.35 97.39,184.22 97.39,183.69 97.52,183.57 99.37,183.57 100.17,184.37 101.55,184.37 102.46,185.28 103.25,185.28 103.31,185.34 103.32,185.34 103.42,185.44 119.38,185.44 129.89,174.94 133.7,174.94 v4(134.15,175.39)
  BOTTOM w0.102: v4(134.15,175.39) 133.41,174.65 v2(133.08,174.65)
M_A_DQ19: length 57
  TOP w0.089: CPU1.AY63 93.63,179.88 95.37,179.88 97.9,182.41 97.9,183.16 98.12,183.38 98.84,183.38
  TOP w0.102: v4(132.75,175.39) 132.15,175.39 131.99,175.55 DIMM1.51 ; 98.84,183.38 99.75,183.38 99.92,183.21 100.97,183.21 101.1,183.08 101.1,182.75 101.22,182.63 102.47,182.63 102.6,182.75 102.6,183.77 102.47,183.9 99.93,183.9 99.8,184.02 99.8,184.24 99.96,184.4 100.28,184.4 100.52,184.64 100.52,184.66 100.64,184.79 v4(100.74,184.79)
  L3 w0.127: v4(132.75,175.39) 129.93,175.39 119.53,185.79 103.28,185.79 103.18,185.68 103.17,185.68 103.11,185.62 100.97,185.62 100.74,185.4 v4(100.74,184.79)
  BOTTOM w0.102: v2(131.88,175.39) v4(132.75,175.39)
M_A_DQ20: length 55.8
  TOP w0.089: CPU1.BA65 93.97,181.75 94.23,181.82 95.23,181.82 96.21,182.8 96.21,184.24 97.28,185.31 97.28,185.31 98.33,186.36 98.48,186.36 v4(98.89,186.78)
  TOP w0.102: v4(135.8,178.69) 136.23,179.12 138.03,179.12 138.3,178.85 DIMM1.40
  L3 w0.127: v4(135.8,178.69) 135.8,179.2 135.18,179.82 129.32,179.82 119.87,189.27 101.32,189.27 98.89,186.84 v4(98.89,186.78)
  BOTTOM w0.102: v4(135.8,178.69) 135.8,178.49 v2(136.41,177.88)
M_A_DQ21: length 56.4
  TOP w0.089: CPU1.AY65 93.16,181.56 93.4,181.77 93.78,181.87 93.9,181.92 94.21,182 95.11,182 96.03,182.92 96.03,184.31 97.1,185.38 97.1,185.63 v4(98.23,186.76)
  TOP w0.102: DIMM1.42 137.63,178.25 v4(137.19,178.69)
  L3 w0.127: v4(98.23,186.76) 101.08,189.61 120.01,189.61 129.46,180.16 135.72,180.16 v4(137.19,178.69)
  BOTTOM w0.102: v2(137.8,177.88) 137.19,178.49 v4(137.19,178.69)
M_A_DQ22: length 55.9
  TOP w0.089: v4(99.47,184.8) 98.67,183.99 97.99,183.99 97.38,183.39 97.38,182.4 95.25,180.26 94.71,180.26 94.48,180.49 94.23,180.49 94.14,180.47 94.13,180.46 94,180.46 93.97,180.43 CPU1.BA63
  TOP w0.102: DIMM1.50 138.29,175.85 v4(137.83,175.39)
  L3 w0.127: v4(99.47,184.8) 99.11,185.17 99.11,185.94 99.47,186.31 99.76,186.31 99.76,186.31 102.83,186.31 102.89,186.37 102.9,186.37 103,186.47 119.81,186.47 129.92,176.37 136.85,176.37 v4(137.83,175.39)
  BOTTOM w0.102: v2(138.72,175.39) v4(137.83,175.39)
M_A_DQ23: length 55.4
  TOP w0.089: CPU1.BB63 94.46,180.09 95.32,180.09 97.7,182.47 97.7,183.3 98.09,183.69 98.99,183.69 v4(100.11,184.81)
  TOP w0.102: DIMM1.52 138.31,175.25 138.02,174.96 136.99,174.96 v4(136.56,175.39)
  L3 w0.127: v4(100.11,184.81) 99.7,185.22 99.7,185.75 99.92,185.97 102.97,185.97 103.03,186.03 103.04,186.03 103.14,186.13 119.67,186.13 129.78,176.02 136.3,176.02 136.56,175.77 v4(136.56,175.39)
  BOTTOM w0.102: v4(136.56,175.39) 136.56,175.36 v2(137.35,174.57)
M_A_DQ24: length 54.4
  TOP w0.089: CPU1.BA61 93.98,179.52 95.57,179.52 98.24,182.2 98.31,182.2 v4(98.99,182.88)
  TOP w0.102: DIMM1.56 137.13,174.05 v4(136.56,173.48)
  L3 w0.127: v4(136.56,173.48) 136.56,173.79 135.42,174.93 134.5,174.93 134.2,174.62 129.41,174.62 119.2,184.84 102.51,184.84 101.7,184.03 100.14,184.03 v4(98.99,182.88)
  BOTTOM w0.102: v4(136.56,173.48) 136.15,173.89 v2(136.15,174.27)
M_A_DQ25: length 56.1
  TOP w0.089: CPU1.AW61 92.59,178.95 92.82,178.78 92.86,178.77 93.11,178.77 93.32,178.85 94.77,178.85 95.09,179.17 95.77,179.17 98.11,181.51 99.3,181.51 v4(100.6,182.8)
  TOP w0.102: DIMM1.58 137.86,173.45 v4(137.83,173.48)
  L3 w0.089: 102.4,183.18 102.23,183.02 100.81,183.02 v4(100.6,182.8)
  L3 w0.127: v4(137.83,173.48) 138.23,173.48 138.36,173.35 138.36,173.08 138.23,172.95 132.65,172.95 132.23,173.37 129.22,173.37 118.78,183.81 103.02,183.81 102.4,183.18
  BOTTOM w0.102: v4(137.83,173.48) 138.69,173.48 v2(138.72,173.51)
M_A_DQ26: length 54.4
  TOP w0.089: CPU1.BB59 95.62,177.88 97.73,179.98 99.25,179.98 v4(100.22,180.95)
  TOP w0.102: DIMM1.68 139.38,170.43 136.3,170.43 v4(135.8,169.93)
  L3 w0.127: v4(100.22,180.95) 100.68,180.48 101.67,180.48 101.7,180.5 103.47,180.5 104.39,181.43 117.79,181.43 128.71,170.51 130.43,170.51 131.11,169.83 131.35,169.6 135.26,169.6 135.73,169.13 135.91,169.13 136.17,169.38 136.17,169.56 135.99,169.74 135.98,169.74 v4(135.8,169.93)
  BOTTOM w0.102: v2(135.36,170.76) 135.36,170.36 v4(135.8,169.93)
M_A_DQ27: length 57.5
  TOP w0.089: CPU1.AW59 92.29,177.81 92.13,177.81 91.7,177.38 91.7,177.1 91.9,176.9 92.17,176.9 92.21,176.94 92.52,176.94 92.56,176.9 93.54,176.9 93.66,176.96 93.94,176.96 94.2,177.05 94.24,177.06 95.84,177.06 97.34,178.56 97.94,178.56 98.2,178.81 98.2,179.06 98.46,179.32
  TOP w0.102: v4(137.83,169.93) 137.9,169.85 DIMM1.70 ; 98.46,179.32 100.78,179.32 v4(102.38,180.92)
  L3 w0.127: v4(102.38,180.92) 103.4,180.92 104.25,181.77 117.94,181.77 128.85,170.85 130.63,170.85 131.55,169.93 134.41,169.93 134.86,170.37 137.38,170.37 v4(137.83,169.93)
  BOTTOM w0.102: v2(138.89,170.05) 138.77,169.93 v4(137.83,169.93)
M_A_DQ28: length 53.9
  TOP w0.089: CPU1.BB61 94.46,179.34 95.64,179.34 98.01,181.71 99.25,181.71 100.08,182.54 100.08,182.8 99.96,182.93 99.68,182.93 v4(99.63,182.88)
  TOP w0.102: v4(134.15,173.48) 134.32,173.48 134.45,173.61 134.45,173.94 134.32,174.07 132.39,174.07 132.08,173.75 DIMM1.57
  L3 w0.127: v4(99.63,182.88) 99.63,183.21 100.1,183.68 101.93,183.68 102.74,184.49 119.06,184.49 129.26,174.3 130.04,174.3 130.05,174.29 134.42,174.29 134.55,174.17 134.55,173.76 134.28,173.48 v4(134.15,173.48)
  BOTTOM w0.102: v4(134.15,173.48) 134.37,173.71 134.37,174.22 v2(134.4,174.24)
M_A_DQ29: length 55.2
  TOP w0.089: CPU1.AY61 93.68,179.59 93.79,179.71 95.44,179.71 98.36,182.62 v4(98.36,182.88)
  TOP w0.102: v4(132.75,173.48) 132.42,173.15 DIMM1.59
  L3 w0.127: v4(98.36,182.88) 98.33,182.91 96.88,182.91 96.71,182.73 96.71,181.28 96.83,181.15 97.24,181.15 97.37,181.28 97.37,182.12 97.49,182.25 99.73,182.25 100.18,182.69 100.18,182.98 100.54,183.34 102.07,183.34 102.12,183.39 102.88,184.15 118.92,184.15 129.28,173.79 132.44,173.79 v4(132.75,173.48)
  BOTTOM w0.102: v4(132.75,173.48) 131.83,173.48 v2(131.81,173.46)
M_A_DQ30: length 55.6
  TOP w0.089: v4(100.86,180.93) 99.69,179.76 97.75,179.76 95.61,177.62 94.22,177.62 94.09,177.67 93.99,177.77 93.77,177.77 CPU1.BA59
  TOP w0.102: DIMM1.67 132.68,170.75 132.77,170.84 132.92,170.84 133.33,170.42 133.47,170.42 133.62,170.58 133.62,170.71 133.2,171.13 133.2,171.27 v4(133.51,171.58)
  L3 w0.127: v4(133.51,171.58) 133.52,171.58 133.87,171.23 133.87,170.51 133.74,170.38 133.18,170.38 133.06,170.51 133.06,171.01 132.93,171.13 132.67,171.13 132.55,171.01 132.55,170.51 132.42,170.38 132.06,170.38 131.94,170.51 131.94,171.73 131.63,172.03 128.64,172.03 118.22,182.45 103.96,182.45 103.21,181.7 102.09,181.7 101.71,181.32 101.25,181.32 v4(100.86,180.93)
  BOTTOM w0.102: v4(133.51,171.58) 133.51,171.5 v2(132.77,170.76)
M_A_DQ31: length 56.8
  TOP w0.089: CPU1.AY59 93.42,177.57 93.51,177.53 93.91,177.53 94.19,177.44 95.68,177.44 97.82,179.58 100.18,179.58 v4(101.5,180.9)
  TOP w0.102: DIMM1.69 133.48,170.15 v4(134.91,171.58)
  L3 w0.127: v4(134.91,171.58) 135.29,171.58 135.74,171.13 135.74,170.73 135.61,170.6 134.55,170.6 134.11,170.15 131.81,170.15 130.77,171.2 129.33,171.2 128.99,171.2 118.08,182.11 104.11,182.11 103.35,181.36 102.22,181.36 101.76,180.9 v4(101.5,180.9)
  BOTTOM w0.102: v2(134.15,170.79) 134.91,171.55 v4(134.91,171.58)
M_A_DQ32: length 57.4
  TOP w0.089: v4(100.09,166.72) 99.39,167.43 94.88,167.43 94.75,167.3 94.22,167.3 93.91,167.15 93.57,167.15 93.25,166.83 CPU1.AY39
  TOP w0.102: v4(136.03,148.26) 137.22,149.45 DIMM1.130
  L3 w0.089: v4(100.09,166.72) 100.92,166.72 104.42,163.22
  L3 w0.127: 104.42,163.22 109.47,163.22 124.43,148.26 134.52,148.26 135.34,149.08 136.19,149.08 136.32,148.96 136.32,148.55 136.03,148.26 v4(136.03,148.26)
  BOTTOM w0.102: v2(136.03,149.12) v4(136.03,148.26)
M_A_DQ33: length 55.5
  TOP w0.089: v4(98.71,166.79) 98.75,166.79 98.88,166.66 98.88,165.95 98.75,165.82 94.77,165.82 94.65,165.95 94.17,165.95 94.09,165.91 93.89,165.91 93.81,165.95 93.56,165.95 93.42,165.91 92.64,165.91 92.36,166.19 CPU1.AW39
  TOP w0.102: DIMM1.131 132.43,149.15 132.54,149.04 133.61,149.04 v4(134.02,149.45)
  L3 w0.089: 104.59,163.96 101.25,167.3 99.23,167.3 v4(98.71,166.79)
  L3 w0.127: 104.59,163.96 109.71,163.96 124.63,149.03 133.6,149.03 v4(134.02,149.45)
  BOTTOM w0.102: v2(134.02,148.62) v4(134.02,149.45)
M_A_DQ34: length 57.3
  TOP w0.089: v4(99.9,164.58) 98.92,165.56 97.83,165.56 97.75,165.64 94.69,165.64 94.57,165.77 94.21,165.77 94.13,165.73 93.85,165.73 93.76,165.77 93.59,165.77 93.49,165.74 93.48,165.74 93.34,165.67 CPU1.AY37
  TOP w0.102: v4(134.3,145.56) 133.71,146.15 DIMM1.141
  L3 w0.089: 104.73,160.73 104.69,160.77 104.64,160.77 104.34,161.07 104.21,161.21 100.84,164.58 v4(99.9,164.58)
  L3 w0.127: v4(134.3,145.56) 134.45,145.56 134.58,145.44 134.58,145.34 134.84,145.08 135.29,145.08 135.42,144.96 135.42,144.56 135.29,144.43 133.9,144.43 133.69,144.64 129.45,144.64 129.33,144.75 124.29,144.75 111.3,157.75 110.59,158.46 108.95,158.46 106.68,160.73 104.73,160.73
  BOTTOM w0.102: v2(134.3,144.75) 134.3,145.03 134.3,145.03 v4(134.3,145.56)
M_A_DQ35: length 57.6
  TOP w0.089: v4(97.72,164.55) 97.37,164.9 97.16,165.11 94.64,165.11 94.51,164.98 93.73,164.98 93.42,165.29 92.79,165.29 92.48,165.61 CPU1.AW37
  TOP w0.102: DIMM1.143 132.66,145.55 v4(132.67,145.56)
  L3 w0.089: 103.93,162.17 100.94,165.16 99.21,165.16 98.76,164.71 98.76,164.36 98.53,164.13 98.14,164.13 v4(97.72,164.55)
  L3 w0.127: v4(132.67,145.56) 132.8,145.56 132.92,145.69 132.92,146.28 132.8,146.4 131.24,146.4 131.12,146.28 131.12,145.48 130.99,145.35 130.74,145.35 130.61,145.48 130.61,146.28 130.48,146.4 130.14,146.4 129.3,145.56 124.76,145.56 110.37,159.95 110.19,159.95 109.98,159.74 109.8,159.74 109.62,159.92 109.62,160.1 109.83,160.31 109.83,160.49 109.65,160.67 109.47,160.67 109.04,160.25 108.86,160.25 108.68,160.43 108.68,160.61 109.11,161.03 109.11,161.21 108.87,161.46 104.64,161.46 103.93,162.17
  BOTTOM w0.102: v2(132.67,144.75) v4(132.67,145.56)
M_A_DQ36: length 55.2
  TOP w0.102: v4(132.72,149.47) 132.44,149.75 DIMM1.129 ; CPU1.BB39 95.42,166.83 v4(95.44,166.82)
  L3 w0.089: 104.64,164.31 101.42,167.53 93.26,167.53 92.92,167.19 92.39,167.19 92.26,167.07 92.26,166.85 92.39,166.72 95.34,166.72 v4(95.44,166.82)
  L3 w0.127: 104.64,164.31 109.83,164.31 124.67,149.47 v4(132.72,149.47)
  BOTTOM w0.102: v2(132.72,148.67) v4(132.72,149.47)
M_A_DQ37: length 56.2
  TOP w0.089: CPU1.BA39 93.78,166.94 93.88,166.94 94.05,167.02 94.21,167.1 95.07,167.1 95.21,167.23 98.89,167.23 v4(99.37,166.75)
  TOP w0.102: v4(137.3,148.26) 137.3,148.31 137.83,148.85 DIMM1.132
  L3 w0.089: 104.55,163.58 101.01,167.12 99.74,167.12 v4(99.37,166.75)
  L3 w0.127: 104.55,163.58 109.6,163.58 124.49,148.69 134.62,148.69 135.41,149.48 136.74,149.48 137.3,148.93 v4(137.3,148.26)
  BOTTOM w0.102: v2(137.3,149.05) v4(137.3,148.26)
M_A_DQ38: length 56.8
  TOP w0.089: CPU1.BA37 94.01,165.16 94.4,165.16 94.52,165.29 97.6,165.29 v4(98.36,164.53)
  TOP w0.102: v4(135.98,147.24) 135.98,147.14 137.27,145.85 DIMM1.142
  L3 w0.089: v4(98.36,164.53) 98.36,164.56 99.14,165.34 101.14,165.34 104.15,162.33
  L3 w0.127: 104.15,162.33 104.68,161.8 109.01,161.8 124.77,146.03 129.11,146.03 129.72,146.64 133.54,146.64 133.83,146.94 134.91,146.94 135.46,147.49 135.85,147.49 135.98,147.37 v4(135.98,147.24)
  BOTTOM w0.102: v4(135.98,147.24) 135.98,146.43 v2(136,146.41)
M_A_DQ39: length 56.1
  TOP w0.089: CPU1.BB37 94.36,165.46 97.68,165.46 97.89,165.25 98.23,165.25 98.91,164.57 v4(99.19,164.57)
  TOP w0.102: v4(137.25,147.24) 138.03,146.45 DIMM1.140
  L3 w0.089: 104.68,161.11 104.6,161.11 100.74,164.98 99.6,164.98 v4(99.19,164.57)
  L3 w0.127: 104.68,161.11 107.01,161.11 109.26,158.86 110.98,158.86 124.72,145.12 133.56,145.12 133.82,145.38 133.82,145.72 134.57,146.46 136.47,146.46 v4(137.25,147.24)
  BOTTOM w0.102: v2(137.24,146.41) 137.24,146.7 137.25,146.7 v4(137.25,147.24)
M_A_DQ40: length 61.4
  TOP w0.089: CPU1.AY35 93.13,164.26 93.46,164.26 93.56,164.22 93.76,164.22 93.86,164.25 94.13,164.25 94.25,164.2 94.85,164.2 94.93,164.12 95.29,164.12 96.22,164.12 96.42,164.32 v4(96.42,164.49)
  TOP w0.102: DIMM1.149 132.48,143.75 v4(132.7,143.96)
  L3 w0.089: v4(96.42,164.49) 96.42,164.19 96.84,163.77 100.8,163.77 104.61,159.96
  L3 w0.127: v4(132.7,143.96) 132.48,144.18 129.45,144.18 129.33,144.07 123.66,144.07 123.55,144.18 121.46,146.27 121.28,146.27 120.9,145.89 120.72,145.89 120.54,146.07 120.54,146.25 120.92,146.63 120.92,146.81 120.74,146.99 120.56,146.99 120.18,146.61 120.01,146.61 119.83,146.79 119.83,146.97 120.2,147.35 120.2,147.53 120.02,147.71 119.84,147.71 119.47,147.33 119.29,147.33 119.11,147.51 119.11,147.69 119.48,148.07 119.48,148.25 119.24,148.49 119.06,148.49 118.68,148.11 118.5,148.11 118.32,148.29 118.32,148.47 118.7,148.85 118.7,149.03 118.52,149.21 118.34,149.21 117.96,148.83 117.79,148.83 117.61,149.01 117.61,149.19 117.98,149.57 117.98,149.75 117.8,149.93 117.62,149.93 117.25,149.55 117.07,149.55 116.89,149.73 116.89,149.91 117.26,150.29 117.26,150.47 117.08,150.65 116.9,150.65 116.53,150.27 116.35,150.27 116.17,150.45 116.17,150.63 116.54,151.01 116.54,151.19 116.36,151.37 116.18,151.37 115.81,150.99 115.63,150.99 115.45,151.17 115.45,151.35 115.83,151.72 115.83,151.9 115.58,152.15 114.52,152.15 113.09,153.57 109.11,157.55 108.57,157.55 106.16,159.96 105.57,159.96 104.61,159.96
  BOTTOM w0.102: v2(132.7,143.18) v4(132.7,143.96)
M_A_DQ41: length 62.4
  TOP w0.089: CPU1.AW35 92.66,164.08 93.43,164.08 93.53,164.04 93.8,164.04 93.89,164.08 94.1,164.08 94.18,164.04 94.18,164.04 94.24,164.01 94.75,164.01 94.82,163.94 94.86,163.94 96.54,163.94 v4(97.06,164.47)
  TOP w0.102: DIMM1.147 131.25,144.4 133.61,144.4 v4(134.04,143.96)
  L3 w0.089: v4(97.06,164.47) 97.58,163.95 101.1,163.95 104.66,160.39
  L3 w0.127: 104.66,160.39 104.75,160.3 105.15,160.3 106.3,160.3 108.71,157.89 110.04,157.89 110.32,157.89 110.33,157.89 110.57,157.64 110.57,157.47 110.22,157.11 110.22,156.93 110.4,156.75 110.58,156.75 110.93,157.11 111.11,157.11 111.29,156.93 111.29,156.75 110.94,156.39 110.94,156.21 111.12,156.03 111.29,156.03 111.65,156.39 111.83,156.39 112.01,156.21 112.01,156.03 111.65,155.67 111.65,155.49 111.83,155.31 112.01,155.31 112.37,155.67 112.55,155.67 112.73,155.49 112.73,155.31 112.37,154.95 112.37,154.78 112.55,154.6 112.73,154.6 113.09,154.95 113.27,154.95 113.45,154.77 113.45,154.59 113.09,154.24 113.09,154.06 113.27,153.88 113.45,153.88 113.81,154.23 113.99,154.23 114.17,154.05 114.17,153.87 113.81,153.52 113.81,153.34 113.99,153.16 114.17,153.16 114.52,153.51 114.7,153.51 114.95,153.27 114.95,153.09 114.77,152.91 114.77,152.74 114.95,152.56 115.13,152.56 115.31,152.73 115.49,152.73 123.81,144.41 133.6,144.41 v4(134.04,143.96)
  BOTTOM w0.102: v2(134.04,143.18) v4(134.04,143.96)
M_A_DQ42: length 61.6
  TOP w0.089: v4(96.43,162.45) 96.09,162.8 95.54,162.8 95.46,162.71 94.21,162.71 94.2,162.72 94.09,162.74 94.03,162.78 93.68,162.86 93.44,162.86 93.24,163 CPU1.AY33
  TOP w0.102: DIMM1.160 139.37,140.42 v4(137.92,140.42)
  L3 w0.089: 104.56,157.19 104.46,157.19 99.89,161.76 97.11,161.76 97.11,161.77 97.11,161.78 v4(96.43,162.45)
  L3 w0.127: v4(137.92,140.42) 140.05,140.42 140.18,140.55 140.18,141.04 140.05,141.17 136.98,141.17 136.75,140.94 121.01,140.94 104.76,157.19 104.56,157.19
  BOTTOM w0.102: v2(137.92,139.64) v4(137.92,140.42)
M_A_DQ43: length 60.5
  TOP w0.102: CPU1.AW33 92.36,163.83 91.85,164.34 v4(91.85,164.52) ; DIMM1.158 137.24,141.05 v4(136.61,140.42)
  L3 w0.089: 104.25,157.12 99.83,161.54 94.83,161.54 v4(91.85,164.52)
  L3 w0.127: 104.25,157.12 104.47,156.91 104.56,156.91 120.87,140.6 130.85,140.6 130.86,140.61 134.93,140.61 135.54,140 136.18,140 v4(136.61,140.42)
  BOTTOM w0.102: v2(136.61,139.64) v4(136.61,140.42)
M_A_DQ44: length 59.9
  TOP w0.102: v4(95.08,164.53) 95.03,164.48 CPU1.BB35 ; v4(137.94,144.66) 137.95,144.65 DIMM1.146
  L3 w0.089: v4(95.08,164.53) 96.2,163.42 100.27,163.42 104.41,159.27 104.55,159.27
  L3 w0.127: v4(137.94,144.66) 137.94,145.68 138.07,145.8 138.62,145.8 138.74,145.68 138.74,143.3 138.62,143.18 123.87,143.18 122.47,143.18 108.79,156.86 108.29,156.86 105.87,159.27 104.55,159.27
  BOTTOM w0.102: v2(137.94,143.83) v4(137.94,144.66)
M_A_DQ45: length 60.8
  TOP w0.089: CPU1.BA35 93.96,164.78 94.65,164.78 94.8,164.93 95.37,164.93 v4(95.77,164.53)
  TOP w0.102: v4(136.67,144.66) 136.64,144.66 136.51,144.54 136.51,144.01 136.64,143.89 137.18,143.89 137.31,144.01 137.31,144.14 137.44,144.27 137.73,144.27 137.85,144.15 137.85,143.99 137.96,143.89 138.34,143.89 138.51,144.05 DIMM1.148
  L3 w0.089: 104.68,159.62 104.45,159.62 100.47,163.6 96.71,163.6 v4(95.77,164.53)
  L3 w0.127: 104.68,159.62 106.01,159.62 108.42,157.21 108.93,157.21 120.89,145.24 121.07,145.24 121.45,145.61 121.63,145.61 121.81,145.44 121.81,145.26 121.43,144.88 121.43,144.7 121.61,144.52 121.79,144.52 122.17,144.9 122.35,144.9 122.53,144.72 122.53,144.54 122.15,144.16 122.15,143.98 122.61,143.52 123.73,143.52 123.93,143.72 129.33,143.72 129.56,143.95 132.08,143.95 132.51,143.52 134.88,143.52 135.31,143.95 136.44,143.95 136.67,144.18 v4(136.67,144.66)
  BOTTOM w0.102: v2(136.67,143.83) v4(136.67,144.66)
M_A_DQ46: length 61.4
  TOP w0.089: CPU1.BA33 93.78,163.15 94.11,162.95 94.13,162.92 94.15,162.91 94.23,162.89 95.38,162.89 95.47,162.98 96.61,162.98 v4(97.09,162.5)
  TOP w0.102: DIMM1.159 132.12,140.75 132.23,140.64 135.38,140.64 135.5,140.77 135.5,143.4 135.38,143.53 134.14,143.53 134.01,143.4 134.01,141.86 v4(134.12,141.74)
  L3 w0.089: v4(97.09,162.5) 97.64,161.94 100.09,161.94 104.46,157.57 104.6,157.57
  L3 w0.127: 104.6,157.57 105.14,157.57 107.58,155.13 108.15,155.13 109.58,153.7 109.58,152.91 121.2,141.28 133.66,141.28 v4(134.12,141.74)
  BOTTOM w0.102: v4(134.12,141.74) 134.12,140.97 v2(134.15,140.94)
M_A_DQ47: length 60.2
  TOP w0.089: CPU1.BB33 95.39,163.15 95.39,163.15 97.95,163.15 98.08,163.03 98.08,162.84 97.78,162.54 v4(97.74,162.54)
  TOP w0.102: v4(132.82,141.73) 132.87,141.73 133.29,141.31 133.65,141.31 133.66,141.31 134.66,141.31 134.78,141.18 134.78,140.97 134.66,140.84 132.44,140.84 132.32,140.97 132.32,141.22 132.19,141.35 DIMM1.157
  L3 w0.089: v4(97.74,162.54) 98.14,162.14 100.4,162.14 104.62,157.92
  L3 w0.102: 132.81,141.74 v4(132.82,141.73)
  L3 w0.127: 104.62,157.92 105.32,157.92 107.72,155.52 108.24,155.52 109.92,153.84 109.92,153.05 116.83,146.15 117.01,146.15 117.22,146.36 117.4,146.36 117.58,146.18 117.58,146 117.36,145.79 117.36,145.61 117.54,145.43 117.72,145.43 117.94,145.64 118.12,145.64 118.3,145.46 118.3,145.28 118.08,145.07 118.08,144.89 118.26,144.71 118.44,144.71 118.66,144.92 118.84,144.92 119.02,144.74 119.02,144.56 118.8,144.35 118.8,144.17 118.98,143.99 119.16,143.99 119.38,144.2 119.56,144.2 119.74,144.02 119.74,143.85 119.52,143.63 119.52,143.45 119.7,143.27 119.88,143.27 120.1,143.49 120.28,143.49 120.45,143.31 120.45,143.13 120.24,142.91 120.24,142.73 121.13,141.84 129.41,141.84 129.58,142.01 132.69,142.01 132.81,141.88 132.81,141.74
  BOTTOM w0.102: v4(132.82,141.73) 132.82,141.2 v2(132.57,140.94)
M_A_DQ48: length 60
  TOP w0.089: v4(97.73,161.01) 97.31,161.43 94.18,161.43 94.03,161.58 93.37,161.58 93.3,161.63 CPU1.AY31
  TOP w0.102: v4(135.99,138.06) 137.19,139.25 DIMM1.164
  L3 w0.089: 102.75,156.49 98.6,160.64 98.11,160.64 v4(97.73,161.01)
  L3 w0.127: v4(135.99,138.06) 135.55,138.5 132.39,138.5 132.27,138.37 132.27,137.74 132.14,137.62 131.88,137.62 131.76,137.74 131.76,138.37 131.63,138.5 131.38,138.5 131.25,138.37 131.25,137.96 131.12,137.83 130.87,137.83 130.74,137.96 130.74,138.37 130.61,138.5 120.74,138.5 102.75,156.49
  BOTTOM w0.102: v2(135.99,137.27) v4(135.99,138.06)
M_A_DQ49: length 61.4
  TOP w0.089: 98.77,162 95.42,162 95.13,162.29 94.09,162.29 93.97,162.17 92.86,162.17 92.55,161.85 CPU1.AW31
  TOP w0.102: DIMM1.163 132.1,139.55 132.36,139.29 133.24,139.29 133.37,139.42 v4(133.37,140.16) ; 98.77,162 99.75,162 100.41,162.66 100.41,163.8 100.54,163.93 101.05,163.93 101.17,163.8 101.17,161.74 100.22,160.78 99.85,160.78 99.72,160.91 v4(99.72,161.05)
  L3 w0.089: v4(99.72,161.05) 99.72,160.97 103.64,157.06
  L3 w0.127: 103.64,157.06 120.98,139.72 132.93,139.72 v4(133.37,140.16)
  BOTTOM w0.102: v2(133.37,139.29) v4(133.37,140.16)
M_A_DQ50: length 59.6
  TOP w0.089: CPU1.AY29 93.41,160.35 93.57,160.23 93.76,160.18 93.87,160.06 94.57,160.06 94.74,159.89 94.76,159.89 94.76,159.89 95.65,159.89 v4(96.05,159.49)
  TOP w0.102: DIMM1.174 137.93,136.25 v4(137.92,136.26)
  L3 w0.089: v4(96.05,159.49) 97.06,158.48 98.59,158.48
  L3 w0.102: 98.59,158.48 98.61,158.46 98.61,158.45 101.15,155.9 101.15,154.2
  L3 w0.127: v4(137.92,136.26) 137.04,135.38 135.65,135.38 134.94,134.68 121.22,134.68 106.32,149.58 105.77,149.58 101.15,154.2
  BOTTOM w0.102: v2(138.79,136.26) v4(137.92,136.26)
M_A_DQ51: length 59.4
  TOP w0.102: DIMM1.175 132.62,135.95 132.74,135.82 v4(132.74,135.81) ; v4(91.8,160.52) 91.86,160.52 91.97,160.63 CPU1.AW29
  L3 w0.089: 102.01,155.34 102.01,156.07 98.15,159.93 93.19,159.93 93.07,160.05 93.07,160.21 93.06,160.22 93.06,160.85 92.93,160.98 91.92,160.98 91.8,160.85 v4(91.8,160.52)
  L3 w0.127: v4(132.74,135.81) 127.47,135.81 126.29,136.99 125.86,136.99 125.73,136.86 125.73,135.81 125.63,135.71 125.2,135.71 125.1,135.81 125.1,136.86 124.97,136.99 124.59,136.99 124.46,136.86 124.46,136.22 124.34,136.09 123.95,136.09 123.83,136.22 123.83,136.86 123.7,136.99 120.37,136.99 102.01,155.34
  BOTTOM w0.102: v2(132.74,135.02) v4(132.74,135.81)
M_A_DQ52: length 58.2
  TOP w0.089: CPU1.BB31 94.78,161.85 95.02,161.61 97.83,161.61 v4(98.41,161.04)
  TOP w0.102: DIMM1.166 137.87,138.65 v4(137.28,138.06)
  L3 w0.089: 103.03,156.7 99.2,160.53 99,160.53 98.5,161.04 v4(98.41,161.04)
  L3 w0.127: 103.03,156.7 120.88,138.85 136.24,138.85 136.36,138.97 136.36,139.74 136.48,139.85 137.16,139.85 137.28,139.72 v4(137.28,138.06)
  BOTTOM w0.102: v2(137.28,137.28) v4(137.28,138.06)
M_A_DQ53: length 59
  TOP w0.089: CPU1.BA31 93.9,161.85 94.16,162.11 95.06,162.11 95.35,161.82 98.28,161.82 v4(99.04,161.05)
  TOP w0.102: v4(134.67,140.11) 133.51,138.95 DIMM1.165
  L3 w0.089: v4(99.04,161.05) 99.45,160.65 99.56,160.65 103.33,156.88
  L3 w0.127: 103.33,156.88 121.02,139.19 136.01,139.19 136.13,139.32 136.13,139.64 136.01,139.77 135.45,139.77 135.32,139.9 135.11,140.11 v4(134.67,140.11)
  BOTTOM w0.102: v4(134.67,140.11) 134.67,139.35 134.68,139.34 v2(134.68,139.19)
M_A_DQ54: length 58.8
  TOP w0.089: CPU1.BA29 93.94,160.35 94.04,160.25 94.65,160.25 94.84,160.07 96.11,160.07 v4(96.7,159.48)
  TOP w0.102: v4(136.59,136.25) 137.18,135.65 DIMM1.176
  L3 w0.089: 101.51,155.84 98.56,158.78 97.4,158.78 v4(96.7,159.48)
  L3 w0.127: v4(136.59,136.25) 136.14,135.8 135.58,135.8 134.8,135.02 121.36,135.02 106.46,149.92 106.12,149.92 101.51,154.53 101.51,155.84
  BOTTOM w0.102: v2(136.13,135.46) 136.59,135.92 v4(136.59,136.25)
M_A_DQ55: length 57.7
  TOP w0.089: CPU1.BB29 94.7,160.53 94.98,160.25 96.57,160.25 v4(97.33,159.48)
  TOP w0.102: v4(134.07,135.78) 134.07,135.48 133.95,135.35 DIMM1.177
  L3 w0.089: v4(97.33,159.48) 97.81,159.01 98.71,159.01 101.79,155.93
  L3 w0.127: v4(134.07,135.78) 133.66,135.36 124.08,135.36 123.95,135.49 123.95,135.63 123.83,135.75 123.4,135.75 123.28,135.63 123.28,135.49 123.15,135.36 122.89,135.36 122.77,135.49 122.77,136.52 122.64,136.64 122.26,136.64 122.13,136.52 122.13,135.49 122.01,135.36 121.51,135.36 106.6,150.27 106.51,150.27 101.79,154.99 101.79,155.93
  BOTTOM w0.102: v2(134.07,134.99) v4(134.07,135.78)
M_A_DQ56: length 63
  TOP w0.089: v4(96.98,158.04) 96.55,158.46 95.32,158.46 94.74,159.04 94.27,159.04 94.06,159.1 93.86,159.15 93.53,159.15 93.37,159.22 93.3,159.28 CPU1.AY27
  TOP w0.102: DIMM1.181 133.6,134.15 v4(134.78,132.97)
  L3 w0.089: v4(96.98,158.04) 96.24,158.78 96.06,158.78 95.56,158.28 95.56,158.1 96.29,157.37 98.84,157.37 98.91,157.3 99.47,156.74 99.47,155.96
  L3 w0.127: v4(134.78,132.97) 134.3,133.45 120.71,133.45 105.88,148.27 104.85,148.27 100.29,152.83 100.29,155.14 99.47,155.96
  BOTTOM w0.102: v4(134.78,132.97) 134.78,132.44 v2(134.53,132.18)
M_A_DQ57: length 63
  TOP w0.102: v4(133.39,133) 132.84,133.55 DIMM1.183 ; v4(92.67,160.05) 92.36,159.74 CPU1.AW27
  L3 w0.089: v4(92.67,160.05) 93.55,159.17 93.67,159.17 94.17,159.67 94.35,159.67 94.49,159.53 94.49,159.35 93.64,158.5 93.64,158.32 93.77,158.19 93.95,158.19 94.91,159.15 95.09,159.15 95.22,159.01 95.22,158.83 94.62,158.22 94.62,158.1 95.58,157.13 98.83,157.13 99.1,156.86 99.1,155.82
  L3 w0.127: 99.1,155.82 100.06,154.86 100.06,152.34 104.47,147.93 105.74,147.93 121.11,132.56 132.95,132.56 v4(133.39,133)
  BOTTOM w0.102: v2(133.14,132.21) 133.39,132.47 v4(133.39,133)
M_A_DQ58: length 62.7
  TOP w0.089: CPU1.AY25 93.37,157.9 93.45,157.86 93.45,157.86 93.79,157.86 94.4,157.67 94.86,157.21 95.44,157.21 v4(95.98,156.68)
  TOP w0.102: v4(136.18,130.56) 136.69,130.05 137.7,130.05 137.9,130.25 DIMM1.194
  L3 w0.127: v4(136.18,130.56) 135.32,129.7 132.36,129.7 131.78,130.28 120.28,130.28 107.01,143.55 103.96,143.55 98.45,149.06 98.45,153.91 95.98,156.38 v4(95.98,156.68)
  BOTTOM w0.102: v4(136.18,130.56) 136.18,130.02 v2(135.92,129.77)
M_A_DQ59: length 63.3
  TOP w0.102: DIMM1.192 137.74,130.85 v4(137.45,130.56) ; CPU1.AW25 v4(92.67,157.65)
  L3 w0.127: v4(137.45,130.56) 136.25,129.36 132.17,129.36 131.61,129.92 120.1,129.92 106.81,143.21 103.8,143.21 98.13,148.88 98.13,153.89 96.06,155.96 95.03,155.96 v4(92.67,157.65)
  BOTTOM w0.102: v2(137.19,129.77) 137.45,130.02 v4(137.45,130.56)
M_A_DQ60: length 61.2
  TOP w0.102: v4(98.25,158.02) 98.25,158.09 97.33,159 95.31,159 94.88,159.43 94.53,159.43 94.47,159.5 CPU1.BB27 ; DIMM1.180 138.1,134.45 v4(137.93,134.28)
  L3 w0.089: 98.68,158.02 98.69,158.02 100.11,156.61 100.11,156.13
  L3 w0.102: v4(98.25,158.02) 98.68,158.02
  L3 w0.127: 100.11,156.13 100.76,155.49 100.76,153.48 105.28,148.96 106.17,148.96 120.79,134.34 135.11,134.34 135.76,134.99 139.01,134.99 139.14,134.86 139.14,134.4 139.01,134.28 v4(137.93,134.28)
  BOTTOM w0.102: v4(137.93,134.28) v2(138.77,134.28)
M_A_DQ61: length 62.3
  TOP w0.089: CPU1.BA27 93.97,159.3 94.29,159.22 94.81,159.22 95.39,158.64 97,158.64 v4(97.61,158.03)
  TOP w0.102: v4(136.57,134.28) 136.54,134.28 136.12,133.86 136.12,133.57 136.25,133.44 137.45,133.44 137.58,133.57 137.58,133.72 137.71,133.85 138.11,133.85 138.11,133.85 DIMM1.182
  L3 w0.089: v4(97.61,158.03) 98.04,157.6 98.86,157.6 99.82,156.64 99.82,156.12
  L3 w0.127: v4(136.57,134.28) 136.65,134.28 136.92,134 136.92,133.58 136.8,133.45 134.62,133.45 134.28,133.79 120.85,133.79 106.03,148.62 104.99,148.62 100.54,153.06 100.54,155.4 99.82,156.12
  BOTTOM w0.102: v4(136.57,134.28) 136.57,134.41 v2(137.35,135.18)
M_A_DQ62: length 61.8
  TOP w0.089: v4(96.63,156.68) 96.22,157.08 95.84,157.08 95.52,157.4 94.92,157.4 94.49,157.83 94.02,157.98 CPU1.BA25
  TOP w0.102: DIMM1.191 131.95,131.15 132.11,131.32 134.02,131.32 v4(134.78,130.56)
  L3 w0.127: v4(134.78,130.56) 134.27,130.04 132.5,130.04 131.88,130.66 120.4,130.66 104.88,146.18 101.81,146.18 99.63,148.36 99.63,148.54 99.88,148.8 99.88,148.98 99.61,149.24 99.43,149.24 99.18,148.99 99,148.99 98.74,149.25 98.74,154 96.63,156.11 v4(96.63,156.68)
  BOTTOM w0.102: v4(134.78,130.56) 134.78,130.02 v2(134.53,129.77)
M_A_DQ63: length 60.7
  TOP w0.089: v4(97.32,156.69) 96.91,157.1 96.5,157.1 96.34,157.26 95.91,157.26 95.6,157.58 95.04,157.58 94.45,158.17 CPU1.BB25
  TOP w0.102: DIMM1.193 131.85,130.55 132.37,131.06 133,131.06 v4(133.51,130.56)
  L3 w0.127: v4(133.51,130.56) 133.07,131 120.57,131 105.04,146.53 103.84,146.53 102.41,147.97 102.23,147.97 101.59,147.33 101.41,147.33 101.14,147.6 101.14,147.78 101.78,148.42 101.78,148.6 101.51,148.87 101.33,148.87 100.59,148.13 100.42,148.13 100.15,148.4 100.15,148.58 100.88,149.31 100.88,149.49 98.99,151.38 98.99,154.23 97.32,155.9 v4(97.32,156.69)
  BOTTOM w0.102: v2(133.26,129.77) 133.51,130.02 v4(133.51,130.56)
M_A_DQS_DN0: length 71.3
  TOP w0.089: CPU1.AM70 88.36,184.54 88.36,184.72 88.42,184.92 88.42,185.06 88.37,185.21 88.37,185.66 88.37,185.67 88.37,186.01 88.41,186.06 88.41,186.68 88.4,186.69 88.4,186.71
  TOP w0.102: 88.4,186.71 88.4,189.95 88.33,190.02 88.07,190.02 v4(87.84,189.79) ; DIMM1.10 138.48,187.85 138.35,187.72 137.59,187.72 136.48,186.61 v4(136.48,186.32)
  L3 w0.127: v4(136.48,186.32) 136.56,186.32 136.68,186.43 136.68,186.84 135.72,187.79 130.44,187.79 120.4,197.84 92.42,197.84 88.3,193.72 88.3,189.61 88.17,189.48 88.02,189.48 87.84,189.66 v4(87.84,189.79)
  BOTTOM w0.102: v2(136.94,185.49) 136.48,185.96 v4(136.48,186.32)
M_A_DQS_DN1: length 65.9
  TOP w0.089: CPU1.AT69 90.51,183.81 90.9,184.2 90.9,184.71 90.95,184.89 90.95,185.08 90.9,185.26 90.9,185.28 90.9,185.57 91.66,186.32 91.66,187.24 v4(91.04,187.86)
  TOP w0.102: v4(133.97,182.35) 133.35,182.97 132.4,182.97 132.18,182.75 DIMM1.27
  L3 w0.127: v4(91.04,187.86) 91.3,187.86 91.82,188.39 91.82,189.26 92.15,189.58 93.01,189.58 93.49,189.1 96.6,189.1 99.66,192.16 105.97,192.16 106.81,193 107.31,193 107.58,192.74 107.58,192.15 107.7,192.02 108.06,192.02 108.2,192.16 108.2,193.4 108.48,193.69 109.07,193.69 109.35,193.4 109.35,192.13 109.48,192 109.87,192 110,192.13 110,193.48 110.29,193.76 110.89,193.76 111.17,193.48 111.17,192.21 111.37,192.01 120.96,192.01 129.56,183.41 133.63,183.41 133.9,183.14 133.9,182.41 v4(133.97,182.35)
  BOTTOM w0.102: v2(134.07,183.13) 134.07,182.45 v4(133.97,182.35)
M_A_DQS_DN2: length 56.4
  TOP w0.089: CPU1.BA64 93.54,181.1 93.72,181.1 93.92,181.16 94.06,181.16 94.21,181.11 94.63,181.11 94.78,181.26 95.62,181.26 96.83,182.47 96.83,184.05 98.2,185.42 98.45,185.42 98.46,185.41 98.54,185.41 98.54,185.41 98.63,185.41
  TOP w0.102: DIMM1.45 131.89,177.35 132.28,176.96 132.28,176.67 132.42,176.53 133.71,176.53 133.8,176.62 133.8,176.75 v4(133.51,177.04) ; v4(102.09,186.79) 102.19,186.79 102.32,186.66 102.32,186.62 102.55,186.38 102.6,186.38 102.73,186.25 102.73,186.06 102.6,185.93 101.74,185.93 101.22,185.41 98.63,185.41
  L3 w0.127: v4(102.09,186.79) 102.03,186.79 101.9,186.92 101.9,187.34 102.23,187.67 103.59,187.67 104.05,187.21 104.51,187.21 104.97,187.67 106.15,187.67 106.81,187 120.03,187 129.06,177.98 133.59,177.98 133.75,177.82 133.75,177.28 v4(133.51,177.04)
  BOTTOM w0.102: v4(133.51,177.04) 132.75,177.8 132.7,177.8 v2(132.67,177.83)
M_A_DQS_DN3: length 55.7
  TOP w0.089: CPU1.AY60 93.06,178.16 93.69,178.16 93.89,178.1 94.09,178.1 94.24,178.14 95.5,178.14 95.68,178.32 95.7,178.32 95.71,178.34
  TOP w0.102: 95.71,178.34 95.78,178.41 97.61,180.24 99.09,180.24 99.36,180.51 99.36,180.77 v4(99.58,180.98) ; DIMM1.62 137.23,172.25 v4(136.56,171.58)
  L3 w0.127: v4(136.56,171.58) 136.81,171.83 136.81,172.07 136.62,172.27 132.15,172.27 131.83,172.59 128.86,172.59 118.44,183.01 103.76,183.01 102.99,182.24 101.85,182.24 101.12,181.51 99.85,181.51 99.58,181.24 v4(99.58,180.98)
  BOTTOM w0.102: v4(136.56,171.58) 136.56,170.79 v2(136.63,170.71)
M_A_DQS_DN4: length 56.6
  TOP w0.089: v4(97.38,166.8) 96.8,166.22 95.11,166.22 94.93,166.39 94.21,166.39 94.06,166.44 93.92,166.44 93.72,166.37 93.42,166.37 93.34,166.3 CPU1.BA38
  TOP w0.102: DIMM1.135 131.98,147.95 132.28,147.65 132.28,147.28 132.41,147.15 133.33,147.15 133.5,147.32 v4(133.5,147.57)
  L3 w0.089: 104.46,162.81 104.44,162.83 104.39,162.83 103.65,163.56 102.38,164.84 101.11,166.11 101.11,166.11 101.05,166.16 97.27,166.16 96.95,166.48 96.95,167.01 97.08,167.13 97.25,167.13 97.38,167 v4(97.38,166.8)
  L3 w0.127: 104.46,162.81 104.67,162.6 109.34,162.6 124.88,147.06 125.56,147.06 125.77,147.27 125.77,147.43 126.06,147.71 126.59,147.71 126.88,147.43 126.88,147.05 127,146.92 127.42,146.92 127.55,147.05 127.55,147.45 127.83,147.73 128.5,147.73 128.78,147.45 128.78,147.27 128.91,147.14 133.32,147.14 133.5,147.32 v4(133.5,147.57)
  BOTTOM w0.102: v2(133.13,146.86) 133.5,147.24 v4(133.5,147.57)
