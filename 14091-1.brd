# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VCORE_VCC: length 10.7
  TOP w0.305: v3(29.5,207.01) 29.5,205.82 28.88,205.21 28.25,205.21 PC4627.1
  TOP w0.508: v3(29.5,207.01) v1(30.84,207.01) 31.78,207.01 32.29,207.52 PR4639.2
  BOTTOM w0.203: PU4601.13 28.34,204.84 29.5,205.99 29.5,206.38
  BOTTOM w0.508: 29.5,206.38 v3(29.5,207.01)
PWR_VCORE_VR_RDY: length 8.1
  BOTTOM w0.102: PU4601.42 22.41,199.95 22.13,199.67 21.31,199.67 20.73,199.09 20.73,196.79 PR4665.1 19.47,195.64 v2(18.48,194.66)
PWR_VCORE_VRHOT#: length 3.3
  BOTTOM w0.203: 24.68,197.69 25.14,198.16 PU4601.35
  BOTTOM w0.254: PR4663.2 24.59,195.73 v2(24.59,197.56) 24.59,197.6 24.68,197.69
PWR_VCORE_VRMP: length 7.5
  TOP w0.305: v3(28.61,205.87) 27.21,205.87 26.32,204.98 PC4629.1
  TOP w0.508: v3(28.61,205.87) 28.76,206.02 28.76,207.09 v1(28.53,207.31) 28.58,207.37 28.58,208.57 PR4638.1
  BOTTOM w0.203: PU4601.12 27.94,205.2 v3(28.61,205.87)
PWR_VCORE_VSN: length 7.1
  TOP w0.254: PC4624.1 PR4635.1 29.92,196.06 28.02,196.06 v1(28.02,196.06) 27.69,196.06 27.06,196.7 27.06,197.48 27.37,197.79 v3(27.59,197.79)
  BOTTOM w0.203: v3(27.59,197.79) 27.54,197.84 PU4601.29
PWR_VCORE_VSN_G: length 6.2
  TOP w0.254: PG4606.1 31.02,192.07 31.02,192.85 PC4623.1 30.32,193.55 29.95,193.55 v1(29.14,194.36) 29.98,195.2 29.98,195.24 PR4635.2 PC4624.2
PWR_VCORE_VSP: length 8.2
  TOP w0.254: v3(27.62,197.03) 27.97,197.38 v1(29.29,197.38) 31.52,197.38 PR4641.2 PR4661.1
  BOTTOM w0.203: v3(27.62,197.03) 28.1,197.51 28.1,198 27.94,198.16 PU4601.28
PWR_VCORE_VSP_G: length 6
  TOP w0.254: PG4607.1 31.85,192.01 PC4623.2 PC4621.2 32.28,193.5 32.01,193.5 v1(31.28,194.23) 31.28,194.5 PR4641.1
PWR_VCORE_VSP_RC: length 3.8
  TOP w0.254: v1(33.75,191.92) PC4621.1 33.69,192.98 33.69,194.88 33.57,195 33.57,195.46 PR4661.2
PWR_VDDQ_BOOT: length 3.3
  BOTTOM w0.203: PU5104.18 87.54,211.58 87.71,211.4 v2(88.43,211.4)
  BOTTOM w0.508: PR5103.1 89.03,210.82 88.44,211.4 v2(88.43,211.4)
PWR_VDDQ_BOOT_1: length 4
  BOTTOM w0.254: PC5114.1 92.54,212.72 v2(92.74,212.52) 92.74,211.75 91.81,210.82 PR5103.2
PWR_VDDQ_CS: length 4.9
  BOTTOM w0.203: 85.5,214 85.25,213.74 PU5104.13
  BOTTOM w0.254: 85.5,214 86.16,214.66 v2(86.16,214.76) 86.24,214.83 86.24,215.23 86.9,215.89 PR5111.2 PC5111.2
PWR_VDDQ_EN: length 6.9
  BOTTOM w0.102: PU5104.8 82.33,211.58 v2(82.08,211.84) 81.57,212.34 81.57,213.61 81.19,214 C1796.1 80.93,212.92 R1810.2 81,212.72 R80117.2
PWR_VDDQ_FB: length 5.1
  BOTTOM w0.203: PU5104.6 82.8,210.78 82.33,210.31
  BOTTOM w0.254: 82.33,210.31 v2(82.19,210.17) 81.38,209.36 PR5110.1 PR5102.2 PC5112.2
PWR_VDDQ_LGATE: length 29.2
  L3 w0.762: v5(86.77,213.49) 86.01,214.25 86.01,216.15 91.85,222 101.25,222 103.79,224.54 v5(103.79,225.81)
  BOTTOM w0.203: PU5104.15 86.42,213.13 v5(86.77,213.49)
  BOTTOM w0.762: v2(104.94,226.09) 104.07,226.09 v5(103.79,225.81) 103.67,225.68 PU5102.4
PWR_VDDQ_PG: length 182.2
  TOP w0.102: R80141.1 13.56,184.79 13.9,184.79 14.38,185.27 v3(14.38,185.29)
  L3 w0.127: v3(79.54,216.03) 80.55,217.04 80.55,218.17 80.55,218.17 80.55,223.59 78.81,225.34 59.43,225.34 58.79,224.7 49.97,224.7 48.37,223.1 35.23,223.1 33.62,221.49 19.56,221.49 16.2,218.13 16.2,217.64 16.25,217.59 16.25,214.54 15.65,213.94 15.65,188.13 13.82,186.3 13.82,185.86 14.38,185.29 v3(14.38,185.29) 14.89,184.78 14.89,184.15 13.64,182.9 13.64,155.81 14.51,154.94 20.86,154.94 21.84,153.96 21.84,144.18 25.43,140.59 v3(33.69,140.59)
  BOTTOM w0.102: PU5104.10 83.7,212.93 83.45,213.18 83.45,213.26 81.44,215.26 PR5106.2 80.82,216.58 v2(80.18,216.58) 80.09,216.58 v3(79.54,216.03) ; D5212.3 34.13,141.03 v3(33.69,140.59)
PWR_VDDQ_PG_N: length 6.1
  TOP w0.152: R80200.2 R80141.2 14.35,183.71 v1(14.38,183.67) 15.02,184.3 15.02,184.33 15.14,184.44 16.32,184.44 16.8,183.97 16.8,183.85 17.26,183.39 Q9637.5
PWR_VDDQ_PHASE: length 10.7
  L3 w0.762: v5(92.49,217.17) 92.49,216.53 89.95,214 v5(89.95,213.36)
  BOTTOM w0.203: PU5104.16 87.19,212.38 87.66,212.85
  BOTTOM w0.635: v5(89.95,213.36) 89.42,213.89 v2(88.53,213.89) 88.53,213.72 87.66,212.85
  BOTTOM w0.762: v5(89.95,213.36) 90.05,213.36 90.94,214.25 PC5114.2
  vias: v2(97.26,218.36) v2(103.21,216.74) v5(94.52,216.41) v5(95.41,217.04) v5(96.3,216.41) v5(97.32,217.04) v5(98.2,216.41) v5(98.97,217.04) v5(99.86,216.41) v5(100.62,217.04) v5(101.63,216.41)
PWR_VDDQ_SENSE: length 8
  BOTTOM w0.203: PU5104.5 83.95,210.03 83.35,209.42
  BOTTOM w0.254: 83.35,209.42 83.35,209.07 v2(82.77,208.5) 82.07,207.79 81.51,207.79 PR5122.2 80.17,207.47 PR5102.1 PC5112.1
PWR_VDDQ_SNB: length 2.7
  BOTTOM w0.508: v2(98,223.65) PC5110.1 96.93,222.71 PR5114.2
PWR_VDDQ_TON: length 5.4
  BOTTOM w0.203: PU5104.9 82.82,211.98 82.71,212.09
  BOTTOM w0.254: 82.71,212.09 82.3,212.5 v2(82.3,213.59) 82.28,213.61 82.28,213.76 80.9,215.14 PR5101.2
PWR_VDDQ_UGATE: length 12.9
  L3 w0.762: v5(89.82,211.96) 89.37,211.96 88.55,212.78 88.55,214.63 v5(91.09,217.17)
  BOTTOM w0.203: 87.92,211.98 PU5104.17
  BOTTOM w0.508: v5(89.82,211.96) 89.67,212.12 88.05,212.12 87.92,211.98
  BOTTOM w0.762: PU5103.4 v5(91.09,217.17) 91.09,216.84 91.07,216.81 v2(91.07,216.15)
PWR_VDDQ_VDD: length 12.8
  BOTTOM w0.203: PU5104.11 84.08,213.13 83.85,213.36 83.85,213.74
  BOTTOM w0.508: PC5111.1 PR5111.1 86.9,218.06 86.06,218.9 v2(85.71,218.9) 84.99,218.9 84.66,218.57 83.09,218.57 83.04,218.52 82.52,218 PR5105.1 PC5115.1 82.52,215.07 83.85,213.74
PWR_VDDQ_VDDP: length 4.1
  BOTTOM w0.203: 84.85,214.36 PU5104.12
  BOTTOM w0.508: 84.85,214.36 84.85,214.37 v2(84.56,214.66) 84.56,214.97 84.49,215.04 PC5103.1 84.51,215.94 PR5118.1
PWR_VDDQ_VLDOIN: length 3.1
  TOP w0.508: PR5116.2 v1(87.77,206.25)
  BOTTOM w0.203: v5(88.04,210.57) 87.43,211.18 PU5104.19
PWR_VDDQ_VTTREF: length 5.4
  BOTTOM w0.203: 84.23,208.91 84.85,209.53 PU5104.4
  BOTTOM w0.508: 84.28,206.71 PC5102.1 ; 84.28,206.71 82.96,206.71 PR5125.2 ; 84.28,206.71 84.23,206.76 v2(84.23,208.23) 84.23,208.91
PWR_VGA_CORE_BOOT1: length 5.2
  TOP w0.203: U9.19 127.05,98.93 126.84,98.73 126.84,98.4 126.53,98.08
  TOP w0.508: PR43.1 126.45,95.2 126.45,95.28 126.35,95.38 v1(126.35,96.39) 126.35,97.9 126.53,98.08
PWR_VGA_CORE_COMP: length 16.7
  TOP w0.203: U9.7 129.48,104.56
  TOP w0.254: 129.48,104.56 129.48,104.58 129.99,105.09 130.55,105.09 131.16,105.7 PC7.2 PR13.2 130.84,107.06 130.4,106.62 PC8.1 130.21,107.51 PC6.1 130.6,108.03 131.11,108.03 PR1.2 131.16,108.9 v1(131.02,109.04) 130.87,109.19 125.99,109.19 125.37,108.57 125.37,107.92 PC4.2
PWR_VGA_CORE_FB: length 6.3
  TOP w0.203: U9.8 129.08,103.87 128.56,104.39
  TOP w0.508: 128.56,104.39 v1(128.18,104.78) PR21.1 ; PR20.1 PR21.1 ; PR21.1 PR8.2 PC8.2
PWR_VGA_CORE_FB2: length 6.6
  TOP w0.203: 128.43,103.76 128.68,103.51 U9.9
  TOP w0.508: 128.43,103.76 128.05,103.76 126.97,104.84 126.97,104.89 PC5.2 125.97,105.69 v1(124.8,105.69) 124.8,106.46 PC4.1
PWR_VGA_CORE_IMON: length 14.3
  TOP w0.203: U9.18 126.91,99.33
  TOP w0.254: 126.91,99.33 126.91,99.32 126.11,98.52 126.07,98.52 125.71,98.17 125.71,94.82 PC59.2 124.43,94.74 PR5488.2 123.67,94.11 122.46,94.11 121.85,93.5 v1(121.65,93.5) 120.8,93.5 120.18,94.13 120.18,95.63 PR5487.1
PWR_VGA_CORE_ISEN1: length 7.3
  TOP w0.203: 127.08,102.69 127.53,102.25 U9.11
  TOP w0.254: 127.08,102.69 125.23,104.55 123.39,104.55 PR12.2 122.36,105.16 v1(121.8,104.6)
PWR_VGA_CORE_ISEN2: length 6.6
  TOP w0.203: U9.10 127.79,102.88
  TOP w0.254: 127.79,102.88 v1(126.1,104.58) 125.62,105.05 123.77,105.05 PR12.1 PR11.2
PWR_VGA_CORE_ISUM+: length 11.1
  TOP w0.203: 126.9,100.53 U9.15
  TOP w0.254: PR45.1 118.59,99.89 PR5491.1 PC15.1 120.68,98.87 ; 120.68,98.87 121,99.19 PC16.1 121.95,99.31 123.99,99.31 124.24,99.57 PR34.1 124.88,100.53 125.28,100.53 v1(125.38,100.63) 126.8,100.63 126.9,100.53 ; 120.68,98.87 PR42.1
PWR_VGA_CORE_ISUM-: length 7.6
  TOP w0.203: 126.31,101.05 126.88,101.05 127.01,100.93 U9.14
  TOP w0.254: PC14.1 122.97,102.04 122.97,102.34 v1(122.41,102.9) ; PC14.1 123.29,101.79 123.78,102.29 124.7,102.29 124.87,102.11 125.26,102.11 126.31,101.05 ; PC14.1 123.22,101.66 PR16.2
PWR_VGA_CORE_LGATE1A: length 21
  TOP w0.203: v5(128.81,95.76) 128.81,96.27 129.08,96.54 U9.23
  TOP w0.762: v5(131.35,91.8) 131.35,91.79 PU3.4
  L3 w0.762: 131.35,88.65 130.69,88.65 128.81,90.52 v5(128.81,95.76) ; 131.35,88.65 131.35,88.64 v5(131.35,85.95) ; 131.35,88.65 v5(131.35,91.8)
  BOTTOM w0.508: v5(128.81,95.76) v2(129.9,95.76)
  BOTTOM w0.762: PU5409.4 v5(131.35,85.95) 131.35,85.78 v2(130.54,84.96)
PWR_VGA_CORE_LGATE1B: length 3
  TOP w0.203: TP203.1 129.62,95.05 129.62,96.25 129.48,96.39 U9.24
PWR_VGA_CORE_NTC: length 49.1
  TOP w0.203: v3(130.34,104.14) 130.28,104.09 U9.5
  TOP w0.254: PR60.2 v3(125.95,75.63)
  L3 w0.254: v3(125.95,75.63) 126.33,75.25 133.74,75.25 136,77.52 136,82.25 136.81,83.06 136.81,93.85 136.1,94.56 136.1,103.5 135.36,104.24 130.44,104.24 v3(130.34,104.14)
  BOTTOM w0.254: v3(130.34,104.14) 130.54,104.34 131.25,104.34 v2(131.33,104.27) 131.33,103.4 131.11,103.19 PC9.1
PWR_VGA_CORE_PHASE1: length 18.4
  TOP w0.203: U9.21 128.1,97.78 127.41,97.09 v5(127.41,96.27)
  TOP w0.508: v5(127.41,96.27) 127.8,95.89 127.8,95.47 128.18,95.09 PC19.1
  L3 w0.762: v5(127.41,96.27) 127.03,95.89 127.03,84.2 v5(126.02,83.19)
  BOTTOM w0.508: v5(127.41,96.27) v2(126.53,96.27)
  vias: v2(121.8,85.67) v5(121.06,91.06) v5(121.06,90.04) v5(121.06,88.9) v5(121.19,83.57) v5(121.19,82.55) v5(121.19,81.53) v5(122.08,91.06) v5(122.08,90.04) v5(122.08,88.9) v5(122.21,83.57) v5(122.21,82.55) v5(122.21,81.53) v5(123.1,91.06) v5(123.1,90.04) v5(123.1,88.9) v5(123.22,83.57) v5(123.22,82.55)
PWR_VGA_CORE_RTN: length 19.2
  TOP w0.203: 126.62,101.47 126.71,101.38 127.02,101.38 127.07,101.33 U9.13
  TOP w0.254: PC59.1 125.06,93.22 PR5488.1 123.92,93.47 v3(122.97,93.47) ; 126.62,101.47 126.02,102.08 v3(126.02,102.11) 125.45,102.68 PC13.2 124.94,103 PR29.2
  L3 w0.254: v3(122.97,93.47) 123.35,93.85 123.35,98.55 126.02,101.22 v3(126.02,102.11)
  BOTTOM w0.254: v3(126.02,102.11) v2(126.02,101.24) 127.25,101.24 PC12180.2
PWR_VGA_CORE_SNB1: length 3
  TOP w0.508: PR5492.2 128.71,84.58 PC12175.1 129.27,84.61 v1(129.8,85.14)
PWR_VGA_CORE_UGATE1: length 25.5
  TOP w0.203: v5(127.29,97.79) 127.53,98.03 U9.20
  TOP w0.762: PU1.4 v5(124.38,78.36)
  L3 w0.762: v5(124.38,78.36) v5(124.38,82.17) 124.38,83.83 125.64,85.09 125.64,96.84 126.58,97.79 v5(127.29,97.79)
  BOTTOM w0.508: v2(123.49,78.36) v5(124.38,78.36)
  BOTTOM w0.762: PU2.4 v5(124.38,82.17)
PWR_VGA_CORE_VCCP: length 5.2
  TOP w0.203: U9.25 129.88,96.85 130.21,96.52
  TOP w0.508: PR44.1 130.78,93.92 130.84,93.98 PC17.1 PC18.1 130.84,95.89 v1(130.32,96.41) 130.21,96.52
PWR_VGA_CORE_VDD: length 8.1
  TOP w0.203: U9.16 126.8,100.13 126.72,100.21 125.83,100.21 125.38,99.77 125.34,99.77
  TOP w0.508: PR5487.2 121.32,97.66 121.72,98.07 121.79,98.07 v1(121.79,98.07) 121.8,98.08 121.8,98.14 122.08,98.42 122.91,98.42 PR5481.2 124.18,98.49 PC58.1 124.24,98.67 125.34,99.77
PWR_VGA_CORE_VIN: length 9
  TOP w0.203: U9.17 126.42,99.73
  TOP w0.508: PR101.2 PC60.1 123.1,95 123.73,95.63 124.37,95.63 v1(124.59,95.86) 125.08,96.34 125.08,98.43 125.81,99.16 125.85,99.16 126.42,99.73
PWR_VGA_CORE_VSEN: length 15.5
  TOP w0.203: 126.65,102.11 127.03,101.73 U9.12
  TOP w0.254: PR28.2 124.77,104.01 125.22,103.57 PC13.1 125.51,103.31 125.7,103.31 v3(126.14,102.87) 126.65,102.36 126.65,102.11 ; v3(128.18,108.41) 128.11,108.34 PC11.2 128.18,107.51 PR21.2
  L3 w0.254: v3(128.18,108.41) 126.14,106.38 v3(126.14,102.87)
  BOTTOM w0.254: v3(126.14,102.87) 126.14,103.38 126.4,103.63 v2(126.58,103.63) 126.86,103.63 127.35,103.14 PC12176.1
PWR_VGA_CORE_VSUM-: length 19.7
  TOP w0.254: PR5491.2 118.78,100.77 PR5489.1 117.83,101.73 117.13,101.73 116.75,101.35 116.75,98.3 117.7,97.35 117.7,92.77 117.32,92.39 PR51.2 ; PR5491.2 119.67,101.85 PC20.2 119.39,102.39 v1(118.63,102.39) ; PR5491.2 PC15.2 121.76,100.77 PC16.2 122.65,99.89 PR16.1
PWR_VGA_CORE_VW: length 5.7
  TOP w0.203: U9.6 129.88,103.83 129.83,103.89 129.83,104.39 130.09,104.65
  TOP w0.254: 130.09,104.65 130.11,104.67 131.04,104.67 v1(131.18,104.82) 132.05,105.69 PC7.1 PR13.1
PWRBTN_N: length 145.1
  TOP w0.102: U4101.47 87.98,55.06 87.79,54.86 87.79,52.74 86.09,51.04 86.09,49.71 86.9,48.9 88.35,48.9 88.57,48.67 v3(88.66,48.67) ; v3(118.78,46.61) 119.16,46.99 R332.1
  L4 w0.127: v3(118.78,46.61) 118.31,46.14 117.72,46.14 116.75,47.12 101.25,47.12 97.72,50.65 90.81,50.65 88.84,48.67 v3(88.66,48.67) 88.57,48.67 88.55,48.69 87.47,48.69 83.35,44.58 71.94,44.58 70.74,43.37 65.05,43.37 58.6,36.92 50.62,36.92 47.91,39.62 41.66,39.62 38.11,43.17 31.55,43.17 23.03,34.65 23.03,22.86 25.79,20.1 26.44,20.1 26.79,19.75 27.46,19.75 28.84,21.13 v3(28.84,23.24)
  BOTTOM w0.102: v3(88.66,48.67) 88.66,48.58 88.81,48.44 v2(88.81,47.83) ; R1756.2 29.76,23.32 C1760.1 v3(28.84,23.24)
PWRCN_DET_N: length 164.3
  TOP w0.089: CPU1.H3 76.12,146.05 76.12,145.56 76.08,145.48 76.08,145.19 76.12,145.11 76.12,144.91 76.08,144.81 76.08,144.11 75.34,143.37
  TOP w0.102: PWRCN1.5 29.6,22.75 29.33,23.02 29.33,25.82 28.23,26.92 v3(28.23,28.19) ; v3(42.45,131.2) 42.77,131.2 45,133.43 55.57,133.43 v1(57.18,135.04) 57.18,135.15 59.77,137.74 72.03,137.74 R1610.1 73.25,138.81 C12377.1 73.38,139.34 74.23,140.19 74.23,142.26 75.34,143.37 75.34,143.37
  L3 w0.127: v3(28.23,28.19) 28.23,29.5 27.5,30.23 27.5,38.6 31.15,42.25 31.15,42.61 31.34,42.8 31.34,127.98 35.4,132.04 36.62,132.04 37.68,130.98 42.23,130.98 v3(42.45,131.2)
PWRGD_3V: length 71.3
  TOP w0.102: Q9629.G 145.61,111.35 146.49,110.46 149.38,110.46 151.13,108.72 151.49,108.35 151.49,102.15 150.91,101.57 150.91,97.03 v3(149.26,95.38) ; R338.1 134.17,68.14 R339.1 C201.1 137.45,69.53 R336.2 R80192.2 136.18,70.17 135.97,70.37 135.97,72.12 136.58,72.72 139.05,72.72 v3(139.23,72.9)
  L4 w0.127: v3(149.26,95.38) 143.16,95.38 v3(140.88,97.66)
  BOTTOM w0.102: v3(140.88,97.66) 140.42,97.21 140.42,75.95 140.6,75.77 v2(140.6,75.34) 140.6,74.26 139.56,73.23 139.56,73.23 v3(139.23,72.9)
PWRGD_3V_B: length 10.5
  TOP w0.152: R117.2 146.59,111.85 v1(146.59,113.41) Q9629.D 145.13,117.03 144.31,116.2 143.13,116.2 Q2.B
PWRGD_3V_B_1: length 6.7
  TOP w0.102: 144.56,79.38 144.05,79.38 143.91,79.23 Q9620.6 ; 144.56,79.38 144.72,79.54 145.59,79.54 145.85,79.81 v1(147.35,79.81) 147.48,79.68 R337.2 ; 144.56,79.38 Q9620.5
PWRGD_3V_C: length 18.8
  TOP w0.152: Q2.C 144.49,118.49 v1(144.62,118.49) 144.64,118.5 144.64,118.61 146.77,120.75 151.09,120.75 151.67,120.17 151.67,119.13 151.48,118.94 C12335.1 R118.2 151.42,117.67 Q4.G 153.37,116.76 155.12,116.76 Q9628.G
PWRGD_3V_LL: length 17.4
  TOP w0.102: Q9620.3 145.21,75.85 144.94,75.58 143.78,75.58 143.29,75.1 143.29,74.69 142.89,74.3 142.22,74.3 141.33,73.41 138.84,73.41 138.64,73.2 136.42,73.2 134.92,71.71 134.92,71.65 134.91,71.64 134.91,70.93 133.76,69.79 v1(133.76,69.19) 133.76,68.62 R338.2
PWRGD_PS_L: length 5.9
  TOP w0.102: Q6.2 150.53,76.56 149.97,76 149.17,76 v1(148.96,75.79) 148.96,75.04 C189.1 R293.1 R288.2
PWRGD_PS_L1: length 6.1
  TOP w0.102: R79934.2 148.5,80.01 148.75,80.26 v1(149.16,80.26) 149.39,80.04 149.39,79.12 149.59,78.92 Q6.6 149.88,79.64 149.99,79.76 150.4,79.76 150.53,79.63 Q6.5
PWRGD_PS_L2: length 2.8
  TOP w0.102: R80149.2 151.16,75.12 v1(151.16,75.62) 151.16,77.02 Q6.3
PWRGOOD_GPU: length 2.9
  TOP w0.102: v4(79.51,94.26) 80,94.76 GPU1.N10
  BOTTOM w0.102: R1158.2 80.23,93.97 v2(80.02,93.75) 80.02,93.75 v4(79.51,94.26)
PWROK3_1: length 10.3
  TOP w0.102: U109.29 131.81,65.68 131.86,65.72 131.86,66.32 v1(132.32,66.78) 132.98,67.44 136.17,67.44 138.46,69.73 R298.2
PWROK3_1_R: length 4.1
  TOP w0.102: R335.2 138.53,71.12 R298.1 R336.1 137.45,71.37 v3(136.91,71.91)
  BOTTOM w0.102: v2(136.91,71.04) v3(136.91,71.91)
PWROK3_2: length 4.1
  TOP w0.102: U109.75 134.61,48.01 133.85,47.24 133.64,47.24 v1(133.41,47.02) 133.41,46.75 132.88,46.22 R295.1
PWROK3_2_R: length 42.2
  TOP w0.102: R265.1 144.94,74.99 R340.1 145.07,75.06 145.83,74.3 v3(146.59,74.3) ; v3(132.62,46.61) 132.42,46.41 132.42,45.24 132.76,44.89 R295.2
  L3 w0.127: v3(146.59,74.3) 145.7,73.41 145.7,71.01 143.54,68.85 143.54,61.2 143.01,60.67 139.92,60.67 136.27,57.02 135.32,57.02 132.02,53.72 132.02,47.21 v3(132.62,46.61)
  BOTTOM w0.102: v2(132.62,45.8) v3(132.62,46.61)
PX_EN: length 2.2
  TOP w0.305: v4(88.06,98.76) 88.06,98.79 87.4,99.45 GPU1.AB16
  BOTTOM w0.508: v4(88.06,98.76) 88.06,98.03 TP159.1
QSAN_0: length 37.5
  TOP w0.127: v4(75.8,108.81) 76.04,108.81 76.2,108.65 GPU1.H27
  L3 w0.152: v4(57.62,113.28) 57.46,113.28 57.19,113.55 57.19,113.75 57.35,113.91 59.74,113.91 59.85,113.8 59.86,113.8 59.95,113.71 60.88,113.71 61.29,114.12 61.29,114.15 61.4,114.26 61.4,116.82 61.52,116.95 62,116.95 62.12,116.82 62.12,114.94 62.43,114.63 63.04,114.63 63.54,115.14 64.03,115.14 64.36,115.47 64.36,115.6 64.51,115.75 64.82,115.75 64.97,115.6 64.97,115.47 65.3,115.14 65.86,115.14 66.19,115.47 66.19,115.6 66.34,115.75 66.64,115.75 66.8,115.6 66.8,115.47 67.13,115.14 67.9,115.14 68.33,115.58 68.33,116.45 68.84,116.96 71.3,116.96 72.42,115.84 72.42,115.6 72.14,115.32 72.14,114.79 72.68,114.25 73.92,114.25 74.57,113.6 74.57,110.65 74.96,110.27 75.72,110.27 75.95,110.49 76.13,110.49 76.4,110.23 76.4,110.05 76.1,109.76 76.1,109.11 v4(75.8,108.81)
  BOTTOM w0.127: v4(57.62,113.28) 57.35,113.28 57.21,113.14 MEM3.G3 ; v4(75.8,108.81) 75.8,109.32 v2(76.04,109.56)
QSAN_1: length 35.1
  TOP w0.102: GPU1.A27 71.04,108.4 70.75,108.68 70.75,108.79
  TOP w0.127: 70.75,108.79 70.75,108.96 70.13,109.58 69.93,109.58 v4(69.58,109.94)
  BOTTOM w0.127: MEM3.B7 54.01,116.55 54.12,116.44 54.33,116.44 54.54,116.65 54.54,117.13 55.09,117.67 55.76,117.67 55.91,117.82 55.91,118.09 55.78,118.21 55.49,118.21 55.17,118.53 55.17,119.18 55.44,119.46 56.59,119.46 56.85,119.19 56.85,118.82 57.05,118.62 57.33,118.62 57.53,118.82 57.53,119.18 57.78,119.43 60.42,119.43 63.71,116.15 63.71,114.39 ; v2(63.99,114.39) 63.71,114.39 ; 63.71,114.39 63.71,113.26 64.22,112.75 64.22,109.28 64.45,109.05 64.91,109.05 65.03,109.17 65.03,109.58 65.31,109.86 65.77,109.86 66.05,109.58 66.05,109.17 66.18,109.05 66.43,109.05 66.56,109.17 66.56,109.61 66.83,109.88 67.3,109.88 67.57,109.61 67.57,109.17 67.7,109.05 68.33,109.05 68.99,109.71 69.35,109.71 v4(69.58,109.94)
QSAN_2: length 36
  TOP w0.102: GPU1.C23 73,105.05 72.9,104.96 72.44,104.96 72.35,104.88 72.34,104.87 72.06,104.87 71.92,105.01 71.03,105.01 70.83,105.21 68.81,105.21 68.79,105.23
  TOP w0.127: v1(64.72,109.15) 65.11,109.15 ; 65.11,109.15 65.11,112.32 65.38,112.6 65.89,112.6 66.02,112.72 66.02,112.98 65.89,113.1 65.38,113.1 65.11,113.38 65.11,113.84 65.38,114.12 65.94,114.12 66.07,114.25 66.07,115 64.97,116.1 64.79,116.1 64.53,115.83 64.14,115.83 63.81,116.16 63.81,116.55 64.07,116.81 64.07,116.99 63.75,117.32 63.57,117.32 63.29,117.04 62.9,117.04 62.57,117.37 62.57,117.76 62.85,118.04 62.85,118.22 62.67,118.4 62.49,118.4 62.21,118.12 61.82,118.12 61.49,118.45 61.49,118.84 61.77,119.12 61.77,119.3 61.45,119.62 58.08,119.62 56.61,118.15 56.5,118.15 56.25,117.91 56.25,117.56 56.92,116.9 57.2,116.9 MEM1.B7 ; 65.11,109.15 65.11,108.28 68.16,105.23 68.79,105.23
QSAN_3: length 35
  TOP w0.102: v4(69.12,102.9) 69.78,102.24 71.09,102.24 71.97,102.24 72.06,102.33 72.32,102.33 arc(72.39,102.28) 72.47,102.27 72.72,102.27 72.99,102 GPU1.C19
  TOP w0.127: MEM1.G3 54.21,113.08 54.21,113.34 54.48,113.6 54.67,113.6 55.17,114.1 v4(55.4,114.1)
  L4 w0.152: v4(55.4,114.1) 55.28,114.23 55.28,114.61 55.5,114.84 55.64,114.84 55.74,114.94 55.75,114.94 56,115.19 56.29,115.19 56.33,115.23 56.98,115.23 57.58,115.83 59.4,115.83 59.84,115.4 61.02,115.4 61.44,114.98 61.65,114.98 61.93,115.26 62.4,115.26 62.8,114.86 62.8,114.4 62.03,113.63 62.03,113.39 62.23,113.2 62.46,113.2 63.23,113.96 63.69,113.96 64.09,113.57 64.09,113.1 63.45,112.46 63.45,112.23 63.65,112.03 63.88,112.03 64.45,112.6 64.93,112.6 65.31,112.22 65.31,111.73 65.1,111.53 65.1,110.9 67.14,108.87 67.14,108.08 68.94,106.27 68.94,103.08 v4(69.12,102.9)
QSAN_4: length 35.3
  TOP w0.102: v4(70.09,97.84) 70.09,97.84 70.09,98.14 70.17,98.21 70.83,98.21 71.09,98.47 72.32,98.47 72.52,98.57 72.75,98.68 GPU1.C15
  L4 w0.152: v4(70.09,97.84) 70.04,97.79 66.75,97.79 65.76,96.79 65.76,90.14 65.41,89.8 65.2,89.8 64.92,90.08 64.43,90.08 64.05,89.71 64.05,89.22 64.34,88.94 64.34,88.72 64.12,88.51 63.9,88.51 63.67,88.74 63.18,88.74 62.8,88.37 62.8,87.88 63.04,87.64 63.04,87.43 62.17,86.56 61.97,86.56 61.56,86.14 59.52,86.14 59.35,86.32 59.35,86.8 58.71,87.44 57.99,87.44 57.66,87.1 57.66,86.91 57.56,86.81 57.21,86.81 57.11,86.92 57.11,88.8 56.65,89.25 55.87,89.25 55.35,89.78 54.9,89.78 54.57,90.11 v4(54.49,90.11)
  BOTTOM w0.127: v4(70.09,97.84) 70.09,97.31 v2(69.86,97.08) ; MEM4.G3 54.01,90.22 54.12,90.11 v4(54.49,90.11)
QSAN_5: length 36.7
  TOP w0.102: GPU1.E9 73.08,94.33 72.89,94.33 72.87,94.32 72.82,94.3 72.67,94.27 72.52,94.27 72.31,94.33 71.76,94.33 70.87,94.33 70.61,94.07 70.25,94.07 69.45,93.27 69.4,93.27
  TOP w0.127: v1(65.31,92.1) 65.31,92.46 ; 65.31,92.46 66.87,92.46 67.69,93.27 69.4,93.27 ; 65.31,92.46 64.55,92.46 64.42,92.33 64.42,88.83 64.16,88.56 63.68,88.56 63.53,88.42 63.53,88.02 63.62,87.93 64.18,87.93 64.42,87.7 64.42,87.02 64.21,86.81 63.48,86.81 63.37,86.7 63.37,86.28 63.47,86.18 64.06,86.18 64.34,85.9 64.34,84.01 64.07,83.74 63.26,83.74 63.01,83.99 63.01,84.7 62.84,84.87 62.54,84.87 62.37,84.7 62.37,83.78 62.09,83.5 61.76,83.5 61.53,83.74 61.14,83.74 60.9,83.5 55.29,83.5 55.07,83.72 55.07,84.2 54.65,84.62 54.65,85.78 54.17,86.27 MEM2.B7
QSAN_6: length 30
  TOP w0.102: 70.08,89.79 v4(69.68,90.2) ; 70.08,89.79 v1(70.08,89.41) ; 70.08,89.79 70.53,89.79 70.76,90.02 70.92,90.02 72.05,91.16 72.27,91.16 72.5,91.07 72.73,91.07 GPU1.C5
  TOP w0.127: MEM2.G3 56.79,89.99 56.7,89.99 v4(56.7,89.99)
  L3 w0.152: v4(56.7,89.99) 56.88,89.81 56.88,89.26 57.26,88.87 59.42,88.87 59.72,89.17 59.72,89.89 59.85,90.01 60.56,90.01 60.69,89.89 60.69,87.88 60.99,87.57 61.6,87.57 61.9,87.88 61.9,88.82 62.03,88.95 62.39,88.95 62.51,88.82 62.51,88.06 62.82,87.75 63.35,87.75 63.66,88.06 63.66,88.82 63.78,88.95 64.04,88.95 64.16,88.82 64.16,88.06 64.47,87.75 64.95,87.75 65.26,88.06 65.26,88.82 65.38,88.95 65.64,88.95 65.76,88.82 65.76,88.06 66.07,87.75 66.56,87.75 66.87,88.06 66.87,89.48 67.87,90.48 69.4,90.48 v4(69.68,90.2)
QSAN_7: length 32.4
  TOP w0.102: v4(75.9,88.09) 75.66,88.09 75.52,88.23 75.52,88.34 75.62,88.44 75.62,88.65 75.79,88.81 75.79,88.81 75.85,88.87 75.93,88.96 75.93,89.39 75.84,89.59 75.84,89.68 75.87,89.72 75.89,89.75 75.94,89.87 75.94,90.29 76.05,90.4 GPU1.H4
  BOTTOM w0.127: v4(75.9,88.09) 75.72,88.27 75.39,88.27 74.89,87.77 74.28,87.77 73.32,86.81 71.44,86.81 ; 71.44,86.81 66.34,86.81 65.92,86.39 65.92,85.09 65.79,84.97 65.27,84.97 65.15,85.09 65.15,85.94 64.87,86.21 64.3,86.21 64.03,85.94 64.03,84.99 63.9,84.87 63.52,84.87 63.39,84.99 63.39,85.98 63.12,86.25 62.55,86.25 62.28,85.98 62.28,84.97 61.74,84.43 60.46,84.43 60.01,84.89 57.17,84.89 56.33,85.73 56.33,86.54 56.66,86.87 57.07,86.87 57.21,86.73 MEM4.B7 ; 71.44,86.81 v2(71.44,87.08)
QSAP_0: length 37.8
  TOP w0.127: GPU1.H28 76.2,109.19 v4(76.6,108.79)
  L3 w0.152: v4(76.6,108.79) 76.41,108.98 76.41,109.63 76.7,109.92 76.7,110.36 76.26,110.8 75.82,110.8 75.6,110.57 75.09,110.57 74.88,110.78 74.88,113.73 74.05,114.56 72.8,114.56 72.45,114.91 72.45,115.19 72.73,115.47 72.73,115.97 71.43,117.27 68.71,117.27 68.03,116.58 68.03,115.7 67.77,115.45 67.25,115.45 67.1,115.6 67.1,115.73 66.77,116.06 66.21,116.06 65.88,115.73 65.88,115.6 65.73,115.45 65.43,115.45 65.27,115.6 65.27,115.73 64.94,116.06 64.38,116.06 64.05,115.73 64.05,115.6 63.9,115.45 63.42,115.45 62.91,114.94 62.55,114.94 62.43,115.07 62.43,116.95 62.12,117.25 61.4,117.25 61.09,116.95 61.09,114.39 60.98,114.28 60.98,114.25 60.75,114.02 60.07,114.02 59.98,114.1 59.98,114.1 59.86,114.22 57.23,114.22 56.89,113.89 v4(56.67,113.89)
  BOTTOM w0.127: v2(77.31,109.58) 77.3,109.58 76.6,108.88 v4(76.6,108.79) ; v4(56.67,113.89) 57.06,113.83 MEM3.F3
QSAP_1: length 35.5
  TOP w0.102: 70.5,108.65 70.95,108.2 71.93,108.2 72.01,108.11 72.07,108.09 72.12,108.07 72.21,108.07 72.27,108.07 72.34,108.1 72.43,108.16 72.67,108.4 GPU1.C27
  TOP w0.127: v4(69.55,109.33) 70.03,109.33 70.5,108.86 70.5,108.65
  BOTTOM w0.127: v4(69.55,109.33) 69.43,109.45 69.09,109.45 68.43,108.79 67.59,108.79 67.32,109.07 67.32,109.5 67.19,109.63 66.94,109.63 66.81,109.5 66.81,109.07 66.54,108.79 66.07,108.79 65.8,109.07 65.8,109.48 65.67,109.61 65.41,109.61 65.29,109.48 65.29,109.07 65.01,108.79 64.34,108.79 63.96,109.17 63.96,110.51 ; 63.96,110.51 63.96,112.64 63.45,113.15 63.45,116.04 60.32,119.18 57.89,119.18 57.79,119.08 57.79,118.71 57.44,118.36 56.94,118.36 56.59,118.71 56.59,119.09 56.48,119.2 55.55,119.2 55.43,119.08 55.43,118.64 55.6,118.47 55.89,118.47 56.16,118.19 56.16,117.72 55.87,117.42 55.2,117.42 54.8,117.02 54.8,116.55 54.44,116.19 54.12,116.19 MEM3.C7 ; 63.96,110.51 v2(63.61,110.51)
QSAP_2: length 36.1
  TOP w0.102: 68.79,105.49 68.8,105.49 68.84,105.45 68.88,105.45 68.91,105.41 70.92,105.41 71.12,105.21 72.01,105.21 72.02,105.2 GPU1.A23
  TOP w0.127: MEM1.C7 57.21,116.24 56,117.45 56,118.01 56.39,118.41 56.5,118.41 57.97,119.87 61.55,119.87 62.02,119.4 62.02,119.01 61.75,118.74 61.75,118.56 61.93,118.37 62.11,118.37 62.38,118.65 62.77,118.65 63.1,118.32 63.1,117.93 62.83,117.66 62.83,117.48 63.01,117.3 63.19,117.3 63.46,117.57 63.85,117.57 64.33,117.1 64.33,116.71 64.06,116.45 64.06,116.27 64.24,116.09 64.42,116.09 64.69,116.35 65.08,116.35 66.32,115.1 66.32,114.14 66.05,113.87 65.49,113.87 65.36,113.74 65.36,113.48 65.49,113.36 66,113.36 66.27,113.08 66.27,112.62 66,112.34 65.49,112.34 65.36,112.21 65.36,108.39 66.34,107.41 ; v1(66.59,107.66) 66.34,107.41 ; 66.34,107.41 68.26,105.49 68.79,105.49
QSAP_3: length 35.3
  TOP w0.102: 69.34,103.27 69.54,103.07 69.54,102.77 69.86,102.44 71.01,102.44 71.01,102.44 71.89,102.44 71.98,102.53 72.4,102.53 72.43,102.5 72.51,102.47 73,102.47 73.47,102 GPU1.E19
  TOP w0.127: 69.34,103.27 69.29,103.32 68.92,103.32 68.67,103.07 68.67,103.07 v4(68.51,102.9) ; MEM1.F3 54.19,113.68 54.37,113.86 54.57,113.86 55.23,114.52 55.93,114.52 v4(55.98,114.57)
  L4 w0.152: v4(68.51,102.9) 68.64,103.03 68.64,106.15 66.83,107.95 66.83,108.74 64.8,110.78 64.8,111.65 65,111.86 65,112.09 64.81,112.29 64.57,112.29 64.01,111.72 63.52,111.72 63.14,112.1 63.14,112.59 63.78,113.23 63.78,113.44 63.57,113.66 63.35,113.66 62.59,112.89 62.1,112.89 61.72,113.27 61.72,113.75 62.49,114.52 62.49,114.74 62.27,114.95 62.06,114.95 61.78,114.67 61.31,114.67 60.89,115.09 59.71,115.09 59.28,115.52 57.7,115.52 57.1,114.93 56.47,114.93 56.43,114.88 56.29,114.88 v4(55.98,114.57)
QSAP_4: length 36.2
  TOP w0.102: GPU1.E15 73.16,98.49 72.87,98.41 72.58,98.37 72.36,98.27 71.17,98.27 v4(70.71,97.81)
  L4 w0.152: v4(70.71,97.81) 70.31,97.4 69.68,97.4 69.6,97.48 66.88,97.48 66.06,96.66 66.06,90.01 65.54,89.49 65.07,89.49 64.79,89.78 64.56,89.78 64.36,89.58 64.36,89.35 64.64,89.06 64.64,88.59 64.25,88.2 63.78,88.2 63.54,88.44 63.31,88.44 63.11,88.24 63.11,88.01 63.35,87.77 63.35,87.3 62.3,86.25 62.09,86.25 61.68,85.84 59.39,85.84 59.04,86.19 59.04,86.67 58.59,87.13 58.12,87.13 57.96,86.97 57.96,86.78 57.69,86.51 57.09,86.51 56.8,86.79 56.8,88.67 56.53,88.95 55.75,88.95 55.22,89.47 v4(54.6,89.47)
  BOTTOM w0.127: v4(70.71,97.81) 71.46,98.55 v2(71.71,98.55) ; MEM4.F3 54.45,89.62 v4(54.6,89.47)
QSAP_5: length 36.9
  TOP w0.102: 69.4,93.53 69.42,93.53 70.16,94.27 70.53,94.27 70.79,94.53 71.68,94.53 72.34,94.53 72.55,94.47 72.64,94.47 72.77,94.5 73.07,94.8 GPU1.D10
  TOP w0.127: v1(63.76,89.44) 64.17,89.44 ; 64.17,89.44 64.17,88.93 64.06,88.82 63.57,88.82 63.28,88.53 63.28,87.91 63.52,87.68 64.08,87.68 64.16,87.59 64.16,87.12 64.1,87.07 63.38,87.07 63.11,86.8 63.11,86.17 63.36,85.92 63.96,85.92 64.09,85.79 64.09,84.12 63.96,83.99 63.37,83.99 63.26,84.1 63.26,84.81 62.95,85.12 62.43,85.12 62.12,84.81 62.12,83.89 61.99,83.76 61.87,83.76 61.63,83.99 61.03,83.99 60.8,83.76 55.39,83.76 55.33,83.82 55.33,84.3 54.9,84.73 54.9,85.89 54.41,86.38 54.41,86.82 MEM2.C7 ; 64.17,89.44 64.17,92.44 64.44,92.71 66.77,92.71 67.58,93.53 69.4,93.53
QSAP_6: length 29.7
  TOP w0.102: v4(70.29,90.2) 70.31,90.23 70.83,90.23 71.97,91.36 72.31,91.36 72.54,91.27 73.25,91.27 73.4,91.42 GPU1.D6
  TOP w0.127: MEM2.F3 57.21,89.62 v4(57.61,90.02)
  L3 w0.152: v4(57.61,90.02) 57.38,90.02 57.13,89.77 57.13,89.36 57.32,89.17 59.29,89.17 59.42,89.3 59.42,90.01 59.72,90.32 60.69,90.32 60.99,90.01 60.99,88.01 61.12,87.88 61.47,87.88 61.6,88.01 61.6,88.94 61.9,89.25 62.51,89.25 62.82,88.94 62.82,88.18 62.94,88.06 63.22,88.06 63.35,88.18 63.35,88.94 63.66,89.25 64.16,89.25 64.47,88.94 64.47,88.18 64.6,88.06 64.82,88.06 64.95,88.18 64.95,88.94 65.26,89.25 65.76,89.25 66.07,88.94 66.07,88.18 66.2,88.06 66.43,88.06 66.56,88.18 66.56,89.6 67.74,90.78 69.7,90.78 70.11,90.38 70.11,90.38 v4(70.29,90.2)
QSAP_7: length 32.9
  TOP w0.102: GPU1.G5 75.73,90.47 75.73,89.91 75.71,89.85 75.68,89.81 75.63,89.75 75.63,89.54 75.73,89.34 75.73,89.04 75.65,88.96 75.42,88.73 75.42,88.52 75.32,88.42 75.32,88.15 75.45,88.02 v4(75.45,87.62)
  BOTTOM w0.127: 67.14,86.56 73.43,86.56 74.38,87.51 74.99,87.51 75.11,87.62 v4(75.45,87.62) ; 67.14,86.56 66.44,86.56 66.17,86.28 66.17,84.99 65.9,84.71 65.17,84.71 64.89,84.99 64.89,85.83 64.77,85.96 64.41,85.96 64.28,85.83 64.28,84.89 64.01,84.61 63.42,84.61 63.14,84.89 63.14,85.87 63.01,86 62.66,86 62.53,85.87 62.53,84.87 61.84,84.18 60.36,84.18 59.9,84.63 57.06,84.63 56.07,85.62 56.07,86.64 56.55,87.13 57.12,87.13 MEM4.C7 ; 67.14,86.56 v2(67.14,86.21)
RASA0#: length 41.2
  TOP w0.127: GPU1.G22 75.71,104.2 76.06,103.86 76.42,103.86 v4(76.59,103.69) ; MEM1.J3 54.46,111.28 54.77,110.97 55.04,110.97 55.36,110.65 55.47,110.65 55.76,110.37 56.35,110.37 56.48,110.5 56.48,110.65 v4(56.17,110.96)
  L3 w0.165: v4(76.59,103.69) 76.92,104.02 76.92,105.34 75.33,106.93 74.1,106.93 74.1,106.93 73.74,106.93 73.48,107.19 73.48,107.93 73.35,108.06 72.95,108.06 72.83,107.93 72.83,107.65 72.7,107.52 72.14,107.52 72.01,107.65 72.01,107.93 71.89,108.06 70.67,108.06 70.18,107.57 69.67,107.57 69.67,107.57 69.42,107.57 68.55,108.45 63.38,108.45 63.21,108.28 63.21,107.74 63.05,107.57 62.57,107.57 62.4,107.74 62.4,108.28 62.24,108.45 61.97,108.45 61.73,108.69 61.46,108.69 61.33,108.56 61.33,107.68 61.21,107.55 60.15,107.55 60.03,107.68 60.03,108.16 60.15,108.28 60.56,108.28 60.69,108.41 60.69,109.24 60.56,109.37 59.03,109.37 58.91,109.24 58.91,108.72 58.78,108.59 58.27,108.59 58.15,108.72 58.15,109.24 58.02,109.37 57.43,109.37 56.17,110.63 v4(56.17,110.96)
  BOTTOM w0.127: v4(56.17,110.96) 55.96,111.17 55.96,111.75 56.17,111.96 56.38,111.96 56.51,111.83 56.51,111.46 56.68,111.28 56.68,110.94 56.81,110.81 57.06,110.81 57.19,110.94 57.19,111.25 MEM3.J3
RASA1#: length 42.4
  TOP w0.127: v4(56.07,92.06) 56.07,92.33 56.22,92.47 57.47,92.47 57.57,92.37 57.57,92.12 57.47,92.02 MEM2.J3 ; GPU1.G17 75.88,101.07 v4(75.88,101.1)
  L3 w0.165: v4(75.88,101.1) 75.9,101.1 76.05,100.95 76.97,100.95 77.13,100.78 77.81,100.78 78.01,100.58 78.37,100.58 78.74,100.94 79.35,100.94 79.48,100.82 79.48,100.26 79.35,100.13 79.01,100.13 78.85,99.97 78.85,99.64 79.01,99.47 79.35,99.47 79.48,99.34 79.48,96.8 79.35,96.67 78.97,96.67 78.84,96.54 78.84,95.69 78.97,95.56 78.97,94.82 78.54,94.39 78.54,94.23 77.71,93.4 77.41,93.4 76.48,92.47 73.68,92.47 73.36,92.8 71.3,92.8 70.52,93.58 60.73,93.58 59.92,92.76 56.98,92.76 56.27,92.06 v4(56.07,92.06)
  BOTTOM w0.127: MEM4.J3 54.13,92.02 54.63,91.52 55.05,91.52 55.17,91.65 55.17,91.81 55.42,92.05 55.43,92.05 55.44,92.07 56.06,92.07 v4(56.07,92.06)
RDY#: length 9.7
  TOP w0.102: U4101.23 93.72,62.63 94.17,63.07 97.16,63.07 98.99,61.24 99.58,61.24 99.89,60.93 100.85,60.93 TP4126.1
REMOTE1+: length 246.4
  TOP w0.127: U109.87 139.41,49.76 139.63,49.97 140.3,49.97 v3(140.75,50.42) ; v3(39.91,173.23) 39.97,173.29 RT3.1
  L3 w0.127: v3(39.91,173.23) 39.66,172.97 39.66,172.29 40.64,171.31 47.04,171.31 48.17,170.18 48.17,164.85 50.71,162.31 50.71,152.12 51.6,151.24 51.6,143.26 50.58,142.24 50.58,135.13 36.44,120.99 36.44,90.34 38.26,88.52 38.26,86.11 46.82,77.55 46.82,71.28 51.85,66.24 55.41,66.24 59.26,62.4 61.14,62.4 65.01,58.53 65.01,51.24 71.04,45.2 85.8,45.2 87.04,43.96 87.18,43.82 87.18,42.63 87.59,42.22 87.97,42.22 v3(88.3,42.55)
  L4 w0.127: v3(88.3,42.55) 88.81,42.55 95.03,48.77 98.06,48.77 100.73,46.1 115.96,46.1 116.95,45.11 134.04,45.11 136.39,47.46 139.95,47.46 141.13,48.64 141.13,50.04 v3(140.75,50.42)
  BOTTOM w0.127: v3(88.3,42.55) 88.48,42.72 v2(88.48,43.38) ; R404.1 140.75,49.31 140.81,49.38 C211.2 140.81,50.36 v3(140.75,50.42)
REMOTE1-: length 245
  TOP w0.127: v3(39.15,173.23) 39.09,173.29 RT3.2
  L3 w0.127: v3(88.3,41.78) 88.12,41.96 87.48,41.96 86.92,42.52 86.92,43.71 86.86,43.78 85.69,44.95 70.94,44.95 64.75,51.13 64.75,58.42 61.03,62.14 59.15,62.14 55.3,65.99 51.75,65.99 46.57,71.17 46.57,77.44 38.01,86 38.01,88.41 36.19,90.23 36.19,121.1 50.33,135.23 50.33,142.35 51.34,143.36 51.34,151.13 50.45,152.02 50.45,162.2 47.91,164.74 47.91,170.07 46.93,171.06 40.54,171.06 39.4,172.19 39.4,172.97 v3(39.15,173.23)
  L4 w0.127: v3(141.51,50.42) 141.38,50.29 141.38,48.54 140.05,47.21 136.5,47.21 134.15,44.86 116.84,44.86 115.85,45.85 100.63,45.85 97.96,48.51 95.13,48.51 88.66,42.04 88.55,42.04 v3(88.3,41.78)
  BOTTOM w0.127: v3(88.3,41.78) 88.3,41.05 v2(88.45,40.89) ; v3(141.51,50.42) 141.51,49.62 C211.1 141.7,48.56 R400.2
REXT: length 3.3
  TOP w0.102: U118.18 131.75,39.01 v3(131.86,39.12)
  BOTTOM w0.102: R2082.1 131.02,38.8 v2(131.02,39.34) 131.15,39.47 131.5,39.47 v3(131.86,39.12)
RING2: length 32
  TOP w0.203: U6.31 167.85,76.65 168.31,76.2
  TOP w0.762: v3(178.02,84.52) Q24.2 178.94,84.11 176.55,81.71 176.55,78.88 177.83,77.6 181.91,77.6 UHS1.3
  L3 w0.762: v3(178.02,84.52) 176.44,82.93 176.44,77.81 174.44,75.82 v3(171.86,75.82)
  BOTTOM w0.508: v2(172.65,76.12) 172.35,75.82 v3(171.86,75.82)
ROM_CS#: length 3.9
  BOTTOM w0.102: 86.65,88.9 v2(85.07,88.9) 84.63,88.9 R1168.2 R1167.2
ROM_SI_D3: length 12
  BOTTOM w0.102: U49.5 92.87,92.71 v2(93.63,91.95) 93.89,91.69 93.89,88.99 92.14,87.25 90.01,87.25 R1171.1
ROM_SLK_D4: length 9.9
  BOTTOM w0.102: U49.6 93.12,91.44 93.38,91.19 v2(93.38,89.51) 93.38,88.77 92.06,87.45 89.89,87.45 89.18,86.74 R1170.1
ROM_SO_C4: length 2.8
  BOTTOM w0.102: R1169.2 84.07,90.58 v2(85.17,90.58) 85.58,90.17 86.65,90.17
RREF: length 3.6
  BOTTOM w0.203: 176.46,143.46 U14.9
  BOTTOM w0.305: R79840.1 178.47,142.47 177.9,141.9 v2(177.66,141.9) 177.66,142.27 176.46,143.46
RSMRST*_R: length 4.8
  TOP w0.102: R340.2 145.89,75.98 v1(146.62,76.71) 146.62,76.76 146.16,77.22 144.81,77.22 144.56,76.96 Q9620.2
RSMRST_N: length 554.3
  TOP w0.089: 95.23,154.73 93.43,154.73 93.12,154.43 CPU1.AY17
  TOP w0.102: R80205.1 121.19,53.85 v3(120.94,53.59) ; v3(111.92,135.26) 111.92,136.02 111.92,148.08 104.14,155.86 RN9504.4 102.72,155.74 102.72,155.39 102.65,155.32 100.87,155.32 100.28,154.73 95.23,154.73 ; R80047.1 105,158.5 112.85,150.64 v3(112.85,134.49) ; R9904.1 v3(16.67,225.93) ; v3(9.94,172.97) 9.94,165.29 13.88,161.35 13.88,159.51 14.26,159.13 15.91,159.13 16.18,158.86 Q9650.3
  L3 w0.127: v3(162.47,206.88) 161.96,206.38 156.25,206.38 154.48,208.15 101.13,208.15 100.69,207.72 94.22,207.72 93.79,208.15 84.71,208.15 82.33,210.54 82.33,224.84 80.09,227.08 58.71,227.08 58.07,226.44 50.97,226.44 50.58,226.83 20.46,226.83 19.09,225.46 17.14,225.46 v3(16.67,225.93)
  L4 w0.127: v3(112.85,134.49) 112.85,134.45 129.8,117.5 135.05,117.5 135.95,117.5 139.35,120.9 146.46,120.9 v3(148.62,118.75) ; v3(134.49,51.98) 134.15,52.32 126.65,52.32 126.44,52.11 124.58,52.11 124.11,52.58 121.95,52.58 v3(120.94,53.59)
  BOTTOM w0.102: v3(111.92,135.26) 112.04,135.26 112.81,134.49 v3(112.85,134.49) ; v3(134.49,51.98) 135.86,50.61 R291.1 137,51.44 R1993.1 137.38,52.07 145.44,52.07 147.05,53.67 147.05,56.69 146.13,57.61 146.13,59.88 147.05,60.79 147.05,88.39 146.08,89.36 146.08,116.2 v3(148.62,118.75) 149.08,119.2 156.55,119.2 160.66,123.31 160.66,144.01 161.41,144.76 161.41,148.5 164.1,151.19 164.1,160.69 v2(163.71,161.09) 163.23,161.57 163.23,201.04 162.47,201.8 v3(162.47,206.88) ; v3(16.67,225.93) 16.21,226.39 15.1,226.39 3.75,215.04 3.75,207.53 7.73,203.54 7.73,188.92 9.94,186.71 v3(9.94,172.97)
RSMRST_N_2: length 7.1
  TOP w0.102: R80205.2 122.68,53.82 125.84,53.82 126.98,54.97 v1(127.03,54.97) 127.36,55.3 127.6,55.3 127.68,55.37 U109.52
RSMRST_N_B: length 2.6
  TOP w0.152: v1(15.55,162.64) 15.46,162.55 R80236.1 15.53,161.48 Q9650.5
RSMRST_PWRGD#: length 239.4
  TOP w0.102: PR8512.1 12.96,186.14 12.56,186.14 11.89,185.48 11.89,179.3 13.39,177.8 v3(14.51,177.8) ; v3(20.48,142.37) 20.25,142.6 v1(20.25,145.24) 20.56,145.54 PR8511.2 PR8510.2 ; U109.127 143.45,62.57 142.98,62.1 v3(142.78,62.1)
  L4 w0.127: v3(142.78,62.1) 141.87,63.02 133.15,63.02 132.41,62.27 127.86,62.27 126.58,63.55 101.75,63.55 101.43,63.87 100.73,63.87 97.32,67.28 91.31,67.28 88.81,69.79 73.45,69.79 72.72,70.52 69.72,70.52 68.74,71.5 66.42,71.5 63.88,74.05 63.88,74.49 61.15,77.22 57.41,77.22 55.66,78.97 54.83,78.97 51.76,82.04 47.96,82.04 43.49,86.51 43.49,119.89 40.45,122.94 35.16,122.94 33.5,124.6 33.5,133.47 29.36,137.6 24.18,137.6 20.48,141.3 v3(20.48,142.37) 17.94,144.91 17.94,156.8 13.83,160.91 13.83,177.11 v3(14.51,177.8)
RSVD_TP_AK12: length 4.8
  TOP w0.102: CPU1.AK12 86.7,151.01 v4(86.54,151.01)
  BOTTOM w0.102: v4(86.54,151.01) 86.54,151.04 85.94,151.64 85.94,152.41 85.36,152.98 85.36,154.17 TP606.1
RSVD_TP_AK13: length 6
  TOP w0.102: v4(86.54,151.64) 86.86,151.97 CPU1.AK13
  BOTTOM w0.102: v4(86.54,151.64) 86.14,152.04 86.14,152.48 85.55,153.06 85.55,153.52 86.47,154.43 86.47,154.99 87.18,155.7 TP605.1
RSVD_TP_BA68: length 13.1
  TOP w0.102: CPU1.BA68 93.99,184.34 93.99,185 94.63,185.64 94.63,186.36 94.39,186.6 94.27,186.6 93.87,187 93.87,187.34 94.67,188.14 100.67,188.14 101.02,188.49 101.53,188.49 TP602.1
RSVD_TP_BA70: length 10.8
  TOP w0.102: TP601.1 100.31,188.54 94.75,188.54 93.53,187.33 93.53,184.84 CPU1.BA70
RSVD_TP_BB68: length 12.1
  TOP w0.102: CPU1.BB68 94.31,183.77 94.62,184.08 94.62,184.44 94.82,184.64 94.82,184.71 95.33,185.21 95.33,186.98 95.99,187.64 100.81,187.64 101.13,187.32 102.27,187.32 TP603.1
RSVD_TP_BB69: length 10
  TOP w0.102: CPU1.BB69 94.31,184.4 94.63,184.72 94.63,184.84 95.14,185.35 95.14,187.11 95.89,187.86 101.41,187.86 TP604.1
RSVD_TP_F65: length 2.5
  TOP w0.102: CPU1.F65 75,181.41 75.32,181.73 v4(75.32,181.81)
  BOTTOM w0.102: TP612.1 74.09,181.47 74.98,181.47 v4(75.32,181.81)
RSVD_TP_G65: length 3.8
  TOP w0.102: v4(75.35,180.85) 75.65,181.15 CPU1.G65
  BOTTOM w0.102: TP613.1 72.67,181.24 74.96,181.24 v4(75.35,180.85)
RT: length 2.8
  BOTTOM w0.102: R79628.1 35.23,22.14 v2(35.23,22.73) U120.10
RTD2482_VREF: length 10.1
  TOP w0.254: C12190.1 v1(71.41,75.82) 69.38,75.82 67.22,77.98 66.33,77.98 65.12,76.78 SCA1.44
RTD_PIN2: length 5.3
  TOP w0.102: R9519.2 R9531.2 71.25,55.4 v1(71.07,55.4) 70.92,55.4 69.93,56.4 SCA1.2
RTD_PIN105: length 9.2
  TOP w0.102: v3(55.28,57.02) 54.82,56.57 54.82,56.17 54.55,55.9 SCA1.102
  BOTTOM w0.102: v3(55.28,57.02) 54.82,56.57 54.82,55.84 R79832.1 53.44,54.61 53.44,55.87 v2(53.45,55.88) 53.44,55.89 R79236.1 R79237.2
RTD_PIN119: length 3.6
  TOP w0.102: v3(63.53,56.01) 63.12,55.6 SCA1.119
  BOTTOM w0.102: R9525.1 63.03,55.5 v3(63.53,56.01) v2(64.35,56.01)
RTD_PIN121: length 3.1
  TOP w0.102: R9527.2 64.27,51.98 64.27,53.35 64.12,53.5 SCA1.121
RTD_PIN122: length 3.5
  TOP w0.102: SCA1.122 64.62,53.5 64.48,53.35 64.48,52.7 ; 64.48,52.7 v1(64.83,52.7) ; 64.48,52.7 64.48,52.07 R9530.2
RTD_PIN123: length 3.2
  TOP w0.102: R9536.2 65.54,52.03 65.54,53.32 65.12,53.74 SCA1.123
RTD_PIN124: length 3.5
  TOP w0.102: R9546.2 66.96,51.82 v1(66.1,52.68) 66.1,53.27 65.62,53.74 SCA1.124
RTD_RESETB: length 5.9
  TOP w0.102: SCA1.125 66.12,55.7 v3(65.82,56.01)
  BOTTOM w0.102: v3(65.82,56.01) 66.5,55.32 C12174.1 66.45,54.69 65.87,54.69 65.57,54.99 v2(65.08,54.99) 64.93,54.84 64.93,54.09 R9548.1
RTL_ISOLATE_N: length 15.7
  TOP w0.102: Q36.6 31.04,7.22 v3(30.56,7.7) 30.23,7.37 v1(30.23,6.9) 30.23,6.18 R1817.1 R377.2 ; v3(34.07,15.37) 34.43,15 35.34,15 35.4,15.06 U16.20
  L3 w0.127: v3(34.07,15.37) 34.07,14.85 30.89,11.68 30.89,8.03 v3(30.56,7.7)
RTL_ISOLATE_N_1: length 7.1
  TOP w0.102: Q36.5 31.97,7.87 32.37,8.27 32.37,8.74 33.03,9.4 v3(33.56,9.4)
  BOTTOM w0.102: v3(33.56,9.4) 33.5,9.4 R1816.2 C1798.1 33.51,7.57 v2(33.56,7.62) 34.44,7.62 R406.1
RTL_ISOLATE_N_2: length 5.8
  TOP w0.102: v1(32.93,4.5) 32.86,4.56 R378.2 32.55,5.91 32.55,7.67 32.75,7.87 ; Q36.3 32.74,8.52 32.65,8.43 32.65,7.98 32.75,7.87 ; 32.75,7.87 Q36.2
RTN1: length 5.3
  TOP w0.254: R51.1 32.43,43.23 v1(31.53,43.23) 31.28,43.23 29.19,41.15 28.33,41.15 CONVT1.1
RTN2: length 3.9
  TOP w0.254: R53.1 v1(30.73,41.2) 30.18,41.2 29.13,40.15 CONVT1.2
RTN3: length 6
  TOP w0.254: v3(31.66,35.94) 32.04,36.32 v1(32.04,36.86) 31.94,36.96 29.57,36.96 29.38,37.15 CONVT1.5
  BOTTOM w0.254: R56.1 v3(31.66,35.94)
RTN4: length 4.8
  TOP w0.254: v1(30.64,35.51) v3(30.64,36.37) 29.7,36.37 29.48,36.15 CONVT1.6
  BOTTOM w0.254: R59.1 v3(30.64,36.37)
RUN_EN1: length 7.4
  TOP w0.102: v3(125.76,15.62) 125.89,15.75 R732.1 R733.2
  BOTTOM w0.102: Q65.2 127.41,15.88 ; 127.41,15.88 127.72,15.88 128.06,16.22 Q65.3 129.01,16.56 v2(129.32,16.26) ; 127.41,15.88 127.16,15.62 v3(125.76,15.62)
RUN_EN2: length 6.8
  TOP w0.102: v1(125.66,14.55) 125.66,13.56 v3(125.89,13.34) 126.91,12.32 R722.1 R1778.2
  BOTTOM w0.102: Q65.6 125.93,14.68 R1178.1 125.26,13.97 v3(125.89,13.34)
RUN_EN_1P8V: length 303.4
  L3 w0.127: v3(84.11,202.18) 86.16,204.24 86.19,204.24 86.2,204.25 89.76,204.25 89.88,204.14 109.27,204.14 109.31,204.18 114.29,204.18 115.04,204.93 126.17,204.93 127.54,203.56 154.99,203.56 164.92,193.64 164.92,155.11 163.77,153.96 163.77,127.17 164.71,126.23 164.71,95.04 154.78,85.11 154.78,82.04 153.61,80.88 153.61,72.86 154.24,72.24 154.24,66.6 150.97,63.33 150.97,54.67 152.27,53.38 152.27,51.9 151.42,51.05 151.42,40.33 144.2,33.11 130.33,33.11 126.94,29.72 126.94,18.12 v3(127.41,17.65)
  BOTTOM w0.102: U105.3 84.62,198.74 C862.1 85.82,197.23 R1179.2 85.5,197.68 85.5,201.42 84.74,202.18 v3(84.11,202.18) ; R1178.2 125.26,17.58 125.74,18.06 v2(126.45,18.06) 127.01,18.06 v3(127.41,17.65)
RUNPWR_R6: length 3.6
  BOTTOM w0.102: R718.2 C865.2 127.41,13.21 v2(127.41,13.41) Q65.5
S_LVDS_BL_EN: length 5.3
  BOTTOM w0.102: R139.1 43.64,24.65 v2(43.64,25.6) 43.7,25.65 R135.1 R144.1 R1985.1 44.8,22.73 R143.2
S_TXE0+: length 38.1
  TOP w0.102: 47.61,72.03 47.61,70.48 47.87,70.22 47.87,69.83 47.61,69.57 47.61,67.97 47.88,67.7 48.2,67.7 48.57,68.07 49.65,68.07 49.94,67.78 49.94,67.28 49.67,67.01 49.06,67.01 48.93,66.88 48.93,66.63 49.13,66.43 49.93,66.43 50.25,66.75 50.99,66.75 51.7,66.04 52.39,66.04 52.66,65.78 52.87,65.78 53,65.9 SCA1.82 ; 47.61,72.03 47.61,84.71 45.5,86.82 45.5,89.81 44.69,90.62 44.21,90.62 43.95,90.88 43.95,91.74 43.59,92.1 43.29,92.1 42.89,92.5 LVDS1.18 ; 47.61,72.03 v1(47.96,72.03)
S_TXE0-: length 38.1
  TOP w0.102: LVDS1.19 42.92,91.5 43.26,91.85 43.49,91.85 43.7,91.64 43.7,90.78 44.11,90.37 44.58,90.37 44.94,90.02 ; 44.94,90.02 v1(44.69,89.76) ; 44.94,90.02 45.25,89.71 45.25,86.71 47.35,84.61 47.35,70.38 47.62,70.11 47.62,69.94 47.35,69.67 47.35,67.87 47.77,67.45 48.31,67.45 48.67,67.82 49.54,67.82 49.69,67.67 49.69,67.39 49.56,67.26 49.16,67.26 48.95,67.26 48.67,66.98 48.67,66.53 49.02,66.18 50.04,66.18 50.35,66.5 50.88,66.5 51.59,65.79 52.29,65.79 52.55,65.52 52.89,65.52 53.01,65.4 SCA1.83
S_TXE1+: length 38.4
  TOP w0.102: 49.59,68.81 48.69,68.81 48.5,69.01 48.5,69.41 48.63,69.55 48.91,69.55 49.18,69.82 49.18,70.43 48.93,70.68 48.45,70.68 48.34,70.79 48.34,71.09 48.45,71.19 48.93,71.19 49.18,71.44 49.18,72.14 48.34,72.97 48.34,85.12 46.26,87.2 46.26,90.09 44.69,91.67 44.69,92.05 43.87,92.86 43.87,93.93 44.17,94.22 44.17,94.85 43.89,95.13 43.34,95.13 42.97,95.5 LVDS1.15 ; 49.59,68.81 v1(49.59,69.16) ; 49.59,68.81 49.99,68.81 52.02,66.78 52.59,66.78 52.72,66.9 SCA1.80
S_TXE1-: length 38.4
  TOP w0.102: v1(50.6,67.36) 50.84,67.6 ; 50.84,67.6 51.92,66.52 52.59,66.52 52.72,66.4 SCA1.81 ; 50.84,67.6 49.88,68.56 48.59,68.56 48.24,68.91 48.24,69.52 48.52,69.8 48.8,69.8 48.93,69.93 48.93,70.33 48.83,70.43 48.34,70.43 48.09,70.68 48.09,71.2 48.34,71.45 48.83,71.45 48.93,71.55 48.93,72.03 48.09,72.87 48.09,85.01 46.01,87.1 46.01,89.99 44.43,91.56 44.43,91.94 43.62,92.76 43.62,94.03 43.92,94.33 43.92,94.75 43.79,94.87 43.34,94.87 42.97,94.5 LVDS1.16
S_TXE2+: length 38.2
  TOP w0.102: SCA1.78 52.72,67.9 52.59,67.78 52.07,67.78 50.68,69.16 50.68,69.55 49.94,70.28 49.94,72.52 49.51,72.95 ; v1(49.77,73.2) 49.51,72.95 ; 49.51,72.95 49.18,73.28 49.18,85.32 47,87.51 47,90.4 45.43,91.97 45.43,92.35 44.91,92.87 44.91,98.05 44.53,98.42 44.02,98.42 43.72,98.13 43.34,98.13 42.97,98.5 LVDS1.12
S_TXE2-: length 38.2
  TOP w0.102: 44.65,96.19 44.65,92.77 45.17,92.25 45.17,91.87 46.74,90.29 46.74,87.4 48.93,85.22 48.93,73.17 49.69,72.41 49.69,70.18 50.43,69.44 50.43,69.06 51.96,67.52 52.59,67.52 52.72,67.4 SCA1.79 ; 44.65,96.19 v1(44.31,96.19) ; 44.65,96.19 44.65,97.95 44.43,98.17 44.12,98.17 43.83,97.87 43.34,97.87 42.97,97.5 LVDS1.13
S_TXE3+: length 38.9
  TOP w0.102: 50.71,77.09 50.71,86.08 48.47,88.32 48.47,91.01 46.9,92.59 46.9,92.96 46.38,93.48 46.38,99.35 43.6,102.13 43.34,102.13 42.97,102.5 LVDS1.8 ; 50.71,77.09 50.71,75.82 51.47,75.06 51.47,73.2 52.17,72.5 52.17,70.32 52.71,69.78 52.87,69.78 52.99,69.9 SCA1.74 ; 50.71,77.09 v1(51.09,77.09)
S_TXE3-: length 38.9
  TOP w0.102: 51.61,72.71 51.21,73.1 51.21,74.95 50.45,75.71 50.45,85.98 48.22,88.21 48.22,90.91 46.64,92.48 46.64,92.86 46.12,93.38 46.12,99.24 43.49,101.87 43.34,101.87 42.97,101.5 LVDS1.9 ; 51.61,72.71 51.91,72.4 51.91,70.22 52.61,69.52 52.84,69.52 52.96,69.4 SCA1.75 ; 51.61,72.71 v1(51.37,72.47)
S_TXEC+: length 38.3
  TOP w0.102: v1(50.5,74.7) 50.25,74.45 ; 50.25,74.45 50.71,73.99 50.71,72.11 51.42,71.4 51.42,69.6 52.23,68.78 52.59,68.78 52.72,68.9 SCA1.76 ; 50.25,74.45 49.94,74.76 49.94,85.7 47.73,87.91 47.73,90.71 46.16,92.28 46.16,92.66 45.64,93.18 45.64,98.36 43.88,100.13 43.34,100.13 42.97,100.5 LVDS1.10
S_TXEC-: length 38.3
  TOP w0.102: LVDS1.11 42.97,99.5 43.34,99.87 43.77,99.87 45.39,98.26 45.39,93.07 45.91,92.55 45.91,92.17 47.48,90.6 47.48,87.81 49.69,85.6 49.69,74.65 50.45,73.89 50.45,72.01 51.16,71.29 51.16,70.51 ; v1(50.81,70.51) 51.16,70.51 ; 51.16,70.51 51.16,69.49 52.13,68.52 52.59,68.52 52.71,68.4 SCA1.77
S_TXO0+: length 38.6
  TOP w0.102: LVDS1.29 42.97,81.5 43.31,81.15 43.59,81.15 43.85,80.9 43.85,80.14 43.29,79.58 41.66,79.58 41.54,79.45 41.54,78.59 41.66,78.46 41.89,78.46 42.02,78.59 42.02,78.79 42.29,79.07 42.74,79.07 43.01,78.79 43.01,78.03 43.85,77.19 43.85,66.4 45.52,64.72 45.52,61.52 ; v1(45.88,61.52) 45.52,61.52 ; 45.52,61.52 45.52,60.63 47.1,59.05 47.1,58.39 47.76,57.73 49.84,57.73 50.12,58.01 51.24,58.01 51.95,58.72 51.95,59.44 52.29,59.78 52.59,59.78 52.72,59.9 SCA1.94
S_TXO0-: length 38.6
  TOP w0.102: 43.12,77.56 43.59,77.09 43.59,66.29 45.27,64.62 45.27,60.52 46.85,58.95 46.85,58.29 47.65,57.48 49.94,57.48 50.22,57.76 51.34,57.76 52.2,58.62 52.2,59.33 52.39,59.52 52.59,59.52 52.72,59.4 SCA1.95 ; 43.12,77.56 v1(42.88,77.32) ; 43.12,77.56 42.76,77.92 42.76,78.69 42.63,78.82 42.4,78.82 42.27,78.69 42.27,78.48 42,78.21 41.56,78.21 41.28,78.48 41.28,79.56 41.56,79.83 43.18,79.83 43.59,80.24 43.59,80.79 43.49,80.9 43.33,80.9 42.93,80.5 LVDS1.30
S_TXO1+: length 38.1
  TOP w0.102: 47.71,59.54 46.9,60.35 46.9,61.77 46.26,62.41 46.26,65.03 44.58,66.7 44.58,77.63 43.75,78.46 43.75,79 44.66,79.91 44.66,81.16 44.13,81.69 44.13,82.83 43.83,83.13 43.34,83.13 42.97,83.5 LVDS1.27 ; 47.71,59.54 v1(47.99,59.82) ; 47.71,59.54 48.78,58.47 49.18,58.47 49.31,58.6 49.31,59.08 49.58,59.36 50.15,59.36 50.43,59.08 50.43,58.98 50.53,58.88 51.06,58.88 51.19,59 51.19,59.54 51.06,59.66 50.8,59.66 50.53,59.94 50.53,60.48 50.8,60.76 52.54,60.76 52.68,60.9 SCA1.92
S_TXO1-: length 38
  TOP w0.102: 48.32,58.57 v1(48.06,58.32) ; 48.32,58.57 46.64,60.24 46.64,61.67 46.01,62.3 46.01,64.92 44.33,66.6 44.33,77.52 43.5,78.36 43.5,79.1 44.41,80.01 44.41,81.05 43.87,81.58 43.87,82.73 43.73,82.87 43.34,82.87 42.97,82.5 LVDS1.28 ; 48.32,58.57 48.67,58.22 49.29,58.22 49.56,58.49 49.56,58.98 49.69,59.11 50.04,59.11 50.17,58.97 50.17,58.87 50.42,58.62 51.17,58.62 51.44,58.9 51.44,59.64 51.17,59.92 50.91,59.92 50.78,60.05 50.78,60.38 50.91,60.5 52.54,60.5 52.64,60.4 SCA1.93
S_TXO2+: length 38.4
  TOP w0.102: LVDS1.25 42.97,85.5 43.34,85.13 43.66,85.13 43.98,84.81 43.98,84.03 44.86,83.14 44.86,82.52 ; SCA1.90 52.72,61.9 52.59,61.78 52.4,61.78 52.18,62 50.52,62 49.74,61.22 49.74,60.22 49.61,60.1 49.28,60.1 49.16,60.22 49.16,61.17 48.88,61.44 48.44,61.44 48.17,61.17 48.17,60.81 48.04,60.68 47.76,60.68 47.66,60.79 47.66,62.28 47.41,62.53 47.18,62.53 47,62.71 47,63.27 ; 47,63.27 47,65.33 45.32,67.01 45.32,78.28 45.09,78.52 44.81,78.52 44.69,78.64 44.69,78.89 44.84,79.04 45.14,79.04 45.4,79.3 45.4,81.46 44.86,82 44.86,82.52 ; 47,63.27 v1(47.35,63.27) ; v1(45.22,82.52) 44.86,82.52
S_TXO2-: length 38.1
  TOP w0.102: SCA1.91 52.72,61.4 52.59,61.52 52.3,61.52 52.07,61.75 51.34,61.75 ; 51.34,61.75 v1(51.34,61.39) ; 51.34,61.75 50.63,61.75 49.99,61.11 49.99,60.12 49.72,59.84 49.18,59.84 48.9,60.12 48.9,61.06 48.78,61.19 48.55,61.19 48.42,61.06 48.42,60.7 48.14,60.43 47.66,60.43 47.4,60.68 47.4,62.18 47.3,62.28 47.07,62.28 46.74,62.61 46.74,65.23 45.07,66.91 45.07,78.18 44.98,78.26 44.71,78.26 44.43,78.54 44.43,79 44.73,79.3 45.04,79.3 45.14,79.4 45.14,81.36 44.61,81.89 44.61,83.03 43.72,83.92 43.72,84.71 43.56,84.87 43.34,84.87 42.97,84.5 LVDS1.26
S_TXO3+: length 38.1
  TOP w0.102: LVDS1.20 42.97,90.5 43.34,90.13 43.67,90.13 44,89.79 44,89.31 44.74,88.57 44.74,86.34 45.5,85.58 45.5,84.84 45.71,84.63 46.44,84.63 46.87,84.2 46.87,67.55 47.8,66.62 ; 47.8,66.62 v1(48.04,66.85) ; 47.8,66.62 49.18,65.23 49.18,64.08 49.31,63.96 49.69,63.96 49.82,64.08 49.82,65.42 50.09,65.7 50.97,65.7 51.37,65.3 52.01,65.3 52.28,65.03 52.28,63.91 52.41,63.78 52.59,63.78 52.72,63.9 SCA1.86
S_TXO3-: length 38.5
  TOP w0.102: LVDS1.21 42.97,89.5 43.34,89.87 43.56,89.87 43.75,89.69 43.75,89.2 44.48,88.46 44.48,86.23 45.25,85.47 45.25,84.73 45.6,84.38 46.34,84.38 46.62,84.1 46.62,83.64 ; 46.62,83.64 46.62,67.44 48.93,65.13 48.93,63.98 49.2,63.7 49.8,63.7 50.07,63.98 50.07,64.8 ; 46.62,83.64 v1(46.26,83.64) ; SCA1.87 52.72,63.4 52.59,63.52 52.3,63.52 52.03,63.8 52.03,64.92 51.9,65.05 51.26,65.05 50.87,65.44 50.2,65.44 50.07,65.31 50.07,64.8 ; 50.07,64.8 v1(50.43,64.8)
