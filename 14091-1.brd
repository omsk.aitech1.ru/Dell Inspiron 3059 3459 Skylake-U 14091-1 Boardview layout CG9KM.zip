# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ16: length 79.8
  TOP w0.102: v4(91.19,182.82) 91.16,182.82 90.55,182.21 CPU1.AT66 ; DIMM2.52 152.28,175.25 v4(151.69,175.84)
  L4 w0.127: v4(91.19,182.82) 92.45,182.82 97.18,187.56 101.91,187.56 102.59,188.23 102.59,188.23 103.43,189.08 111.69,189.08 112.96,187.81 113.3,187.81 113.43,187.93 113.43,188.81 113.56,188.94 113.81,188.94 113.94,188.81 113.94,187.93 114.07,187.81 114.32,187.81 114.45,187.93 114.45,188.81 114.57,188.94 114.83,188.94 114.95,188.81 114.95,187.93 115.08,187.81 115.34,187.81 115.46,187.93 115.46,188.81 115.59,188.94 115.84,188.94 115.97,188.81 115.97,187.93 116.1,187.81 129.41,187.81 132.03,185.19 134.92,185.19 135.46,184.64 135.46,184.55 135.81,184.2 138.2,184.2 140.42,181.98 140.42,181.65 140.68,181.39 141.02,181.39 141.02,181.38 141.19,181.38 145.33,177.24 146.75,177.24 147.72,176.28 147.84,176.28 147.85,176.28 150.74,176.28 150.77,176.3 151.23,176.3 v4(151.69,175.84)
  BOTTOM w0.102: v2(151.43,175.06) 151.69,175.31 v4(151.69,175.84)
M_B_DQ17: length 79.6
  TOP w0.102: CPU1.AU66 91.2,181.96 v4(91.52,181.64) ; DIMM2.51 148.71,175.55 149.27,174.99 v4(149.27,174.93)
  L4 w0.127: v4(91.52,181.64) 91.75,181.64 93.05,182.93 93.91,182.93 94.39,183.42 94.39,184.27 97.33,187.21 102.05,187.21 102.93,188.09 102.93,188.09 103.26,188.42 106.84,188.42 107.8,187.46 108.14,187.46 108.27,187.59 108.27,188.46 108.39,188.59 108.65,188.59 108.77,188.46 108.77,187.59 108.9,187.46 109.16,187.46 109.28,187.59 109.28,188.46 109.41,188.59 109.66,188.59 109.79,188.46 109.79,187.59 109.92,187.46 110.17,187.46 110.3,187.59 110.3,188.46 110.43,188.59 110.68,188.59 110.81,188.46 110.81,187.59 110.93,187.46 111.19,187.46 111.31,187.59 111.31,188.46 111.44,188.59 111.7,188.59 111.82,188.46 111.82,187.59 111.95,187.46 129.27,187.46 132.49,184.24 135.23,184.24 135.7,183.77 137.91,183.77 138.33,183.36 138.33,183.07 140.42,180.97 141.11,180.97 145.19,176.9 146.09,176.9 147.19,175.8 148.4,175.8 v4(149.27,174.93)
  BOTTOM w0.102: v4(149.27,174.93) 148.5,174.17 v2(148.34,174.17)
M_B_DQ18: length 82.5
  TOP w0.102: CPU1.AP65 89.25,181.05 v4(89.57,180.72) ; DIMM2.40 152.44,178.85 v4(151.84,178.25)
  L4 w0.127: v4(151.84,178.25) 149.98,180.12 146.41,180.12 138.42,188.11 133.31,188.11 129.56,191.86 98.52,191.86 96.69,190.03 95.98,190.03 95.52,189.57 94.67,189.57 93.12,188.01 93.12,186.06 92.86,185.81 91.91,185.81 90.27,184.16 89.27,184.16 88.29,183.18 88.29,180.76 88.75,180.3 89.15,180.3 v4(89.57,180.72)
  BOTTOM w0.102: v2(151.59,177.46) 151.84,177.72 v4(151.84,178.25)
M_B_DQ19: length 83
  TOP w0.102: v4(149.18,179.14) 149.18,178.68 149.05,178.55 DIMM2.41 ; CPU1.AN65 88.6,181.05 v4(88.92,180.72)
  L4 w0.127: v4(88.92,180.72) 88.5,181.14 88.5,181.81 88.75,182.06 88.77,182.06 89.25,182.53 89.25,182.83 91.97,185.56 92.92,185.56 93.45,186.09 93.45,187.86 94.81,189.22 95.66,189.22 96.07,189.63 97.76,189.63 98.15,190.02 98.15,190.2 97.85,190.49 97.85,190.67 98.03,190.85 98.21,190.85 98.55,190.51 98.73,190.51 98.83,190.61 98.83,190.61 98.91,190.7 98.91,190.87 98.63,191.15 98.63,191.33 98.81,191.51 98.99,191.51 99.23,191.28 99.41,191.28 99.48,191.35 101.04,191.35 101.16,191.22 101.16,190.29 101.29,190.17 101.54,190.17 101.67,190.29 101.67,191.22 101.8,191.35 128.87,191.35 130.99,189.23 131.17,189.23 131.43,189.49 131.61,189.49 131.79,189.31 131.79,189.13 131.53,188.87 131.53,188.69 131.71,188.51 131.89,188.51 132.15,188.77 132.33,188.77 132.51,188.59 132.51,188.41 132.25,188.15 132.25,187.97 132.49,187.73 138.2,187.73 146.16,179.77 148.55,179.77 v4(149.18,179.14)
  BOTTOM w0.102: v4(149.18,179.14) 149.61,179.57 v2(149.61,179.93)
M_B_DQ20: length 81.8
  TOP w0.102: DIMM2.39 146.4,179.15 v4(147.86,179.15) ; CPU1.AN66 88.6,181.96 v4(88.92,181.64)
  L4 w0.127: v4(147.86,179.15) 146.03,179.15 137.83,187.35 132.36,187.35 128.72,190.99 128.12,190.99 128,190.86 128,189.64 127.87,189.52 127.62,189.52 127.49,189.64 127.49,190.86 127.36,190.99 127.11,190.99 126.98,190.86 126.98,189.64 126.85,189.52 126.6,189.52 126.47,189.64 126.47,190.86 126.35,190.99 102.89,190.99 102.86,190.96 102.85,190.96 101.16,189.27 100.82,189.27 100.69,189.39 100.69,190.47 100.57,190.6 100.31,190.6 100.18,190.47 100.18,189.39 100.06,189.27 99.8,189.27 99.68,189.39 99.68,190.47 99.55,190.6 99.3,190.6 99.17,190.47 99.17,189.39 99.04,189.27 96.19,189.27 95.8,188.88 94.96,188.88 93.8,187.72 93.8,186.13 92.96,185.29 92.02,185.29 89.51,182.79 89.51,182.23 v4(88.92,181.64)
  BOTTOM w0.102: v2(147.05,179.15) v4(147.86,179.15)
M_B_DQ21: length 81.3
  TOP w0.102: CPU1.AP66 89.25,181.96 v4(89.57,181.64) ; DIMM2.42 v4(153.14,178.25)
  L4 w0.127: v4(153.14,178.25) 153.14,178.25 152.66,177.76 149.97,177.76 149.12,178.61 145.91,178.61 138.3,186.22 138.3,186.54 137.74,187.1 131.93,187.1 129.85,189.17 126.08,189.17 125.96,189.3 125.96,190.17 125.83,190.3 125.58,190.3 125.45,190.17 125.45,189.3 125.32,189.17 125.07,189.17 124.94,189.3 124.94,190.17 124.81,190.3 124.56,190.3 124.43,190.17 124.43,189.3 124.31,189.17 123.96,189.17 122.49,190.64 103.03,190.64 101.28,188.89 96.3,188.89 95.94,188.54 95.47,188.54 94.69,187.76 94.69,186.06 93.67,185.04 92.07,185.04 89.77,182.75 89.77,181.84 v4(89.57,181.64)
  BOTTOM w0.102: v2(153.93,178.28) 153.9,178.25 v4(153.14,178.25)
M_B_DQ22: length 80.7
  TOP w0.102: v4(90.87,180.72) 90.55,181.05 CPU1.AT65 ; DIMM2.53 146.41,174.94 v4(148,174.94)
  L4 w0.127: v4(148,174.94) 147.57,174.94 146.5,176.01 145.53,176.01 141.41,180.14 140.77,180.14 139.99,180.92 139.99,181.08 138.42,182.65 135.8,182.65 134.55,183.9 132.35,183.9 129.13,187.12 108.08,187.12 107.3,186.34 106.96,186.34 106.83,186.47 106.83,187.95 106.7,188.08 106.45,188.08 106.32,187.95 106.32,186.47 106.19,186.34 105.94,186.34 105.81,186.47 105.81,187.95 105.69,188.08 105.43,188.08 105.3,187.95 105.3,186.47 105.18,186.34 104.92,186.34 104.8,186.47 104.8,187.95 104.67,188.08 104.42,188.08 104.29,187.95 104.29,186.47 104.16,186.34 103.91,186.34 103.78,186.47 103.78,187.95 103.65,188.08 103.4,188.08 103.27,187.95 103.27,186.47 103.15,186.34 98.25,186.34 95.36,183.45 94.83,183.45 93.89,182.5 93.12,182.5 91.78,181.15 91.3,181.15 v4(90.87,180.72)
  BOTTOM w0.102: v2(147.06,174.94) v4(148,174.94)
M_B_DQ23: length 80
  TOP w0.102: CPU1.AU65 91.2,181.06 v4(91.53,180.73) ; DIMM2.50 v4(153.14,175.85)
  L4 w0.127: v4(91.53,180.73) 91.86,180.73 93.25,182.12 94.01,182.12 95.13,183.23 95.45,183.23 98.22,186 107.57,186 108.3,186.73 129.03,186.73 132.21,183.55 134.43,183.55 135.56,182.43 138.03,182.43 140.02,180.43 140.02,180.4 140.63,179.79 140.66,179.79 140.67,179.78 141.18,179.78 145.45,175.51 146.39,175.51 147.97,173.94 149.99,173.94 151.17,175.12 153.75,175.12 153.88,174.99 153.88,173.91 154,173.79 154.38,173.79 154.51,173.91 154.51,174.95 154.63,175.07 155.14,175.07 155.26,175.2 155.26,175.72 155.14,175.85 v4(153.14,175.85)
  BOTTOM w0.102: v2(153.98,175.85) v4(153.14,175.85)
M_B_DQ24: length 75.5
  TOP w0.102: v4(90.22,178.89) 90.22,178.96 90.55,179.29 CPU1.AT61 ; DIMM2.56 v4(153.14,174.05)
  L4 w0.127: v4(90.22,178.89) 90.94,178.89 91.64,179.59 91.91,179.59 93.48,181.16 94.66,181.16 94.79,181.28 95.21,181.28 98.28,184.35 104.73,184.35 105.02,184.64 116.49,184.64 117.16,185.31 128.61,185.31 132.5,181.42 135.09,181.42 135.35,181.16 135.35,180.79 135.7,180.44 138.41,180.44 140.38,178.46 140.63,178.46 146.64,172.46 149.72,172.46 150.41,173.15 150.41,174.04 150.9,174.52 152.67,174.52 v4(153.14,174.05)
  BOTTOM w0.102: v2(153.93,174.05) v4(153.14,174.05)
M_B_DQ25: length 74.4
  TOP w0.102: DIMM2.58 152.28,173.45 v4(151.76,173.97) ; v4(91.56,178.92) 91.56,178.98 CPU1.AU61
  L4 w0.127: v4(91.56,178.92) 91.61,178.87 92.39,178.87 93.05,179.54 93.05,179.7 93.8,180.44 95.14,180.44 95.38,180.69 95.38,181.03 98.36,184.01 104.87,184.01 105.16,184.29 116.63,184.29 117.28,184.94 128.27,184.94 129.73,183.49 129.73,183.3 132.92,180.1 138.35,180.1 146.31,172.14 150.89,172.14 151.92,173.17 151.92,173.81 v4(151.76,173.97)
  BOTTOM w0.102: v4(151.76,173.97) 151.76,173.44 v2(151.51,173.18)
M_B_DQ26: length 77.7
  TOP w0.102: v4(88.92,177.98) 88.92,177.98 89.25,178.31 CPU1.AP60 ; DIMM2.68 152.3,170.45 v4(151.75,169.9)
  L4 w0.089: v4(88.92,177.98) 89.34,177.56 91.08,177.56 91.71,176.92
  L4 w0.127: v4(151.75,169.9) 151.75,169.41 151.42,169.08 150.54,169.08 150.42,169.2 150.42,169.79 150.29,169.92 150.04,169.92 149.91,169.79 149.91,169.2 149.78,169.08 149.44,169.08 148.86,169.65 145.59,169.65 137.47,177.77 131.59,177.77 127.4,181.97 102.22,181.97 102.16,181.91 98.29,181.91 95.78,179.4 95,179.4 94.63,179.03 94.63,178.27 93.28,176.92 91.71,176.92
  BOTTOM w0.102: v4(151.75,169.9) 151.34,169.5 v2(151.34,169.16)
M_B_DQ27: length 78.2
  TOP w0.102: v4(88.27,178.89) 88.35,178.89 88.6,178.64 CPU1.AN60 ; DIMM2.70 v4(153.14,169.85)
  L4 w0.089: 93.76,177.07 93.35,176.66 90.7,176.66 90.02,177.35 88.34,177.35 87.87,177.81 87.87,178.49 v4(88.27,178.89)
  L4 w0.127: v4(153.14,169.85) 152.04,168.75 148.46,168.75 147.9,169.31 145.43,169.31 137.19,177.55 131.3,177.55 127.22,181.62 98.31,181.62 95.87,179.19 95.09,179.19 94.84,178.94 94.84,178.15 93.76,177.07
  BOTTOM w0.102: v2(153.96,169.85) v4(153.14,169.85)
M_B_DQ28: length 77.6
  TOP w0.102: CPU1.AN61 88.6,179.48 v4(88.92,179.81) ; v4(147.86,173.16) 147.85,173.15 DIMM2.59
  L4 w0.127: v4(147.86,173.16) 147.14,173.16 146.87,173.43 146.87,173.61 147.18,173.91 147.18,174.09 147,174.27 146.82,174.27 146.51,173.97 146.33,173.97 146.15,174.15 146.15,174.33 146.46,174.63 146.46,174.81 146.28,174.99 146.1,174.99 145.8,174.69 145.62,174.69 141.15,179.15 140.75,179.15 137.83,182.07 135.59,182.07 134.47,183.19 131.78,183.19 128.95,186.02 113.15,186.02 112.46,185.33 112.08,185.33 111.95,185.46 111.95,186 111.83,186.13 111.57,186.13 111.44,186 111.44,185.46 111.32,185.33 111.06,185.33 110.94,185.46 110.94,186 110.81,186.13 110.56,186.13 110.43,186 110.43,185.46 110.3,185.33 110.05,185.33 109.92,185.46 109.92,186 109.79,186.13 109.54,186.13 109.41,186 109.41,185.46 109.29,185.33 109.03,185.33 108.9,185.46 108.9,186 108.78,186.13 108.52,186.13 108.4,186 108.4,185.46 108.27,185.33 101.91,185.33 101.62,185.62 98.16,185.62 97.57,185.03 97.57,184.43 94.88,181.74 93.25,181.74 91.74,180.23 89.45,180.23 89.04,179.81 v4(88.92,179.81)
  BOTTOM w0.102: v2(147.02,173.16) v4(147.86,173.16)
M_B_DQ29: length 77
  TOP w0.102: v4(88.92,178.89) 89.25,179.22 CPU1.AP61 ; DIMM2.57 148.61,173.75 149.13,173.23 v4(149.13,173.16)
  L4 w0.127: v4(149.13,173.16) 149.13,173.16 148.68,172.71 147.11,172.71 141.01,178.81 140.61,178.81 138.29,181.13 138.29,181.15 137.67,181.77 132.55,181.77 129.54,184.79 129.54,184.87 128.73,185.67 117.03,185.67 116.35,184.99 116.01,184.99 115.88,185.12 115.88,185.55 115.75,185.68 115.5,185.68 115.37,185.55 115.37,185.12 115.24,184.99 114.99,184.99 114.86,185.12 114.86,185.55 114.74,185.68 114.48,185.68 114.35,185.55 114.35,185.12 114.23,184.99 113.97,184.99 113.85,185.12 113.85,185.55 113.72,185.68 113.47,185.68 113.34,185.55 113.34,185.12 113.21,184.99 101.77,184.99 101.48,185.28 98.12,185.28 97.79,184.94 97.79,184.34 94.94,181.5 94.7,181.5 94.61,181.41 93.33,181.41 92.49,180.57 92.46,180.57 91.7,179.81 91.46,179.81 91.05,179.39 89.42,179.39 v4(88.92,178.89)
  BOTTOM w0.102: v4(149.13,173.16) 149.13,173.51 v2(149.56,173.94)
M_B_DQ30: length 77.6
  TOP w0.102: CPU1.AT60 90.55,178.34 90.87,178.02 v4(90.87,177.98) ; v4(149.34,170.72) 149.22,170.72 148.8,171.15 147.66,171.15 147.43,170.92 147.39,170.92 147.23,170.75 DIMM2.67
  L4 w0.089: 92.19,177.81 91.88,177.51 91.39,177.51 90.91,177.98 v4(90.87,177.98)
  L4 w0.127: 92.19,177.81 93.75,177.81 94.41,178.48 94.41,179.12 94.91,179.62 95.44,179.62 97.95,182.12 102.01,182.12 102.2,182.31 125.44,182.31 125.57,182.44 125.57,182.89 125.69,183.02 125.95,183.02 126.07,182.89 126.07,182.44 126.2,182.31 126.45,182.31 126.58,182.44 126.58,182.89 126.71,183.02 126.96,183.02 127.09,182.89 127.09,182.44 127.22,182.31 127.56,182.31 127.98,181.89 128.16,181.89 128.39,182.13 128.57,182.13 128.75,181.95 128.75,181.77 128.52,181.53 128.52,181.35 128.7,181.17 128.88,181.17 129.11,181.41 129.29,181.41 129.47,181.23 129.47,181.05 129.23,180.81 129.23,180.63 129.41,180.45 129.59,180.45 129.83,180.69 130.01,180.69 130.19,180.51 130.19,180.33 129.95,180.09 129.95,179.91 130.13,179.73 130.31,179.73 130.55,179.97 130.73,179.97 130.91,179.79 130.91,179.61 130.67,179.38 130.67,179.2 130.85,179.02 131.03,179.02 131.27,179.25 131.45,179.25 131.63,179.07 131.63,178.89 131.39,178.66 131.39,178.48 131.86,178 137.75,178 145.51,170.25 148.86,170.25 v4(149.34,170.72)
  BOTTOM w0.102: v4(149.34,170.72) 149.34,170.19 v2(149.08,169.94)
M_B_DQ31: length 76.7
  TOP w0.102: v4(91.6,177.91) 91.6,178.03 CPU1.AU60 ; v4(147.86,170.69) 147.32,170.15 DIMM2.69
  L4 w0.127: v4(147.86,170.69) 145.77,170.69 138.23,178.23 132.96,178.23 132.94,178.24 132.56,178.24 132.3,178.5 132.3,178.88 129.19,182 129.19,182.14 128.98,182.35 128.97,182.35 128.65,182.67 127.79,182.67 127.1,183.36 125.55,183.36 124.86,182.67 124.41,182.67 124.28,182.8 124.28,183.35 124.15,183.47 123.9,183.47 123.77,183.35 123.77,182.8 123.65,182.67 123.39,182.67 123.26,182.8 123.26,183.35 123.14,183.47 122.88,183.47 122.76,183.35 122.76,182.8 122.63,182.67 122.38,182.67 122.25,182.8 122.25,183.35 122.12,183.47 121.87,183.47 121.74,183.35 121.74,182.8 121.61,182.67 121.36,182.67 121.23,182.8 121.23,183.35 121.11,183.47 120.85,183.47 120.72,183.35 120.72,182.8 120.6,182.67 120.34,182.67 120.22,182.8 120.22,183.35 120.09,183.47 119.84,183.47 119.71,183.35 119.71,182.8 119.58,182.67 119.33,182.67 119.2,182.8 119.2,183.35 119.07,183.47 118.82,183.47 118.69,183.35 118.69,182.8 118.57,182.67 118.31,182.67 118.18,182.8 118.18,183.35 118.06,183.47 117.8,183.47 117.68,183.35 117.68,182.8 117.55,182.67 102.1,182.67 101.76,182.34 97.86,182.34 95.35,179.83 94.82,179.83 94.19,179.21 94.19,178.77 93.5,178.07 91.87,178.07 91.71,177.91 v4(91.6,177.91)
  BOTTOM w0.102: v4(147.86,170.69) 147.86,170.16 v2(147.61,169.91)
M_B_DQ32: length 76.3
  TOP w0.102: DIMM2.132 153.17,148.85 v4(153.14,148.89) ; v4(90.92,166.98) 90.92,166.98 91.2,167.26 CPU1.AU40
  L4 w0.089: v4(90.92,166.98) 93.41,166.98 95.03,165.35 100.49,165.35 104,161.84 104.2,161.84
  L4 w0.127: 104.2,161.84 108.73,161.84 124.47,146.09 138.53,146.09 139.07,146.63 146.08,146.63 147.74,148.29 150.31,148.29 150.8,147.8 153.22,147.8 153.35,147.93 153.35,148.76 153.22,148.89 v4(153.14,148.89)
  BOTTOM w0.102: v2(153.42,149.63) 153.42,149.17 v4(153.14,148.89)
M_B_DQ33: length 77
  TOP w0.102: DIMM2.130 152.34,149.45 v4(151.75,148.86) ; v4(90.27,167.92) 90.27,167.91 90.55,167.64 CPU1.AT40
  L4 w0.089: v4(90.27,167.92) 90.8,167.4 91.1,167.4 91.32,167.17 93.59,167.17 95.18,165.58 100.64,165.58 104.02,162.2 104.27,162.2
  L4 w0.127: v4(151.75,148.86) 151.8,148.86 151.93,148.73 151.93,148.23 151.8,148.11 150.96,148.11 150.55,148.52 150.41,148.52 147.5,148.52 145.98,147 138.85,147 138.29,146.44 124.74,146.44 110.32,160.85 108.97,162.2 104.27,162.2
  BOTTOM w0.102: v4(151.75,148.86) 152.13,149.24 v2(152.13,149.66)
M_B_DQ34: length 78.4
  TOP w0.102: DIMM2.140 152.79,146.45 152.44,146.81 v4(152.44,147) ; v4(90.22,166.09) 90.55,165.77 CPU1.AT37
  L4 w0.089: 103.98,160.69 100.61,164.07 94.96,164.07 92.72,166.3 91.4,166.3 91.19,166.09 v4(90.22,166.09)
  L4 w0.127: 103.98,160.69 104.2,160.48 108.05,160.48 123.83,144.7 131.55,144.7 131.85,144.41 134.96,144.41 135.38,143.99 141.84,143.99 143.14,145.29 146.92,145.29 147.69,146.05 149.32,146.05 150.79,147.52 152.51,147.52 152.64,147.39 152.64,147.13 152.51,147 v4(152.44,147)
  BOTTOM w0.102: v4(152.44,147) 152.45,147 152.89,147.45 v2(153.75,147.45)
M_B_DQ35: length 77.2
  TOP w0.102: v4(149.31,145.57) 149.31,145.68 148.88,146.1 147.23,146.1 147.18,146.15 DIMM2.141 ; v4(90.86,165.18) 90.92,165.18 91.2,165.46 CPU1.AU37
  L4 w0.089: 103.67,160.15 100.24,163.58 94.89,163.58 92.52,165.95 91.63,165.95 v4(90.86,165.18)
  L4 w0.127: v4(149.31,145.57) 148.77,145.03 147.6,145.03 147.09,144.53 143.68,144.53 142.33,143.18 124.38,143.18 108.98,158.58 107.45,158.58 107.33,158.71 107.33,159.45 107.2,159.58 106.94,159.58 106.82,159.45 106.82,158.71 106.69,158.58 106.44,158.58 106.31,158.71 106.31,159.45 106.18,159.58 105.93,159.58 105.8,159.45 105.8,158.71 105.67,158.58 105.33,158.58 104.82,159.09 104.72,159.09 103.67,160.15
  BOTTOM w0.102: v2(149.31,144.73) v4(149.31,145.57)
M_B_DQ36: length 77.7
  TOP w0.102: v4(149.13,149.35) 149.73,149.95 149.91,149.95 150.41,149.44 150.41,149.26 149.89,148.74 147.56,148.74 147.16,149.15 DIMM2.131 ; CPU1.AR40 89.9,167.61 v4(89.59,167.92)
  L4 w0.089: 104.12,162.69 103.92,162.69 100.81,165.8 95.22,165.8 92.87,168.15 91.28,168.15 91.13,168.29 90.46,168.29 90.43,168.32 89.79,168.32 89.59,168.12 v4(89.59,167.92)
  L4 w0.127: 104.12,162.69 108.97,162.69 124.88,146.78 138.07,146.78 138.63,147.34 145.92,147.34 147.43,148.84 148.93,148.84 149.13,149.05 v4(149.13,149.35)
  BOTTOM w0.102: v2(149.23,150.14) 149.13,150.04 v4(149.13,149.35)
M_B_DQ37: length 78.4
  TOP w0.102: DIMM2.129 146.41,149.76 147.45,149.76 v4(147.86,149.35) ; CPU1.AP40 88.93,167.78 v4(88.93,167.92)
  L4 w0.089: 95.26,166.4 93.23,168.43 91.26,168.43 91.19,168.49 90.62,168.49 89.88,169.23 87.33,169.23 87.19,169.1 87.19,168.64 87.28,168.55 87.55,168.55 87.64,168.46 87.64,168.29 87.55,168.2 87.28,168.2 87.19,168.11 87.19,167.57 87.33,167.44 88.81,167.44 88.93,167.56 v4(88.93,167.92)
  L4 w0.127: v4(147.86,149.35) 147.45,149.35 145.78,147.68 135.59,147.68 135.02,147.11 129.35,147.11 129.33,147.12 125.02,147.12 109.08,163.07 103.92,163.07 100.94,166.05 95.6,166.05 95.26,166.4
  BOTTOM w0.102: v2(147.02,149.53) 147.2,149.35 v4(147.86,149.35)
M_B_DQ38: length 80.2
  TOP w0.102: CPU1.AP37 89.25,165.68 88.92,166 v4(88.92,166.09) ; v4(150.99,147.02) 152.16,145.85 DIMM2.142
  L4 w0.089: v4(88.92,166.09) 89.44,165.58 89.74,165.58 90.54,164.78 91.1,164.78 91.45,165.12 92.11,165.12 92.26,165.27 92.91,165.27 93.49,164.69 93.49,164.61 94.78,163.32 100.11,163.32 102.65,160.78
  L4 w0.127: v4(150.99,147.02) 150.99,146.12 150.02,145.14 149.51,145.14 149.14,144.78 147.7,144.78 147.08,144.16 143.81,144.16 142.49,142.83 124.53,142.83 124.53,142.83 124.24,142.83 108.83,158.24 105.19,158.24 102.65,160.78
  BOTTOM w0.102: v4(150.99,147.02) 151.73,146.28 v2(151.8,146.28)
M_B_DQ39: length 79
  TOP w0.102: v4(89.57,166.09) 89.9,165.77 CPU1.AR37 ; DIMM2.143 146.41,145.56 v4(147.86,145.56)
  L4 w0.089: 104.17,160.02 100.81,163.39 100.81,163.39 100.36,163.83 94.9,163.83 92.61,166.12 91.48,166.12 91.05,165.69 89.97,165.69 v4(89.57,166.09)
  L4 w0.127: v4(147.86,145.56) 147.76,145.56 147.06,144.87 143.45,144.87 142.1,143.52 130.86,143.52 130.73,143.65 130.73,144.15 130.61,144.27 130.35,144.27 130.23,144.15 130.23,143.65 130.1,143.52 129.85,143.52 129.72,143.65 129.72,144.15 129.59,144.27 129.34,144.27 129.21,144.15 129.21,143.65 129.08,143.52 128.83,143.52 128.7,143.65 128.7,144.15 128.58,144.27 128.32,144.27 128.19,144.15 128.19,143.65 128.07,143.52 127.81,143.52 127.69,143.65 127.69,144.15 127.56,144.27 127.31,144.27 127.18,144.15 127.18,143.65 127.05,143.52 126.8,143.52 126.67,143.65 126.67,144.15 126.54,144.27 126.29,144.27 126.16,144.15 126.16,143.65 126.04,143.52 125.78,143.52 125.65,143.65 125.65,144.15 125.53,144.27 125.27,144.27 125.15,144.15 125.15,143.65 125.02,143.52 124.53,143.52 108.13,159.92 104.27,159.92 104.17,160.02
  BOTTOM w0.102: v4(147.86,145.56) 147.86,144.91 v2(147.71,144.75)
M_B_DQ40: length 80.4
  TOP w0.102: CPU1.AT33 90.55,163.94 v4(90.22,164.26) ; v4(148,144) 148.12,144 148.24,144.13 148.24,144.4 148.12,144.53 147.54,144.53 147.37,144.35 DIMM2.147
  L4 w0.089: v4(90.22,164.26) 91.39,164.26 91.55,164.1 93.13,164.1 95.25,161.98 99.99,161.98
  L4 w0.127: v4(148,144) 148,143.69 147.79,143.47 144.51,143.47 142,140.97 140.12,140.97 140,140.84 140,140.3 139.87,140.17 139.61,140.17 139.49,140.3 139.49,140.84 139.36,140.97 139.11,140.97 138.98,140.84 138.98,140.19 138.85,140.06 138.6,140.06 138.47,140.19 138.47,140.84 138.34,140.97 135.27,140.97 134.91,140.61 132.51,140.61 131.27,139.37 128.91,139.37 128.79,139.5 128.79,140.1 128.66,140.23 128.4,140.23 128.28,140.1 128.28,139.5 128.15,139.37 127.9,139.37 127.77,139.5 127.77,140.1 127.64,140.23 127.39,140.23 127.26,140.1 127.26,139.5 127.13,139.37 126.45,139.37 108.53,157.29 103.63,157.29 102.56,158.36 102.38,158.54 102.38,159.59 99.99,161.98
  BOTTOM w0.102: v2(148,143.17) v4(148,144)
M_B_DQ41: length 80
  TOP w0.102: CPU1.AU33 91.53,163.47 v4(91.59,163.47) ; DIMM2.149 147.52,143.75 147.7,143.57 149.38,143.57 v4(149.76,143.96)
  L4 w0.089: 99.88,161.48 95.1,161.48 93.1,163.47 v4(91.59,163.47)
  L4 w0.127: 99.88,161.48 100.14,161.22 100.14,160.87 100.13,160.87 100.13,159.97 100.34,159.77 100.52,159.77 100.87,160.12 101.05,160.12 101.23,159.94 101.23,159.76 100.88,159.41 100.88,159.23 101.06,159.05 101.24,159.05 101.59,159.4 101.77,159.4 101.95,159.22 101.95,159.04 101.59,158.69 101.59,158.51 103.67,156.44 108.31,156.44 126.07,138.68 129.41,138.68 129.72,138.38 134.1,138.38 135.13,139.41 139.84,139.41 139.91,139.48 140.15,139.48 140.15,139.48 141.48,139.48 141.92,139.92 144.79,142.79 149.87,142.79 149.99,142.91 149.99,143.83 149.87,143.96 v4(149.76,143.96)
  BOTTOM w0.102: v2(149.76,143.12) v4(149.76,143.96)
M_B_DQ42: length 78.5
  TOP w0.102: v4(149.83,141.54) 149.42,141.95 147.95,141.95 147.35,141.35 DIMM2.157 ; CPU1.AU30 91.2,162.11 v4(90.87,162.43)
  L4 w0.089: 95.89,159 95.33,159 91.9,162.43 v4(90.87,162.43)
  L4 w0.127: v4(149.83,141.54) 150.13,141.54 150.27,141.4 150.27,140.93 150.15,140.8 145.38,140.8 141.74,137.16 135.54,137.16 134.96,136.57 131.22,136.57 130.84,136.2 126.07,136.2 124.33,137.94 111.48,150.79 110.57,150.79 108.84,152.52 108.83,152.52 106.64,154.7 103.55,154.7 99.25,159 95.89,159
  BOTTOM w0.102: v4(149.83,141.54) 149.83,141.01 v2(149.58,140.75)
M_B_DQ43: length 79.7
  TOP w0.102: DIMM2.159 147.52,140.75 v4(148.29,141.52) ; v4(90.22,162.43) 90.22,162.31 90.55,161.98 CPU1.AT30
  L4 w0.089: 92.72,161.93 91.96,162.69 91.18,162.69 91.04,162.83 90.62,162.83 v4(90.22,162.43)
  L4 w0.127: v4(148.29,141.52) 148.03,141.27 145.31,141.27 141.58,137.54 141.16,137.54 141.03,137.67 141.03,137.97 140.9,138.09 140.65,138.09 140.52,137.97 140.52,137.67 140.39,137.54 140.14,137.54 140.01,137.67 140.01,137.97 139.89,138.09 139.63,138.09 139.51,137.97 139.51,137.67 139.38,137.54 139.12,137.54 139,137.67 139,137.97 138.87,138.09 138.62,138.09 138.49,137.97 138.49,137.67 138.36,137.54 135.42,137.54 134.68,136.8 130.7,136.8 130.49,136.59 128.28,136.59 128.16,136.72 128.16,137.22 128.03,137.35 127.77,137.35 127.65,137.22 127.65,136.72 127.52,136.59 127.27,136.59 127.14,136.72 127.14,137.22 127.01,137.35 126.76,137.35 126.63,137.22 126.63,136.72 126.5,136.59 126.16,136.59 124.87,137.88 123.62,139.14 111.62,151.13 110.71,151.13 108.98,152.86 108.97,152.86 106.78,155.05 106.5,155.05 103.74,155.05 103.41,155.37 103.39,155.37 98.8,159.96 94.69,159.96 92.72,161.93
  BOTTOM w0.102: v4(148.29,141.52) 148.29,140.99 v2(148.03,140.73)
M_B_DQ44: length 80.6
  TOP w0.102: DIMM2.148 152.43,144.05 v4(151.84,144.64) ; v4(89.58,164.26) 89.9,163.94 CPU1.AR33
  L4 w0.089: 98.88,161.73 95.22,161.73 93.08,163.87 91.42,163.87 91.41,163.86 89.98,163.86 v4(89.58,164.26)
  L4 w0.127: v4(151.84,144.64) 151.4,144.21 150.97,144.21 150.78,144.4 149.58,144.4 149.32,144.14 149.32,143.98 148.46,143.13 144.65,143.13 141.78,140.26 141.36,139.84 139.95,139.84 139.89,139.78 134.97,139.78 134.72,139.53 133.92,139.53 133.26,138.88 130.15,138.88 130,139.03 126.21,139.03 108.29,156.95 103.46,156.95 102.16,158.25 102.16,159.5 99.93,161.73 98.88,161.73
  BOTTOM w0.102: v2(151.84,143.83) v4(151.84,144.64)
M_B_DQ45: length 81.6
  TOP w0.102: CPU1.AP33 89.25,163.92 v4(88.95,164.22) ; DIMM2.146 v4(153.14,144.65)
  L4 w0.089: v4(88.95,164.22) 89.39,164.66 90.39,164.66 90.45,164.6 91.2,164.6 91.51,164.92 92.02,164.92 92.52,164.42 93.13,164.42 94.53,163.02 99.9,163.02 100.22,162.7
  L4 w0.127: 100.22,162.7 100.36,162.56 100.36,162.18 102.6,159.94 102.6,159 103.96,157.64 108.66,157.64 108.67,157.63 108.68,157.63 125.25,141.06 129.31,141.06 129.43,140.93 129.43,140.15 129.56,140.02 129.82,140.02 129.94,140.15 129.94,140.93 130.07,141.06 134.72,141.06 135.18,141.52 142.07,141.52 144.36,143.81 147.1,143.81 147.81,144.52 149.38,144.52 149.48,144.63 150.27,144.63 150.73,145.09 152.7,145.09 v4(153.14,144.65)
  BOTTOM w0.102: v2(153.14,143.84) v4(153.14,144.65)
M_B_DQ46: length 80.2
  TOP w0.102: DIMM2.160 v4(153.14,140.45) ; CPU1.AR30 89.57,162.3 v4(89.57,162.43)
  L4 w0.089: v4(89.57,162.43) 89.97,162.03 91.22,162.03 91.29,162.11 91.96,162.11 95.28,158.78
  L4 w0.127: v4(153.14,140.45) 153.14,140.65 152.69,141.1 151.03,141.1 150.36,140.42 145.59,140.42 141.89,136.72 135.74,136.72 135.36,136.34 132.46,136.34 131.93,135.81 125.97,135.81 111.34,150.44 110.98,150.44 110.42,150.44 108.69,152.18 108.69,152.18 106.5,154.36 103.51,154.36 99.09,158.78 95.28,158.78
  BOTTOM w0.102: v2(152.89,139.66) 153.14,139.92 v4(153.14,140.45)
M_B_DQ47: length 80.8
  TOP w0.102: v4(151.79,140.47) 152.37,141.05 DIMM2.158 ; CPU1.AP30 88.92,162.3 v4(88.92,162.43)
  L4 w0.089: 95.41,158.45 95.33,158.45 93.82,159.96 93.82,159.97 91.86,161.93 91.37,161.93 91.29,161.86 89.5,161.86 v4(88.92,162.43)
  L4 w0.127: 95.41,158.45 95.41,158.45 98.78,158.45 103.22,154.02 106.36,154.02 110.27,150.1 110.56,150.1 111.2,150.1 125.97,135.33 134.9,135.33 135.09,135.52 141.17,135.52 145.68,140.03 151.35,140.03 v4(151.79,140.47)
  BOTTOM w0.102: v2(151.54,139.68) 151.79,139.94 v4(151.79,140.47)
M_B_DQ48: length 82.7
  TOP w0.102: CPU1.AU27 90.74,159.69 v4(90.22,159.69) ; DIMM2.174 v4(153.14,136.25)
  L4 w0.089: 97.37,155.19 95.05,155.19 93.76,156.49 93.76,157.73 92.64,158.85 91.06,158.85 v4(90.22,159.69)
  L4 w0.127: 97.37,155.19 102.06,150.5 105.14,150.5 108.64,146.99 110.1,146.99 125.6,131.5 141.69,131.5 142.01,131.81 145.73,135.53 145.92,135.53 146.14,135.75 149.77,135.75 151.17,137.16 153.37,137.16 153.5,137.03 153.5,136.38 153.37,136.25 v4(153.14,136.25)
  BOTTOM w0.102: v4(153.14,136.25) 153.14,135.72 v2(152.89,135.46)
M_B_DQ49: length 82.6
  TOP w0.102: CPU1.AT27 90.87,160.47 v4(90.87,160.6) ; v4(150.13,138.53) 150.13,138.68 149.26,139.55 DIMM2.163
  L4 w0.089: v4(90.87,160.6) 91.36,160.12 91.88,160.12 92.35,159.65 93.12,159.65 94.78,157.99 94.78,156.74 95.26,156.25 97.82,156.25
  L4 w0.127: v4(150.13,138.53) 149.64,139.01 146.71,139.01 146.46,138.76 146.46,138.58 147,138.04 147,137.86 146.31,137.17 146.13,137.17 145.95,137.35 145.95,137.53 146.28,137.86 146.28,138.04 146.1,138.22 145.92,138.22 142.14,134.44 139.1,134.44 138.46,133.8 132.33,133.8 131.8,133.27 126.2,133.27 110.8,148.67 109.45,148.67 105.85,152.27 101.8,152.27 97.82,156.25
  BOTTOM w0.102: v4(150.13,138.53) 150.13,137.99 v2(149.87,137.74)
M_B_DQ50: length 81.4
  TOP w0.102: v4(89.57,158.78) 90.09,158.78 CPU1.AT25 ; DIMM2.175 148.75,135.95 148.75,135.92 v4(149.36,135.31)
  L4 w0.089: 97.23,154.65 95.06,154.65 93.26,156.46 93.26,157.62 92.41,158.47 89.88,158.47 v4(89.57,158.78)
  L4 w0.127: 97.23,154.65 102.17,149.71 104.81,149.71 108.21,146.31 109.82,146.31 126.01,130.12 132.68,130.12 132.69,130.11 134.96,130.11 134.97,130.12 135.35,130.12 135.36,130.11 137.63,130.11 137.64,130.12 137.98,130.12 138.11,130.25 138.11,130.53 138.24,130.66 138.49,130.66 138.62,130.53 138.62,130.25 138.75,130.12 139,130.12 139.13,130.25 139.13,130.53 139.25,130.66 139.51,130.66 139.64,130.53 139.64,130.25 139.76,130.12 141.92,130.12 146.64,134.84 148.9,134.84 v4(149.36,135.31)
  BOTTOM w0.102: v2(149.11,134.52) 149.36,134.77 v4(149.36,135.31)
M_B_DQ51: length 80.6
  TOP w0.102: CPU1.AU25 91.35,159.23 91.6,159.49 91.6,159.64 v4(91.6,159.64) ; DIMM2.165 148.39,138.95 v4(148.78,138.56)
  L4 w0.089: 97.8,155.95 95.32,155.95 94.52,156.74 94.52,157.86 92.93,159.46 91.78,159.46 v4(91.6,159.64)
  L4 w0.127: v4(148.78,138.56) 148.78,138.2 148.91,138.07 149.94,138.07 150.07,137.95 150.07,137.59 149.94,137.46 148.36,137.46 148.35,137.48 147.98,137.48 147.38,136.88 145.09,136.88 142.31,134.09 141.24,134.09 141.11,133.97 141.11,132.96 140.99,132.83 140.73,132.83 140.61,132.96 140.61,133.97 140.48,134.09 139.08,134.09 138.46,133.48 132.5,133.48 131.86,132.84 126.14,132.84 110.66,148.33 109.21,148.33 105.65,151.89 101.86,151.89 97.8,155.95
  BOTTOM w0.102: v2(148.53,137.77) 148.78,138.03 v4(148.78,138.56)
M_B_DQ52: length 83
  TOP w0.102: v4(88.92,160.6) 88.92,160.54 89.25,160.21 CPU1.AP27 ; DIMM2.164 152.19,139.25 v4(151.02,138.08)
  L4 w0.089: 95.92,157.23 93.36,159.78 93.36,159.92 92.34,160.94 91.15,160.94 91.08,161 89.32,161 v4(88.92,160.6)
  L4 w0.127: v4(151.02,138.08) 151.02,138.26 150.02,139.26 145.97,139.26 141.5,134.79 135.71,134.79 135.42,134.5 132.51,134.5 131.67,133.65 126.3,133.65 110.94,149.01 109.62,149.01 105.98,152.65 101.92,152.65 99.2,155.37 99.2,156.96 98.94,157.23 95.92,157.23
  BOTTOM w0.102: v4(151.02,138.08) 151.02,137.29 v2(151.01,137.29)
M_B_DQ53: length 83.6
  TOP w0.102: CPU1.AN27 88.27,160.47 v4(88.27,160.6) ; v4(152.4,138.06) 152.4,138.15 152.91,138.65 DIMM2.166
  L4 w0.089: 96.05,157.48 93.63,159.89 93.63,159.9 92.42,161.12 91.38,161.12 91.31,161.18 89.15,161.18 89.09,161.12 88.25,161.12 88.12,160.99 88.12,160.73 88.25,160.6 v4(88.27,160.6)
  L4 w0.127: 96.05,157.48 98.23,157.48 98.26,157.44 99.03,157.44 99.42,157.05 99.42,155.8 102.1,153.11 106.33,153.11 110.09,149.36 111.08,149.36 126.43,134.01 131.51,134.01 132.34,134.84 135.33,134.84 135.64,135.15 141.31,135.15 145.68,139.52 150.25,139.52 151.27,138.5 151.86,138.5 152.3,138.06 v4(152.4,138.06)
  BOTTOM w0.102: v2(152.4,137.26) v4(152.4,138.06)
M_B_DQ54: length 83.6
  TOP w0.102: DIMM2.176 152.2,135.65 v4(151.57,136.28) ; CPU1.AN25 88.27,159.56 v4(88.27,159.69)
  L4 w0.089: 95.26,154.36 95.11,154.36 93.08,156.39 93.08,156.66 92.27,157.48 92.27,157.68 91.69,158.26 89.52,158.26 88.27,159.51 v4(88.27,159.69)
  L4 w0.127: v4(151.57,136.28) 151.57,136.21 149.57,134.21 146.49,134.21 142.07,129.78 125.86,129.78 109.68,145.97 107.99,145.97 104.63,149.33 102.05,149.33 97.02,154.36 95.26,154.36
  BOTTOM w0.102: v4(151.57,136.28) 151.57,135.75 v2(151.32,135.49)
M_B_DQ55: length 82.7
  TOP w0.102: v4(88.92,159.69) 88.92,159.56 CPU1.AP25 ; v4(147.86,135.3) 146.45,135.3 DIMM2.177
  L4 w0.089: v4(88.92,159.69) 89.44,159.18 90.47,159.18 90.98,158.66 92.58,158.66 93.52,157.72 93.52,156.45 95.03,154.94 97.29,154.94
  L4 w0.127: 97.29,154.94 102.16,150.06 104.99,150.06 108.4,146.65 109.96,146.65 125.46,131.16 126.24,131.16 126.37,131.03 126.37,130.59 126.49,130.46 126.75,130.46 126.88,130.59 126.88,131.03 127,131.16 127.26,131.16 127.38,131.03 127.38,130.59 127.51,130.46 127.76,130.46 127.89,130.59 127.89,131.03 128.02,131.16 128.27,131.16 128.4,131.03 128.4,130.59 128.53,130.46 128.78,130.46 128.91,130.59 128.91,131.03 129.03,131.16 129.29,131.16 129.42,131.03 129.42,130.59 129.54,130.46 129.8,130.46 129.92,130.59 129.92,131.03 130.05,131.16 130.3,131.16 130.43,131.03 130.43,130.59 130.56,130.46 130.81,130.46 130.94,130.59 130.94,131.03 131.07,131.16 131.32,131.16 131.45,131.03 131.45,130.59 131.57,130.46 131.83,130.46 131.96,130.59 131.96,131.03 132.08,131.16 142.3,131.16 146.44,135.3 v4(147.86,135.3)
  BOTTOM w0.102: v4(147.86,135.3) 147.86,134.76 v2(147.61,134.51)
M_B_DQ56: length 84.6
  TOP w0.102: CPU1.AT22 90.55,157.27 v4(90.87,156.95) ; DIMM2.181 148.71,134.15 150.15,132.72 v4(150.15,132.33)
  L4 w0.089: 95.63,152.67 91.85,156.45 91.52,156.45 91.02,156.95 v4(90.87,156.95)
  L4 w0.127: 95.63,152.67 95.77,152.53 96.81,152.53 97.45,151.88 97.45,151.5 101.51,147.45 103.54,147.45 106.9,144.08 107.96,144.08 109.06,144.08 127.24,125.91 130.27,125.91 132.51,128.14 138.19,128.14 138.31,128.02 138.31,127.51 138.44,127.38 138.69,127.38 138.82,127.51 138.82,128.02 138.95,128.14 139.2,128.14 139.33,128.02 139.33,127.58 139.46,127.46 139.71,127.46 139.84,127.58 139.84,128.02 139.96,128.14 140.31,128.14 140.43,128.02 140.43,127.58 140.56,127.46 140.81,127.46 140.94,127.58 140.94,128.02 141.07,128.14 142.37,128.14 142.63,128.41 143.04,128.82 143.96,128.82 146.72,131.57 149.39,131.57 v4(150.15,132.33)
  BOTTOM w0.102: v4(150.15,132.33) 150.71,132.33 v2(150.93,132.56)
M_B_DQ57: length 84.4
  TOP w0.102: v4(153.12,134.44) 153.13,134.45 DIMM2.180 ; v4(90.87,157.86) 90.87,157.61 91.08,157.4 CPU1.AU22
  L4 w0.089: v4(90.87,157.86) 91.28,157.45 92.02,157.45 92.49,156.99 92.49,156.73 95.11,154.1 95.23,154.1
  L4 w0.127: v4(153.12,134.44) 153.12,134.75 153,134.87 152.66,134.87 152.66,134.88 152.29,134.88 152.29,134.87 150.67,134.87 150.54,134.75 150.54,134.21 150.8,133.95 151.8,133.95 151.93,133.83 151.93,133.35 151.8,133.22 150.53,133.22 150.19,133.56 147.18,133.56 143.47,129.84 142.62,129.84 142.21,129.44 141.94,129.17 132.4,129.17 131.76,128.52 127.88,128.52 126.96,129.44 125.46,129.44 109.67,145.22 107.54,145.22 104.17,148.59 101.38,148.59 98.1,151.87 98.1,152.15 97.08,153.17 96.16,153.17 95.23,154.1
  BOTTOM w0.102: v2(152.87,133.65) 153.12,133.91 v4(153.12,134.44)
M_B_DQ58: length 83.1
  TOP w0.102: DIMM2.183 147.71,133.55 148.62,132.63 v4(148.62,132.33) ; v4(91.78,156.87) 91.4,156.49 CPU1.AU21
  L4 w0.089: 95.92,152.74 91.79,156.87 v4(91.78,156.87)
  L4 w0.127: 95.92,152.74 96.9,152.74 97.67,151.97 97.67,151.59 101.43,147.83 103.79,147.83 107.08,144.54 109.29,144.54 125.2,128.63 125.46,128.63 125.59,128.75 125.79,128.75 125.96,128.58 125.96,128.4 125.71,128.15 125.71,127.97 125.88,127.79 126.06,127.79 126.76,128.49 126.94,128.49 127.12,128.31 127.12,128.13 126.42,127.43 126.42,127.25 127.43,126.25 127.77,126.25 127.9,126.38 127.9,127 128.02,127.13 128.28,127.13 128.4,127 128.4,126.38 128.53,126.25 128.78,126.25 128.91,126.38 128.91,127 129.04,127.13 129.29,127.13 129.42,127 129.42,126.38 129.55,126.25 130.13,126.25 132.37,128.49 142.23,128.49 142.49,128.75 142.9,129.16 143.82,129.16 147.18,132.52 147.18,132.52 147.43,132.78 148.18,132.78 v4(148.62,132.33)
  BOTTOM w0.102: v4(148.62,132.33) 148.27,132.69 v2(148.27,133.05)
M_B_DQ59: length 84.1
  TOP w0.102: v4(89.57,156.03) 90.09,156.03 CPU1.AT21 ; DIMM2.193 147.61,130.55 148.18,129.99 149.35,129.99 v4(149.76,130.4)
  L4 w0.089: v4(89.57,156.03) 89.89,155.71 91.14,155.71 95.77,151.08 95.77,151.03
  L4 w0.127: 95.77,151.03 104.43,142.37 108.41,142.37 126.54,124.23 140.83,124.23 142.96,126.36 145.32,126.36 146.17,127.22 146.35,127.22 147.13,126.44 147.31,126.44 147.57,126.71 147.57,126.89 146.8,127.67 146.8,127.85 148.94,129.98 149.34,129.98 v4(149.76,130.4)
  BOTTOM w0.102: v2(149.76,131.19) v4(149.76,130.4)
M_B_DQ60: length 86.3
  TOP w0.102: DIMM2.191 147.77,131.15 148.41,130.52 v4(148.41,130.43) ; v4(88.92,156.95) 88.92,157.08 CPU1.AN22
  L4 w0.089: v4(88.92,156.95) 89.4,156.46 89.76,156.46 90.32,155.9 91.33,155.9 96.45,150.77
  L4 w0.127: 96.45,150.77 96.51,150.77 104.54,142.75 108.51,142.75 126.68,124.57 131.89,124.57 132.02,124.7 132.02,125.48 132.15,125.6 132.53,125.6 132.65,125.48 132.65,124.7 132.78,124.57 136.88,124.57 137.01,124.7 137.01,125.86 137.14,125.98 137.52,125.98 137.64,125.86 137.64,124.7 137.77,124.57 138.15,124.57 138.28,124.7 138.28,125.86 138.41,125.98 138.79,125.98 138.91,125.86 138.91,124.7 139.04,124.57 139.47,124.57 141.02,126.12 142.23,126.12 142.86,126.75 145.22,126.75 148.41,129.94 v4(148.41,130.43)
  BOTTOM w0.102: v4(148.41,130.43) 147.97,130.43 v2(147.63,130.76)
M_B_DQ61: length 85.8
  TOP w0.102: v4(88.92,157.86) 89.25,157.54 CPU1.AP22 ; v4(151.78,134.42) 152.35,133.86 152.81,133.86 152.82,133.85 DIMM2.182
  L4 w0.089: v4(88.92,157.86) 89.42,157.37 91.05,157.37 91.14,157.27 91.96,157.27 92.19,157.03 92.19,156.76 95.99,152.96
  L4 w0.127: v4(151.78,134.42) 151.85,134.42 152.29,133.99 152.81,133.99 152.94,133.86 152.94,132.97 152.81,132.84 150.27,132.84 150.02,133.1 147.23,133.1 143.63,129.5 142.76,129.5 142.35,129.09 142.09,128.83 132.39,128.83 131.7,128.14 127.77,128.14 126.82,129.09 125.31,129.09 109.52,144.88 107.37,144.88 104.05,148.21 101.36,148.21 97.89,151.68 97.89,152.06 96.99,152.96 95.99,152.96
  BOTTOM w0.102: v4(151.78,134.42) 151.78,133.89 v2(151.53,133.64)
M_B_DQ62: length 84.8
  TOP w0.102: DIMM2.192 151.84,130.85 150.89,129.9 v4(150.89,129.75) ; CPU1.AP21 88.92,156.16 v4(88.92,156.03)
  L4 w0.089: v4(88.92,156.03) 89.44,155.52 91.08,155.52 95.41,151.19 95.41,150.86
  L4 w0.127: 95.41,150.86 104.28,141.99 108.24,141.99 126.34,123.89 140.97,123.89 143.07,125.98 147.35,125.98 148.88,127.51 149.39,127.51 150.02,128.14 150.02,128.32 149.82,128.52 149.82,128.7 150.09,128.97 150.27,128.97 150.47,128.77 150.65,128.77 150.89,129.02 v4(150.89,129.75)
  BOTTOM w0.102: v2(150.89,128.94) v4(150.89,129.75)
M_B_DQ63: length 86.4
  TOP w0.102: CPU1.AN21 88.6,156.55 88.27,156.87 v4(88.27,156.95) ; v4(152.31,129.76) 152.81,130.25 DIMM2.194
  L4 w0.127: v4(88.27,156.95) 87.85,156.53 87.85,154.94 88.11,154.69 91.64,154.69 94.52,151.8 94.52,151.26 104.3,141.48 108.26,141.48 126.19,123.54 141.13,123.54 143.19,125.6 147.48,125.6 148.88,127 149.56,127 v4(152.31,129.76)
  BOTTOM w0.102: v2(152.31,128.94) v4(152.31,129.76)
M_B_DQS_DN0: length 92.4
  TOP w0.102: DIMM2.27 147.31,182.75 147.31,182.76 147.34,182.76 147.59,183.01 148.52,183.01 149.14,182.39 v4(149.17,182.39) ; v4(85.6,181.74) 85.93,182.06 CPU1.AH66
  L4 w0.127: v4(149.17,182.39) 149,182.55 149,182.99 148.68,183.32 146.89,183.32 136.4,193.81 131.2,193.81 129.63,195.38 111.18,195.38 111.05,195.51 111.05,196.66 110.77,196.95 110.17,196.95 109.88,196.66 109.88,195.51 109.75,195.38 109.37,195.38 109.25,195.51 109.25,196.58 108.96,196.87 108.36,196.87 108.08,196.58 108.08,195.52 107.95,195.39 107.45,195.39 107.32,195.52 107.32,196.24 106.87,196.69 92.75,196.69 89.59,193.54 89.59,189.34 90.07,188.87 90.07,186.17 89.82,185.93 88.87,185.93 88.31,185.37 87.99,185.37 86.07,183.44 86.07,182.26 85.79,181.98 85.79,181.92 v4(85.6,181.74)
  BOTTOM w0.102: v4(149.17,182.39) 149.17,182.79 149.56,183.18 v2(150.07,183.18)
M_B_DQS_DN1: length 92.6
  TOP w0.089: v4(84.17,187.7) 84.35,187.87 84.51,187.87 84.58,187.81 84.58,186.01 85.11,185.48 85.11,185.24 85.06,185.09 85.06,184.89 85.12,184.69 85.12,184.38 CPU1.AG69
  TOP w0.102: v4(151.74,186.66) 151.84,186.75 151.84,187.24 152.26,187.66 153.36,187.66 153.55,187.85 DIMM2.10
  L4 w0.127: v4(151.74,186.66) 151.74,187.5 151.36,187.88 149.15,187.88 141.06,195.96 139.91,195.96 135.14,200.72 122.3,200.72 122.01,200.44 118.72,200.44 118.43,200.73 91.23,200.73 85.38,194.87 85.38,194.22 85.38,188.72 84.78,188.13 v4(84.17,187.7)
  BOTTOM w0.102: v4(151.74,186.66) 151.74,186.38 v2(151.29,185.93)
M_B_DQS_DN2: length 81.1
  TOP w0.102: DIMM2.45 146.42,177.37 148.6,177.37 v4(149.22,176.74) ; v4(90.22,181.64) 89.9,181.96 CPU1.AR66
  L4 w0.089: 91.41,183.7 91.21,183.51 90.91,183.51 90.59,183.19 90.59,182.58 90.65,182.53 90.65,181.76 90.52,181.64 v4(90.22,181.64)
  L4 w0.114: 149.02,176.94 v4(149.22,176.74)
  L4 w0.127: 91.41,183.7 92.51,184.8 93.74,184.8 94.99,186.04 94.99,187.17 95.82,188 96.19,188 96.54,188.36 101.5,188.36 103.15,190.01 115.9,190.01 117.28,188.63 117.81,188.63 117.94,188.76 117.94,189.71 118.23,189.99 118.83,189.99 119.11,189.71 119.11,188.76 119.24,188.63 119.62,188.63 119.75,188.76 119.75,189.67 120.03,189.95 120.63,189.95 120.91,189.67 120.91,188.76 121.04,188.63 121.42,188.63 121.55,188.76 121.55,189.67 121.83,189.95 122.43,189.95 122.72,189.67 122.72,188.76 122.84,188.63 129.72,188.63 132.51,185.85 137.86,185.85 145.66,178.04 148.64,178.04 149.02,177.67 149.02,176.95 149.02,176.94
  BOTTOM w0.102: v4(149.22,176.74) 149.22,176.26 v2(149.56,175.92)
M_B_DQS_DN3: length 76.5
  TOP w0.102: v4(89.57,178.89) 89.57,178.95 89.9,179.27 CPU1.AR61 ; DIMM2.62 153.74,172.25 153.58,172.09 152.51,172.09 152.22,171.8 152.2,171.8 151.77,171.36 v4(151.74,171.36)
  L4 w0.089: 98.84,183.64 98.83,183.64 98.79,183.6 98.24,183.6 95.58,180.94 95.58,180.61 95.22,180.25 94.86,180.23 94.86,180.22 94.52,180.22 93.49,179.2 93.49,178.86 93.16,178.52 91.16,178.52 91.12,178.57 90.46,178.57 90.39,178.49 89.9,178.49 89.57,178.82 v4(89.57,178.89)
  L4 w0.127: 98.84,183.64 100.86,183.64 101.03,183.47 105.1,183.47 105.26,183.64 116.73,183.64 117.36,184.27 128.19,184.27 132.79,179.67 137.99,179.67 146.16,171.49 150.23,171.49 151.08,170.64 151.64,170.64 151.93,170.92 151.93,171.18 v4(151.74,171.36)
  BOTTOM w0.102: v4(151.74,171.36) 151.74,171.04 v2(151.37,170.66)
M_B_DQS_DN4: length 78.1
  TOP w0.102: CPU1.AT38 90.31,166.55 90.11,166.75 90.11,166.94 90.2,167.03 v4(90.28,167.03) ; v4(148.74,147.84) 148.99,147.58 148.99,147.46 148.82,147.29 147.86,147.29 147.62,147.53 147.62,147.81 147.48,147.95 DIMM2.135
  L4 w0.089: v4(90.28,167.03) 90.4,167.03 90.52,166.9 90.52,166.81 90.54,166.79 90.54,166.69 90.67,166.55 91.02,166.55 91.05,166.58 91.09,166.58 91.26,166.75 93.01,166.75 94.59,165.17 100.18,165.17 100.62,164.73 104.05,161.3 104.3,161.3
  L4 w0.127: 104.3,161.3 108.36,161.3 124.15,145.52 131.61,145.52 132.04,145.08 135.34,145.08 135.7,145.44 138.47,145.44 139.13,146.1 139.88,146.1 140.16,145.82 140.16,144.96 140.29,144.83 140.67,144.83 140.8,144.96 140.8,145.82 141.08,146.1 145.92,146.1 146.39,146.57 148.77,146.57 149,146.81 149,147.07 148.88,147.19 148.5,147.19 148.37,147.32 148.37,147.52 148.5,147.64 148.5,147.71 148.62,147.84 v4(148.74,147.84)
  BOTTOM w0.102: v2(148.18,147.05) 148.74,147.6 v4(148.74,147.84)
M_B_DQS_DN5: length 80.2
  TOP w0.102: CPU1.AT32 90.55,163.09 v4(90.25,163.39) ; v4(152.46,142.69) 152.46,142.42 152.57,142.31 153.26,142.31 153.27,142.31 153.29,142.31 153.55,142.56 153.55,142.59 153.81,142.85 DIMM2.152
  L4 w0.089: 93.31,162.85 93.3,162.86 93.24,162.86 92.97,163.14 91.82,163.14 91.75,163.07 91.42,163.07 91.41,163.08 91.4,163.08 90.91,163.58 90.38,163.58 90.25,163.45 v4(90.25,163.39)
  L4 w0.127: v4(152.46,142.69) 152.56,142.79 152.56,143.13 152.43,143.26 152.31,143.26 152.26,143.3 151.84,143.3 151.58,143.56 151,143.56 149.69,142.25 145.01,142.25 142.15,139.39 142.15,139.39 141.7,138.94 134.99,138.94 134.19,138.15 125.73,138.15 125.09,138.79 124.03,139.86 108.03,155.85 103.59,155.85 98.92,160.53 95.63,160.53 95.46,160.69 95.31,160.85 93.4,162.76 93.31,162.85
  BOTTOM w0.102: v4(152.46,142.69) 152.46,142.24 v2(152.79,141.91)
M_B_DQS_DN6: length 82.3
  TOP w0.102: CPU1.AR25 89.9,159.37 v4(89.57,159.69) ; v4(149.53,136.97) 148.75,137.75 DIMM2.169
  L4 w0.089: v4(89.57,159.69) 90.03,160.15 90.32,160.15 90.38,160.09 90.39,160.09 90.93,159.55 90.93,159.47 91.36,159.04 92.82,159.04 94.08,157.79 94.08,156.66 94.08,156.42 94.99,155.51 97.46,155.51 97.46,155.51 97.55,155.51
  L4 w0.127: 97.55,155.51 102.02,151.04 105.35,151.04 108.87,147.53 110.32,147.53 125.82,132.03 138.93,132.03 139.21,132.32 139.21,133.3 139.34,133.43 139.72,133.43 139.85,133.3 139.85,132.32 140.13,132.03 141.47,132.03 145.5,136.07 149.11,136.07 149.4,136.35 149.4,136.41 149.53,136.54 v4(149.53,136.97)
  BOTTOM w0.102: v4(149.53,136.97) 149.53,136.48 v2(149.87,136.14)
M_B_DQS_DN7: length 84.5
  TOP w0.102: CPU1.AR22 89.9,157.27 v4(90.22,156.95) ; v4(151.67,131.7) 151.75,131.7 151.87,131.83 151.87,132.21 152,132.33 152.51,132.33 152.64,132.46 153.58,132.46 153.77,132.65 DIMM2.186
  L4 w0.089: 95.06,152.83 94.98,152.91 94.83,152.91 91.48,156.27 90.48,156.27 90.08,156.67 90.08,156.82 90.2,156.95 v4(90.22,156.95)
  L4 w0.127: 95.06,152.83 95.67,152.22 96.81,152.22 97.24,151.8 97.24,151.21 101.76,146.69 103.03,146.69 103.8,145.91 103.8,145.69 103.8,145.63 104.44,144.99 104.44,144.51 105.4,143.55 108.18,143.55 108.84,143.55 127.02,125.37 130.61,125.37 132.16,126.92 133.23,126.92 133.52,126.64 133.52,126.49 133.64,126.36 134.02,126.36 134.15,126.49 134.15,126.64 134.43,126.92 141.9,126.92 142.63,127.65 143.31,127.65 143.94,128.28 144.83,128.28 147.69,131.14 151.75,131.14 151.86,131.25 151.86,131.51 v4(151.67,131.7)
  BOTTOM w0.102: v4(151.67,131.7) 151.67,131.17 v2(151.42,130.91)
M_B_DQS_DP0: length 91.9
  TOP w0.102: DIMM2.29 147.06,182.15 147.43,182.52 147.43,182.54 147.68,182.8 148.43,182.8 148.53,182.69 v4(148.53,182.39) ; v4(85.6,181.09) 85.74,181.09 CPU1.AH65
  L4 w0.127: v4(148.53,182.39) 148.74,182.59 148.74,182.88 148.57,183.05 146.78,183.05 136.29,193.54 131.09,193.54 129.52,195.12 111.07,195.12 110.78,195.4 110.78,196.55 110.66,196.68 110.28,196.68 110.15,196.55 110.15,195.4 109.87,195.12 109.26,195.12 108.98,195.4 108.98,196.47 108.85,196.6 108.47,196.6 108.35,196.47 108.35,195.4 108.06,195.12 107.34,195.12 107.05,195.4 107.05,196.13 106.76,196.43 92.86,196.43 89.86,193.42 89.86,189.45 90.33,188.98 90.33,186.06 89.93,185.66 88.98,185.66 88.42,185.1 88.1,185.1 86.33,183.33 86.33,182.15 86.05,181.87 86.05,181.1 85.93,180.97 85.72,180.97 v4(85.6,181.09)
  BOTTOM w0.102: v4(148.53,182.39) 148.51,182.39 147.78,183.11 v2(147.78,183.18)
M_B_DQS_DP1: length 93.3
  TOP w0.089: v4(84.21,188.33) 84.48,188.06 84.59,188.06 84.77,187.88 84.77,186.09 85.28,185.57 85.28,185.21 85.24,185.06 85.24,184.92 85.3,184.72 85.3,184.54 CPU1.AG70
  TOP w0.102: DIMM2.12 153.55,187.25 153.36,187.44 152.35,187.44 152.05,187.15 152.05,186.98 v4(152.38,186.66)
  L4 w0.127: v4(152.38,186.66) 152.43,186.66 152.56,186.78 152.56,187.05 151.47,188.14 149.26,188.14 141.17,196.23 140.02,196.23 135.26,200.99 122.19,200.99 121.9,200.71 118.83,200.71 118.54,201 91.12,201 85.11,194.98 85.11,194.11 85.11,188.83 84.61,188.33 v4(84.21,188.33)
  BOTTOM w0.102: v2(153.75,186.16) 152.88,186.16 v4(152.38,186.66)
M_B_DQS_DP2: length 81
  TOP w0.102: DIMM2.47 147.29,176.75 147.69,177.15 148.51,177.15 148.69,176.97 148.69,176.84 v4(148.59,176.74) ; CPU1.AR65 89.9,181.05 v4(90.22,180.72)
  L4 w0.089: v4(90.22,180.72) 90.22,181.1 90.35,181.23 90.71,181.23 90.84,181.36 90.84,182.61 90.78,182.66 90.78,183.11 90.99,183.32 91.4,183.32 91.6,183.51
  L4 w0.127: v4(148.59,176.74) 148.75,176.91 148.75,177.56 148.53,177.78 145.55,177.78 137.75,185.58 132.4,185.58 129.61,188.37 122.73,188.37 122.45,188.65 122.45,189.56 122.32,189.68 121.94,189.68 121.82,189.56 121.82,188.65 121.53,188.37 120.93,188.37 120.65,188.65 120.65,189.56 120.52,189.68 120.14,189.68 120.01,189.56 120.01,188.65 119.73,188.37 119.13,188.37 118.84,188.65 118.84,189.6 118.72,189.73 118.34,189.73 118.21,189.6 118.21,188.65 117.93,188.37 117.17,188.37 115.79,189.74 103.26,189.74 101.61,188.09 96.65,188.09 96.3,187.74 95.93,187.74 95.25,187.06 95.25,185.93 93.85,184.53 92.62,184.53 91.6,183.51
  BOTTOM w0.102: v2(148.33,175.96) 148.59,176.21 v4(148.59,176.74)
M_B_DQS_DP3: length 76.4
  TOP w0.102: DIMM2.64 153.76,171.65 153.54,171.87 152.6,171.87 152.37,171.64 152.37,171.37 v4(152.38,171.36) ; CPU1.AR60 89.9,178.38 89.57,178.06 v4(89.57,177.98)
  L4 w0.089: v4(89.57,177.98) 89.57,178.06 89.82,178.3 90.47,178.3 90.54,178.38 91.04,178.38 91.09,178.33 93.24,178.33 93.68,178.78 93.68,179.12 94.6,180.03 94.94,180.03 94.95,180.04 95.3,180.06 95.77,180.53 95.77,180.86 98.32,183.41 98.79,183.41 98.83,183.38 98.84,183.38
  L4 w0.114: 152.2,171.19 v4(152.38,171.36)
  L4 w0.127: 98.84,183.38 100.75,183.38 100.92,183.21 105.21,183.21 105.38,183.38 116.84,183.38 117.47,184.01 128.07,184.01 132.68,179.4 137.88,179.4 146.05,171.23 150.12,171.23 150.97,170.37 151.75,170.37 152.19,170.81 152.19,171.18 152.2,171.19
  BOTTOM w0.102: v2(152.71,170.61) 152.38,170.95 v4(152.38,171.36)
M_B_DQS_DP4: length 78
  TOP w0.102: v4(89.63,167.01) 89.9,166.75 CPU1.AR38 ; DIMM2.137 147.5,147.35 147.77,147.07 148.91,147.07 149.21,147.37 149.21,147.65 149.37,147.81 v4(149.37,147.84)
  L4 w0.089: 104.3,161.04 104.05,161.04 100.48,164.6 100.1,164.98 94.51,164.98 92.93,166.56 91.34,166.56 91.17,166.39 91.12,166.39 91.1,166.36 90.59,166.36 90.46,166.5 90.19,166.5 89.67,167.01 v4(89.63,167.01)
  L4 w0.127: v4(149.37,147.84) 149.37,146.8 148.88,146.31 146.5,146.31 146.03,145.83 141.19,145.83 141.07,145.71 141.07,144.85 140.78,144.56 140.18,144.56 139.9,144.85 139.9,145.71 139.77,145.83 139.24,145.83 138.58,145.17 135.81,145.17 135.45,144.82 131.93,144.82 131.49,145.25 124.04,145.25 108.25,161.04 104.3,161.04
  BOTTOM w0.102: v2(149.43,147.05) 149.37,147.11 v4(149.37,147.84)
M_B_DQS_DP5: length 80.2
  TOP w0.102: v4(151.82,142.69) 152.42,142.09 153.38,142.09 153.54,142.25 DIMM2.154 ; v4(89.61,163.37) 89.9,163.09 CPU1.AR32
  L4 w0.089: v4(89.61,163.37) 90,162.99 90.42,162.99 90.56,163.13 91.08,163.13 91.33,162.88 91.83,162.88 91.9,162.95 92.89,162.95 93.11,162.73 93.11,162.67 93.12,162.66
  L4 w0.127: v4(151.82,142.69) 151.82,142.95 151.47,143.3 151.11,143.3 149.8,141.99 145.12,141.99 142.26,139.12 141.81,138.68 135.1,138.68 134.3,137.88 133.97,137.88 125.62,137.88 124.9,138.61 123.84,139.67 107.92,155.59 103.48,155.59 98.8,160.26 95.52,160.26 95.2,160.58 93.49,162.29 93.21,162.57 93.12,162.66
  BOTTOM w0.102: v2(151.57,141.9) 151.82,142.16 v4(151.82,142.69)
M_B_DQS_DP6: length 82.2
  TOP w0.102: v4(89.57,160.6) 89.57,160.47 CPU1.AR27 ; DIMM2.171 147.22,137.15 147.6,137.53 148.66,137.53 148.89,137.3 v4(148.89,136.97)
  L4 w0.089: v4(89.57,160.6) 89.44,160.6 89.31,160.48 89.31,160.27 89.44,160.15 89.76,160.15 89.95,160.34 90.4,160.34 90.46,160.28 90.47,160.28 91.12,159.63 91.12,159.55 91.44,159.23 92.9,159.23 94.27,157.86 94.27,156.58 94.27,156.58 94.27,156.5 95.07,155.7 97.38,155.7 97.45,155.77 97.67,155.77 97.74,155.7
  L4 w0.127: v4(148.89,136.97) 148.9,136.97 149.13,136.74 149.13,136.46 149,136.33 145.39,136.33 141.36,132.3 140.24,132.3 140.11,132.43 140.11,133.41 139.83,133.69 139.23,133.69 138.94,133.41 138.94,132.43 138.82,132.3 125.93,132.3 110.44,147.79 108.98,147.79 105.46,151.31 102.13,151.31 97.74,155.7
  BOTTOM w0.102: v4(148.89,136.97) 148.89,136.44 v2(148.64,136.19)
M_B_DQS_DP7: length 84.5
  TOP w0.102: v4(89.57,156.95) 89.9,156.62 CPU1.AR21 ; v4(152.31,131.7) 152.31,131.83 152.72,132.24 153.51,132.24 153.71,132.05 DIMM2.188
  L4 w0.089: 94.87,152.65 94.86,152.66 94.82,152.66 91.4,156.08 90.4,156.08 89.57,156.9 v4(89.57,156.95)
  L4 w0.127: 94.87,152.65 95.56,151.96 96.7,151.96 96.97,151.68 96.97,151.1 101.65,146.42 102.92,146.42 103.54,145.8 103.54,145.52 104.17,144.88 104.17,144.4 105.29,143.28 108.29,143.28 108.73,143.28 126.91,125.11 130.72,125.11 132.27,126.66 133.12,126.66 133.25,126.53 133.25,126.38 133.53,126.1 134.13,126.1 134.42,126.38 134.42,126.53 134.54,126.66 142.01,126.66 142.74,127.38 143.42,127.38 144.05,128.02 144.94,128.02 147.8,130.87 151.86,130.87 152.13,131.14 152.13,131.52 v4(152.31,131.7)
  BOTTOM w0.102: v4(152.31,131.7) 152.31,131.34 v2(152.69,130.96)
