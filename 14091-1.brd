# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDA17: length 36.1
  TOP w0.102: GPU1.C25 72.81,106.99 72.41,107.1 72.38,107.1 72.23,107.13 72.02,107.13 71.96,107.07 71.85,106.96 71.56,106.96 ; MEM1.C2 53.65,116.51 53.65,117.08 53.4,117.33 53.02,117.33 52.89,117.45 52.89,117.54 52.88,117.54 52.88,117.82 52.89,117.82 52.89,118.22 53.02,118.34 53.09,118.34 53.34,118.6
  TOP w0.127: 53.34,118.6 53.34,119.45 53.33,119.46 53.33,120.08 55.46,122.22 59.33,122.22 v1(59.34,122.22) 59.35,122.22 61.97,122.22 68.95,115.24 68.95,108.27 69.65,107.56 69.65,107.56 70.18,107.04 70.9,107.04 70.98,106.96 71.56,106.96
MDA18: length 36.6
  TOP w0.102: GPU1.E25 73.73,106.8 73.32,106.39 71.79,106.39 71.67,106.51 71.34,106.51 71.33,106.5 70.41,106.5
  TOP w0.127: MEM1.A3 54.01,118.19 54.14,118.32 54.18,118.32 54.28,118.42 54.28,119.72 54.51,119.96 54.69,119.96 54.84,119.81 55.02,119.81 55.2,119.99 55.2,120.17 55.05,120.32 55.05,120.5 55.63,121.07 61.41,121.07 61.97,121.07 67.82,115.22 v1(67.82,114.39) 67.53,114.1 67.53,111.32 67.4,111.19 66.71,111.19 66.58,111.07 66.58,110.81 66.71,110.68 67.4,110.68 67.53,110.56 67.53,110.3 67.4,110.18 66.71,110.18 66.58,110.05 66.58,109.8 66.71,109.67 67.4,109.67 67.53,109.54 67.53,108.59 68.83,107.29 68.87,107.29 69.66,106.51 70.41,106.51 70.41,106.5
MDA19: length 36.6
  TOP w0.102: 71.33,105.67 71.65,105.67 71.75,105.77 72.33,105.77 72.38,105.74 72.46,105.7 72.58,105.66 72.72,105.68 72.8,105.74 72.93,105.79 73,105.86 73.31,106 GPU1.D24
  TOP w0.127: MEM1.C3 54.01,116.35 55.17,117.5 55.17,118.16 55.81,118.8 55.81,118.98 55.31,119.47 55.31,119.62 55.43,119.74 55.86,119.74 56.07,119.53 56.41,119.53 56.59,119.71 56.59,120.04 56.47,120.17 56.01,120.17 55.89,120.3 55.89,120.6 56.01,120.73 61.83,120.73 67.19,115.37 67.19,111.74 66.98,111.53 66.56,111.53 66.16,111.13 66.16,109.73 66.85,109.03 v1(66.92,109.03) 66.92,108.71 69.4,106.24 70.77,106.24 71.33,105.67
MDA20: length 36.3
  TOP w0.102: 70.23,104.81 71.78,104.81 71.92,104.67 72.39,104.67 72.4,104.67 72.47,104.71 72.47,104.71 72.52,104.75 73.35,104.75 GPU1.E23
  TOP w0.127: 70.23,104.81 69.62,104.81 69.58,104.77 67.98,104.77 67.47,105.27 67.29,105.27 66.74,104.72 66.56,104.72 66.38,104.9 66.38,105.08 66.93,105.63 66.93,105.81 66.76,105.99 66.58,105.99 66.2,105.62 66.02,105.62 65.84,105.8 65.84,105.97 66.22,106.35 66.22,106.53 66.04,106.71 65.86,106.71 65.48,106.33 65.3,106.33 65.12,106.51 65.12,106.69 65.5,107.07 65.5,107.25 65.32,107.43 65.14,107.43 64.76,107.05 64.58,107.05 64.41,107.23 64.41,107.41 64.78,107.79 64.78,107.97 64.65,108.1 64.65,108.45 64.52,108.58 63.96,108.58 63.81,108.73 63.81,109.54 63.96,109.69 64.52,109.69 64.65,109.82 64.65,113.65 64.65,114.22 v1(64.99,114.56) 65.33,114.9 65.33,115.09 65.05,115.37 63.92,115.37 61.02,118.28 61.02,118.93 60.78,119.16 58.07,119.16 57.11,118.2 57.11,117.79 MEM1.A7
MDA21: length 36.9
  TOP w0.102: MEM1.D7 57.21,115.61 56.92,115.91 56.92,115.91 56.7,116.13 ; 70.16,105.87 70.77,105.87 71.23,105.42 71.68,105.42 71.81,105.55 72.31,105.55 72.38,105.51 72.47,105.41 72.7,105.41 arc(72.83,105.5) 72.98,105.53 74.27,105.53 GPU1.F23
  TOP w0.127: 70.16,105.87 70.14,105.89 69.26,105.89 68.81,106.34 68.63,106.34 68.42,106.14 68.26,106.14 68.06,106.33 68.06,106.5 68.27,106.7 68.27,106.88 68.09,107.06 67.91,107.06 67.7,106.86 67.54,106.86 67.35,107.05 67.35,107.22 67.55,107.42 67.55,107.6 66.65,108.5 66.47,108.5 66.36,108.38 66.18,108.38 66,108.56 66,108.74 66.11,108.86 66.11,109.04 65.82,109.33 65.82,111.6 v1(65.98,111.76) 66.1,111.88 66.37,111.88 66.78,112.3 66.78,115.29 61.74,120.33 57.78,120.33 55.77,118.32 55.77,117.76 55.77,117.76 55.77,117.36 56.57,116.56 56.57,116.26 56.7,116.13
MDA22: length 37.1
  TOP w0.102: 70.62,104.37 71,103.99 71.33,103.99 71.35,104.01 71.85,104.01 71.98,104.13 72.15,104.13 72.36,104.13 72.54,104.06 72.66,104.06 72.79,104.11 72.85,104.17 73.17,104.17 GPU1.D22
  TOP w0.127: MEM1.B8 58.01,116.94 58.39,117.32 58.39,117.82 58.17,118.05 57.77,118.05 57.65,118.17 57.65,118.42 58.03,118.8 60,118.8 64.29,114.51 64.29,113.34 64.17,113.21 63.37,113.21 63.24,113.09 63.24,112.83 63.37,112.71 64.17,112.71 64.29,112.58 64.29,112.33 64.17,112.2 63.37,112.2 63.24,112.07 63.24,111.82 63.37,111.69 64.17,111.69 64.29,111.56 64.29,111.31 64.17,111.18 63.37,111.18 63.24,111.06 63.24,110.8 63.37,110.67 64.14,110.67 64.27,110.55 64.27,110.25 64.14,110.13 63.31,110.13 63.1,109.91 63.1,108.95 63.89,108.16 v1(63.89,107.79) 63.89,107.17 64.45,106.6 64.45,106.42 64.41,106.37 64.41,106.19 64.59,106.01 64.77,106.01 64.81,106.06 64.99,106.06 65.17,105.88 65.17,105.7 65.12,105.65 65.12,105.47 65.3,105.29 65.48,105.29 65.53,105.34 65.71,105.34 65.89,105.16 65.89,104.98 65.78,104.87 65.78,104.54 65.94,104.37 70.62,104.37
MDA23: length 37.7
  TOP w0.102: 70.74,103.87 70.81,103.79 71.42,103.79 71.43,103.8 71.94,103.8 72.06,103.93 72.32,103.93 arc(72.4,103.87) 72.5,103.85 72.7,103.85 arc(72.74,103.86) 72.77,103.86 arc(72.83,103.89) 72.88,103.93 74.27,103.93 GPU1.F21
  TOP w0.127: MEM1.C8 58.28,116.08 58.66,116.46 59.34,116.46 59.43,116.37 59.91,116.37 60.1,116.57 60.55,116.57 61.03,117.05 61.21,117.05 61.5,116.75 61.5,116.57 61.18,116.24 61.18,116.06 61.46,115.78 61.64,115.78 62,116.14 62.18,116.14 63.59,114.72 v1(63.59,113.97) 62.76,113.14 62.76,108.4 62.88,108.28 63.18,108.28 63.3,108.15 63.3,107.89 63.18,107.77 62.88,107.77 62.76,107.64 62.76,107.39 62.88,107.26 63.43,107.26 63.54,107.15 63.54,106.88 63.42,106.75 62.88,106.75 62.76,106.62 62.76,104.31 63.04,104.03 63.38,104.03 63.51,104.16 63.51,105.47 63.63,105.59 63.89,105.59 64.01,105.47 64.01,104.16 64.14,104.03 64.39,104.03 64.52,104.16 64.52,104.83 64.65,104.96 64.9,104.96 65.03,104.83 65.03,104.16 65.16,104.03 69.54,104.03 69.55,104.04 70.56,104.04 70.74,103.87
MDA24: length 35.2
  TOP w0.127: GPU1.E21 73.8,103.48 v4(74.14,103.14) ; MEM1.G2 53.21,112.89 v4(53.61,113.29)
  L4 w0.165: v4(74.14,103.14) 73.51,103.77 73.51,105.39 72.14,106.77 72.14,107.59 70.89,108.84 69.41,108.84 69.11,109.14 69.11,110.86 68.56,111.41 68.56,111.84 62.53,117.87 59.22,117.87 59.21,117.88 58.58,117.88 58.01,118.45 56.33,118.45 54.65,116.76 54.65,116.47 54.06,115.88 54.06,113.73 v4(53.61,113.29)
  BOTTOM w0.127: v4(74.14,103.14) 74.06,103.23 73.41,103.23 v2(73.29,103.35)
MDA25: length 35.4
  TOP w0.127: MEM1.E3 v4(53.61,114.88) ; v4(73.91,102.58) 73.69,102.8 GPU1.D20
  L4 w0.165: v4(73.91,102.58) 74.33,102.58 74.63,102.87 74.63,104.02 74.53,104.12 74.53,106.11 71.21,109.43 70.43,109.43 70.01,109.85 70.01,110.51 68.94,111.59 68.94,112.17 68.28,112.84 64.39,116.73 62.36,118.75 58.95,118.75 58.95,118.75 58.58,118.75 58.58,118.75 56.26,118.75 53.61,116.1 v4(53.61,114.88)
  BOTTOM w0.127: v4(73.91,102.58) 73.39,102.06 v2(73.26,102.06)
MDA26: length 36.5
  TOP w0.127: GPU1.F19 73.96,101.36 v4(73.96,101.17) ; v4(54.66,113.16) 54.66,112.73 MEM1.H3
  L4 w0.165: v4(73.96,101.17) 72.93,102.2 72.93,103.89 71.07,105.75 71.07,106.09 68.61,108.55 68.61,110.82 68.18,111.25 68.18,111.54 62.16,117.56 58.13,117.56 57.51,118.18 56.44,118.18 55.05,116.79 55.05,116.29 54.46,115.7 54.46,115.11 54.37,115.03 54.37,114.66 54.66,114.37 v4(54.66,113.16)
  BOTTOM w0.127: v2(73.26,100.76) 73.55,100.76 v4(73.96,101.17)
MDA27: length 35.7
  TOP w0.127: GPU1.A19 72.18,102.02 71.16,102.02 71.16,102.02 70.81,102.02 70.44,101.65 70.19,101.65 v4(70.18,101.64) ; MEM1.F2 53.58,114.04 54.09,114.04 54.39,114.35 54.39,115.02 54.48,115.1 54.48,115.66 55.4,116.59 55.48,116.59 v4(55.49,116.6)
  L4 w0.165: v4(55.49,116.6) 55.73,116.84 57.88,116.84 58.27,117.23 61.8,117.23 67.49,111.54 67.49,111.4 68.13,110.76 68.13,108.34 70.58,105.88 70.58,105.66 71.73,104.5 71.73,103.15 71.94,102.95 72.22,102.95 72.42,102.75 72.42,102.39 72.24,102.21 70.9,102.21 70.33,101.65 70.19,101.65 v4(70.18,101.64)
  BOTTOM w0.127: v4(70.18,101.64) 70.18,102.03 v2(70.47,102.31)
MDA28: length 35.9
  TOP w0.102: GPU1.D18 73.4,101.49 73.22,101.67 72.06,101.67 71.92,101.81 71.29,101.81 v4(71.07,101.59)
  TOP w0.127: MEM1.H8 58.38,112.44 59.09,112.44 59.74,111.79 60.12,111.79 v4(60.27,111.94)
  L4 w0.165: v4(60.27,111.94) 60.62,111.59 60.97,111.59 61.41,111.14 61.41,109.85 63.46,107.81 63.46,107.57 63,107.12 63,106.88 63.24,106.65 63.47,106.65 63.93,107.11 64.16,107.11 64.39,106.87 64.39,106.64 64.09,106.33 64.09,106.1 64.32,105.87 64.56,105.87 64.86,106.17 65.09,106.17 65.61,105.65 65.61,105.27 65.45,105.11 64.64,105.11 64.47,104.94 64.47,104.61 64.64,104.45 65.88,104.45 66.05,104.28 66.05,103.95 65.88,103.78 64.58,103.78 64.45,103.64 64.45,103.26 64.58,103.12 65.88,103.12 66.05,102.96 66.05,102.63 65.88,102.46 64.36,102.46 64.19,102.3 64.19,101.95 64.36,101.79 66.06,101.79 66.93,100.93 69.32,100.93 69.6,101.2 70.69,101.2 v4(71.07,101.59)
  BOTTOM w0.127: v4(71.07,101.59) 71.07,101.6 71.61,102.13 v2(71.69,102.13)
MDA29: length 36.4
  TOP w0.102: v4(69.49,101.64) 68.88,101.03 68.88,100.85 69.09,100.64 69.27,100.64 69.8,101.17 71.28,101.17 71.52,100.93 72.33,100.93 72.35,100.92 72.43,100.91 72.43,100.9 72.45,100.9 72.45,100.89 72.46,100.89 72.52,100.87 73.69,100.87 73.83,100.73 74.27,100.73 GPU1.F17
  TOP w0.127: MEM1.H7 56.5,112.08 56.37,112.21 56.37,112.36 56.24,112.49 55.63,112.49 55.5,112.62 55.5,112.87 55.63,112.99 56.14,112.99 56.27,113.12 56.27,113.63 v4(56.01,113.88)
  L4 w0.165: v4(69.49,101.64) 69.49,101.64 69.04,101.19 68.45,101.19 68.28,101.36 68.28,101.79 68.12,101.96 67.79,101.96 67.62,101.79 67.62,101.49 67.46,101.33 67.07,101.33 66.52,101.88 66.52,102.85 66.72,103.05 66.72,103.52 66.52,103.73 66.52,104.17 66.72,104.37 66.72,104.84 66.52,105.05 66.52,105.43 63,108.94 63,109.83 62.77,110.07 62.53,110.07 62.28,109.82 62.05,109.82 61.86,110.01 61.86,111.09 61.86,111.28 60.76,112.38 60.08,112.38 59.55,111.84 58.94,111.84 58.58,112.2 58.07,112.2 57.92,112.05 57.03,112.05 56.83,112.25 56.83,112.58 56.56,112.84 56.23,112.84 56.01,113.06 v4(56.01,113.88)
MDA30: length 34.8
  TOP w0.102: GPU1.A17 72.09,100.51 70.31,100.51
  TOP w0.127: MEM1.F7 57.21,113.94 56.85,114.31 56.81,114.31 v4(56.62,114.49) ; 70.31,100.51 70.11,100.51 69.49,99.89 67.79,99.89 67.68,99.99 67.68,99.99 67.35,100.32 67.35,101.85 67.19,102.01 65.05,102.01 64.93,102.14 64.93,102.7 65.05,102.82 v4(67.75,102.82)
  L4 w0.165: v4(67.75,102.82) 68.15,103.22 68.15,105.94 66.34,107.75 66.34,108.54 63.77,111.11 63.17,111.11 61.08,113.2 61.08,113.58 61.27,113.77 61.27,114 60.98,114.29 60.75,114.29 60.35,113.89 59.68,113.89 59.15,114.42 58.56,114.42 58.4,114.26 58.4,113.88 58.23,113.72 57.9,113.72 57.74,113.88 57.74,114.26 57.57,114.42 57.2,114.42 57.12,114.5 56.62,114.5 v4(56.62,114.49)
MDA31: length 35.7
  TOP w0.102: GPU1.C17 72.86,100.54 72.7,100.54 72.37,100.69 72.35,100.71 72.3,100.72 72.28,100.73 71.35,100.73 71.24,100.85 69.95,100.85
  TOP w0.127: 69.95,100.85 69.44,100.33 67.82,100.33 67.7,100.46 67.7,101.48 67.86,101.64 v4(68.81,101.64) ; MEM1.F8 v4(58.41,113.28)
  L4 w0.165: v4(68.81,101.64) 68.79,101.67 68.79,102.09 68.52,102.36 67.55,102.36 67.19,102.73 67.19,103.54 67.35,103.71 67.61,103.71 67.77,103.87 67.77,104.21 67.61,104.37 67.35,104.37 67.19,104.53 67.19,104.86 67.35,105.03 67.61,105.03 67.77,105.19 67.77,105.79 67.5,106.05 67.24,106.05 67.03,105.84 66.79,105.84 66.42,106.21 66.42,106.45 66.65,106.68 66.65,106.86 66.36,107.16 66.13,107.16 65.91,106.94 65.67,106.94 65.44,107.17 65.44,107.41 65.95,107.92 65.95,108.15 65.72,108.38 65.48,108.38 64.97,107.88 64.74,107.88 64.51,108.11 64.51,108.34 65.14,108.98 65.14,109.2 64.9,109.45 64.68,109.45 64.04,108.81 63.81,108.81 63.57,109.04 63.57,109.28 64.18,109.89 64.18,110.12 63.92,110.38 63.67,110.38 63.51,110.22 63.18,110.22 62.87,110.52 62.44,110.52 62.24,110.72 62.24,111.48 61.07,112.65 59.84,112.65 59.51,112.32 59.03,112.32 58.41,112.94 v4(58.41,113.28)
  BOTTOM w0.127: v4(68.81,101.64) 68.81,101.71 v2(68.31,102.21)
MDA32: length 36.2
  TOP w0.102: v3(69.35,99.12) 69.35,99.17 70.44,100.26 71.35,100.26 71.37,100.28 71.85,100.28 72,100.14 72,100.14 72.07,100.07 72.28,100.07 72.38,100.12 72.38,100.12 72.41,100.13 72.68,100.13 72.69,100.13 72.84,100.1 72.85,100.08 72.88,100.07 73.14,100.07 73.15,100.08 73.48,100.08 GPU1.E17
  L4 w0.165: v3(69.35,99.12) 68.93,98.7 65.47,98.7 65.2,98.43 65.2,98.2 65.44,97.96 65.44,97.72 65.21,97.49 64.97,97.49 64.73,97.73 64.5,97.73 64.05,97.29 64.05,96.86 64.22,96.7 64.71,96.7 64.88,96.53 64.88,96.2 64.71,96.04 64.22,96.04 64.05,95.87 64.05,95.54 64.22,95.38 64.72,95.38 64.89,95.22 64.89,94.88 64.72,94.72 64.22,94.72 64.05,94.55 64.05,94.22 64.22,94.06 64.7,94.06 64.86,93.89 64.86,93.56 64.7,93.4 64.22,93.4 64.05,93.23 64.05,92.94 63.78,92.67 63.78,92.44 64.54,91.68 64.54,91.45 64.3,91.22 64.07,91.22 63.31,91.97 63.08,91.97 62.85,91.74 62.85,91.51 63.6,90.75 63.6,90.52 63.36,90.29 63.13,90.29 62.38,91.04 62.15,91.04 61.91,90.81 61.91,90.57 62.64,89.85 62.64,89.61 62.41,89.38 62.17,89.38 61.43,90.12 61.19,90.12 60.54,89.47 v4(60.16,89.47)
  BOTTOM w0.127: MEM4.F8 58.14,89.62 58.57,89.19 59.15,89.19 59.42,89.47 v4(60.16,89.47) ; v3(69.35,99.12) 69.1,99.37 v2(69.1,99.9)
MDA33: length 35.1
  TOP w0.102: GPU1.D16 72.98,99.8 72.78,99.89 72.65,99.93 72.47,99.93 72.34,99.87 72.3,99.86 71.99,99.86 71.79,100.06 70.58,100.06 70.35,99.82 v4(70.35,99.56)
  L4 w0.165: v3(59.35,91.76) 60,91.76 60.16,91.6 60.16,91.38 60.33,91.22 60.66,91.22 60.83,91.38 60.83,91.6 60.99,91.76 61.54,91.76 63.05,93.27 63.05,98.54 62.51,99.08 62.51,99.31 62.75,99.55 62.98,99.55 63.85,98.69 64.07,98.69 64.26,98.88 64.26,99.46 64.43,99.63 70.28,99.63 v4(70.35,99.56)
  BOTTOM w0.127: v3(59.35,91.76) 59.35,91.47 59.48,91.34 60,91.34 60.13,91.47 60.13,91.85 v2(60.91,92.64) 61.59,93.31 61.59,93.83 61.11,94.31 60.93,94.31 60.66,94.04 60.66,93.86 60.86,93.66 60.86,93.48 60.68,93.3 60.5,93.3 60.3,93.5 60.12,93.5 59.95,93.32 59.95,93.14 60.14,92.94 60.14,92.76 59.96,92.58 59.78,92.58 59.59,92.78 59.41,92.78 59.08,92.45 58.51,92.45 58.41,92.36 58.41,91.62 MEM4.H8
MDA34: length 36.7
  TOP w0.102: 71.42,99.13 74.27,99.13 GPU1.F15
  TOP w0.127: 71.42,99.13 v4(70.96,99.59)
  L4 w0.165: v4(70.96,99.59) 70.78,99.42 70.78,99.38 69.7,98.29 66.55,98.29 65.27,97 65.27,93.17 64.95,92.85 64.66,92.85 64.5,92.69 64.5,92.35 64.66,92.18 65.1,92.18 65.27,92.02 65.27,91.64 62.25,88.63 62.02,88.63 61.3,89.35 61.06,89.35 60.83,89.11 60.83,88.88 61.55,88.16 61.55,87.93 61.11,87.48 60.01,87.48 58.25,89.24 57.24,89.24 56.93,89.55 56.22,89.55 v4(56.05,89.72)
  BOTTOM w0.127: MEM4.F7 57.21,89.38 56.79,88.96 55.16,88.96 55.04,89.08 55.04,89.67 55.21,89.84 55.93,89.84 v4(56.05,89.72) ; v4(70.96,99.59) 70.95,99.59 70.95,99.29 v2(70.49,98.83)
MDA35: length 36.4
  TOP w0.127: v4(68.56,99.17) 67.12,99.17 66.74,99.55 66.74,101.35 66.62,101.48 64.95,101.48 64.83,101.35 64.83,100.99 64.95,100.87 65.97,100.87 66.1,100.74 66.1,99.09 66.63,98.56 69.7,98.56 69.97,98.83 71.81,98.83 71.84,98.8 GPU1.A15
  L4 w0.165: v4(56.65,90.62) 56.69,90.62 57.14,90.17 57.14,89.86 57.43,89.58 59.09,89.58 59.41,89.9 60.35,89.9 63.52,93.07 63.52,97.44 65.3,99.22 68.51,99.22 v4(68.56,99.17)
  BOTTOM w0.127: v2(68.69,98.37) 68.56,98.5 v4(68.56,99.17) ; v4(56.65,90.62) 56.65,90.68 57.2,91.22 MEM4.H7
MDA36: length 35.7
  TOP w0.127: GPU1.D14 73.65,98 v4(73.9,97.75)
  L4 w0.165: v4(73.9,97.75) 72.38,97.75 70.9,96.27 69.83,96.27 69.49,96.61 67.47,96.61 67.16,96.29 67.16,89.71 62.42,84.98 56.87,84.98 56.08,85.76 56.08,86.23 55.8,86.51 55.68,86.51 54.64,87.55 54.64,88.17 54.07,88.75 54.07,89.91 54.05,89.93 54.05,90.38 v4(53.61,90.82)
  BOTTOM w0.127: v4(73.9,97.75) v2(73.11,97.75) ; MEM4.H3 v4(53.61,90.82)
MDA37: length 35.3
  TOP w0.127: GPU1.F13 74.6,97.05 v4(74,96.45)
  L4 w0.165: v4(53.61,90.01) 52.73,89.13 52.73,88.32 53.25,87.8 53.25,87.43 53.25,87.43 53.25,87.1 56.79,83.56 63.52,83.56 69.6,89.64 70.39,89.64 73.02,92.27 73.02,95.47 v4(74,96.45)
  BOTTOM w0.127: v4(74,96.45) 74,96.42 v2(74.56,95.86) ; v4(53.61,90.01) 53.21,90.41 MEM4.G2
MDA38: length 35
  TOP w0.102: 70.13,97.11 70.5,97.11 70.5,97.11 71.04,97.11 71.14,97.21 71.98,97.21 72,97.2
  TOP w0.127: GPU1.A13 72,97.2 ; 70.13,97.11 68.73,95.7 68.06,95.7 v4(67.64,96.12) 67.64,96.12 v1(66.8,96.12)
  L4 w0.165: v4(55.62,86.07) 55.62,85.64 56.75,84.51 62.62,84.51 67.64,89.52 67.64,91.53 67.81,91.69 68.33,91.69 68.46,91.82 68.46,92.23 68.33,92.35 67.81,92.35 67.64,92.52 67.64,92.85 67.81,93.01 68.33,93.01 68.46,93.14 68.46,93.55 68.33,93.67 67.81,93.67 67.64,93.84 67.64,94.17 67.81,94.34 68.29,94.34 68.42,94.46 68.42,94.87 68.29,95 67.81,95 67.64,95.16 v4(67.64,96.12)
  BOTTOM w0.127: v4(55.62,86.07) 55.56,86.13 55.56,86.63 54.51,87.68 54.51,88.33 MEM4.E3
MDA39: length 35.2
  TOP w0.102: GPU1.C13 72.67,97.53 72.06,97.53 71.95,97.42 70.9,97.42 70.81,97.33 69.68,97.33
  TOP w0.127: v1(68.53,97.06) 68.46,96.98 v4(68.46,96.14) 68.49,96.14 69.68,97.33
  L4 w0.165: v4(53.62,89.22) 53.2,88.79 53.2,88.24 53.71,87.73 53.71,87.17 56.85,84.03 63.11,84.03 68.38,89.3 68.38,89.95 69.58,91.14 69.58,95.03 v4(68.46,96.14)
  BOTTOM w0.127: MEM4.F2 v4(53.62,89.22)
MDA40: length 36.8
  TOP w0.127: GPU1.E11 73.46,95.26 72.05,95.26 71.95,95.36 70.92,95.36 69.55,93.98 67.35,93.98 66.8,93.43 66.45,93.43 66.33,93.31 66.33,93.3 66.2,93.17 65.95,93.17 65.82,93.3 65.82,93.31 65.69,93.43 65.44,93.43 65.31,93.31 65.31,93.3 65.18,93.17 64.93,93.17 64.8,93.3 64.8,93.31 64.68,93.43 63.92,93.43 63.52,93.03 63.52,92.58 63.71,92.39 63.71,92.07 63.52,91.88 63.52,91.57 63.71,91.37 63.71,91.06 63.52,90.86 63.52,90.11 62.59,89.18 v1(62.59,87.45) 62.59,86.37 61.91,85.69 61.53,85.69 61.08,85.23 61.08,84.53 60.62,84.07 58.5,84.07 58.15,84.43 57.7,84.43 57.57,84.3 57.57,84.17 57.45,84.04 56.97,84.04 56.85,84.17 56.85,84.34 56.74,84.45 56.37,84.45 56.26,84.34 56.26,84.17 56.14,84.04 55.72,84.04 55.59,84.17 55.59,84.43 55.23,84.79 55.23,85.34 55.51,85.62 56.16,85.62 56.34,85.8 56.34,86.38 56.21,86.51 55.32,86.51 54.87,86.96 54.87,87.28 55.33,87.74 55.76,87.74 55.98,87.53 55.98,87.25 56.1,87.12 57.12,87.12 MEM2.C3
MDA41: length 36.4
  TOP w0.102: GPU1.A11 72.19,95.59 72.03,95.59 72.01,95.57 70.63,95.57 70.62,95.56
  TOP w0.127: 70.62,95.56 69.39,94.33 67.16,94.33 66.61,93.78 63.86,93.78 63.74,93.9 63.74,94.06 63.62,94.18 63.18,94.18 63.05,94.06 63.05,93.26 62.92,93.13 62.58,93.13 62.45,93.26 62.45,94.13 62.32,94.25 61.87,94.25 61.74,94.13 61.74,93.04 61.61,92.91 61.38,92.91 61.26,92.78 61.26,92.33 61.38,92.2 v1(61.99,92.2) 62.92,92.2 63.1,92.02 63.1,91.67 62.92,91.49 62.41,91.49 62.23,91.31 62.23,90.93 62.38,90.78 62.92,90.78 63.1,90.6 63.1,90.21 62.94,90.06 62.38,90.06 62.22,89.89 62.22,89.02 62.22,89.02 62.22,88.78 61.99,88.55 61.99,86.52 61.69,86.22 61.28,86.22 60.8,85.74 60.8,84.58 60.52,84.3 60.04,84.3 59.87,84.48 59.87,84.53 59.69,84.71 59.33,84.71 59.15,84.53 59.15,84.48 58.98,84.3 58.6,84.3 58.12,84.79 58.12,85.11 57.99,85.24 57.66,85.24 57.53,85.11 57.53,84.86 57.4,84.73 55.84,84.73 55.71,84.86 55.71,85.22 55.84,85.35 56.31,85.35 56.44,85.48 56.44,85.48 56.56,85.61 57.21,85.61 MEM2.A3
MDA42: length 36.2
  TOP w0.102: 70.31,95.76 70.34,95.79 71.92,95.79 72.06,95.93 72.31,95.93 72.36,95.91 72.67,95.6 GPU1.C11
  TOP w0.127: MEM2.A2 58.28,85.62 58.41,85.49 58.41,84.96 58.67,84.69 58.92,84.69 59.18,84.96 59.18,85.94 59.3,86.05 59.77,86.05 59.89,85.94 59.89,84.97 60.11,84.75 60.42,84.75 60.52,84.85 60.52,86.15 60.64,86.27 60.9,86.27 61.01,86.38 61.01,86.84 60.9,86.95 60.46,86.95 60.27,87.13 60.27,87.28 60.57,87.57 61.37,87.57 61.45,87.65 61.45,88.16 61.37,88.24 61.08,88.24 60.98,88.34 60.98,88.72 61.08,88.83 61.51,88.83 61.68,89 61.68,91.5 61.51,91.67 61.01,91.67 60.81,91.87 60.81,93.46 60.92,93.57 61.23,93.57 61.37,93.72 61.37,94.14 61.23,94.28 60.91,94.28 60.81,94.38 60.81,94.69 61.04,94.91 61.88,94.91 62.01,95.04 62.01,95.37 62.14,95.5 62.39,95.5 62.52,95.37 62.52,95.03 62.65,94.91 62.9,94.91 63.03,95.03 63.03,95.37 63.15,95.5 63.41,95.5 63.53,95.37 63.53,94.82 63.66,94.69 63.92,94.69 64.04,94.82 64.04,95.37 64.17,95.5 64.42,95.5 64.55,95.37 64.55,95.03 64.68,94.91 65.02,94.91 65.26,94.67 65.26,94.39 65.42,94.23 65.97,94.23 v1(66.1,94.35) 66.42,94.67 69.22,94.67 70.31,95.76
MDA43: length 36.9
  TOP w0.102: GPU1.F11 74.22,95.98 72.61,95.98 72.51,96.07 72.44,96.1 72.43,96.1 72.41,96.11 72.34,96.13 71.96,96.13 71.82,95.99 71.13,95.99 71.12,96.01 70.35,96.01
  TOP w0.127: 70.35,96.01 70.05,96.01 69.06,95.01 65.55,95.01 65.04,95.53 65.04,96.77 64.91,96.89 64.46,96.89 64.33,96.77 64.33,96 64.17,95.84 63.78,95.84 63.62,96 63.62,97 63.5,97.12 63.11,97.12 62.98,97 62.98,95.97 62.86,95.84 62.47,95.84 62.35,95.97 62.35,96.98 62.22,97.11 60.48,97.11 60.11,96.74 60.11,96.23 60.24,96.11 60.62,96.11 60.75,96.23 60.75,96.39 60.88,96.53 61.33,96.53 61.49,96.37 v1(61.49,96.06) 61.49,95.53 61.25,95.29 60.96,95.29 60.53,94.86 60.53,91.75 61.22,91.07 61.22,89.37 60.7,88.84 60.7,88.1 59.41,86.81 58.6,86.81 58.45,86.66 58.3,86.66 58.14,86.81 57.85,86.81 57.71,86.96 57.71,87.1 57.83,87.22 MEM2.C2
MDA44: length 35.8
  TOP w0.102: 70.25,93.62 70.5,93.87 70.69,93.87 70.94,94.12 72.08,94.12 GPU1.A9
  TOP w0.127: MEM2.A7 54.22,85.62 54.35,85.49 54.35,84.82 54.22,84.69 53.34,84.69 53.19,84.53 53.19,84.34 53.78,83.74 53.94,83.74 54.09,83.89 54.09,84.09 54.19,84.19 54.43,84.19 54.62,84.01 54.62,83.48 54.79,83.31 54.79,82.64 54.92,82.52 55.35,82.52 55.5,82.67 55.5,82.92 55.63,83.05 56.08,83.05 56.21,82.92 56.21,82.62 56.34,82.49 56.8,82.49 56.92,82.62 56.92,82.92 57.05,83.05 62.68,83.05 62.84,83.21 64.18,83.21 64.9,83.93 64.9,88.36 65.03,88.48 65.3,88.48 65.43,88.61 65.43,88.87 65.3,88.99 65.03,88.99 64.9,89.12 64.9,89.64 v1(65.16,89.9) 65.41,90.16 65.41,90.34 65.06,90.69 65.06,90.87 65.24,91.05 65.42,91.05 65.77,90.69 65.95,90.69 66.13,90.87 66.13,91.05 65.78,91.41 65.78,91.59 65.96,91.77 66.14,91.77 66.49,91.41 66.67,91.41 68.08,92.82 69.47,92.82 69.84,93.19 69.84,93.21 70.25,93.62
MDA45: length 36.2
  TOP w0.102: GPU1.C9 72.75,93.75 72.44,93.75 72.42,93.75 72.3,93.67 72.06,93.67 71.82,93.91 71.12,93.91 70.67,93.46 70.58,93.46 70.36,93.25
  TOP w0.127: 70.36,93.25 69.59,92.47 68.29,92.47 65.77,89.95 65.77,86.72 v1(65.47,86.43) 65.32,86.27 65.32,85.72 65.45,85.59 65.48,85.59 65.61,85.47 65.61,84.93 65.48,84.81 65.45,84.81 65.32,84.68 65.32,83.48 64.25,82.42 64.01,82.42 63.88,82.54 63.88,82.75 63.77,82.86 63.39,82.86 63.27,82.75 63.27,82.54 63.15,82.42 61.52,82.42 61.32,82.62 60.35,82.62 60.22,82.49 60.22,82.4 60.22,82.29 60.1,82.16 59.63,82.16 59.51,82.28 59.51,82.6 59.41,82.7 58.91,82.7 58.8,82.6 58.8,82.29 58.68,82.16 58.2,82.16 58.09,82.28 58.09,82.6 57.98,82.7 57.49,82.7 57.38,82.6 57.38,82.29 57.18,82.09 56.26,82.09 55.94,82.41 55.73,82.41 55.43,82.11 54.84,82.11 54.45,82.5 54.45,83.15 54.32,83.28 54.14,83.28 54.11,83.25 53.79,83.25 52.91,84.13 52.91,84.6 53.24,84.93 53.55,84.93 53.67,85.06 53.67,85.48 53.67,85.48 53.67,86.29 53.67,86.29 53.55,86.42 MEM2.B8
MDA46: length 37.3
  TOP w0.102: GPU1.F9 74.15,93.55 72.54,93.55 72.46,93.52 72.35,93.47 71.98,93.47 71.73,93.71 71.32,93.71 70.58,92.97
  TOP w0.127: 70.58,92.97 70.43,92.97 69.59,92.13 68.46,92.13 66.34,90.01 v1(66.34,88.45) 66.34,83.88 64.2,81.74 54.6,81.74 52.04,84.31 52.04,84.95 52.3,85.22 52.56,85.22 52.85,85.51 52.85,86.56 53.06,86.78 53.38,86.78 53.67,87.07 53.67,87.36 53.68,87.37 53.68,87.68 MEM2.D7
MDA47: length 35.8
  TOP w0.102: 70.77,92.77 70.9,92.9 71.98,92.9 72.02,92.91 72.02,92.92 72.09,92.93 72.39,92.93 72.43,92.91 72.52,92.87 73.07,92.87 GPU1.D8
  TOP w0.127: 70.77,92.77 70.06,92.05 69.84,92.05 69.58,91.79 68.62,91.79 66.93,90.1 66.93,83.95 64.38,81.4 53.98,81.4 v1(52.87,82.51) 51.57,83.81 51.57,86.16 52.2,86.78 52.62,86.78 53.06,87.22 MEM2.C8
MDA48: length 31.1
  TOP w0.127: GPU1.E7 73.34,91.94 71.37,91.94 71.06,91.63 71.06,91.63 70.84,91.41 v4(70.78,91.41) ; v4(55.44,90.37) 55.4,90.33 55.4,89.29 55.76,88.93 56.22,88.93 56.34,89.05 56.34,89.42 56.5,89.57 56.78,89.57 57.07,89.28 57.36,89.28 57.53,89.1 57.53,88.95 57.41,88.82 MEM2.E3
  L3 w0.165: v4(70.78,91.41) 70.78,91.78 70.93,91.93 72.08,91.93 72.21,92.05 72.21,92.34 72.08,92.47 70.91,92.47 70.78,92.6 70.78,92.84 70.52,93.11 62.18,93.11 62.05,92.98 62.05,92.14 61.92,92.02 61.5,92.02 61.37,92.14 61.37,93 61.24,93.13 60.86,93.13 60.74,93 60.74,92.62 60.61,92.5 57.28,92.5 56.86,92.08 56.86,91.73 56.63,91.5 56.26,91.5 55.95,91.18 55.95,90.87 v4(55.44,90.37)
MDA49: length 30.4
  TOP w0.127: v4(56.08,90.36) 55.91,90.52 55.91,91.19 56.09,91.37 56.34,91.37 56.49,91.51 56.49,92.14 56.6,92.24 56.76,92.24 56.87,92.14 56.87,91.56 MEM2.H3 ; GPU1.A7 72.03,92.23 71.15,92.23 70.75,91.83 70.54,91.83 v4(70.11,91.41)
  L3 w0.165: v4(56.08,90.36) 56.21,90.49 56.21,91.07 56.37,91.23 56.66,91.23 56.8,91.09 56.97,90.92 57.11,90.92 57.33,91.15 57.33,91.28 57.18,91.44 57.18,91.46 57.13,91.51 57.13,91.97 57.39,92.23 59.71,92.23 59.83,92.1 59.83,91.79 59.96,91.66 62.27,91.66 62.4,91.79 62.4,92.47 62.56,92.64 62.94,92.64 63.11,92.47 63.11,91.81 63.27,91.65 63.6,91.65 63.77,91.81 63.77,92.47 63.94,92.64 64.27,92.64 64.43,92.47 64.43,91.81 64.6,91.65 64.93,91.65 65.09,91.81 65.09,92.47 65.26,92.64 65.59,92.64 65.75,92.47 65.75,91.81 65.92,91.65 66.25,91.65 66.41,91.81 66.41,92.47 66.58,92.64 69.94,92.64 70.11,92.47 v4(70.11,91.41)
  BOTTOM w0.127: v2(69.5,91.85) 69.94,91.41 v4(70.11,91.41)
MDA50: length 32.4
  TOP w0.102: 71.87,92.54 72.03,92.7 72.13,92.73 72.29,92.73 72.35,92.72 GPU1.C7
  TOP w0.127: v4(68.92,91.34) 67.52,89.95 67.52,88.12 67.65,87.99 67.98,87.99 68.1,88.12 68.1,89.81 68.23,89.93 68.53,89.93 68.66,89.81 68.66,88.09 68.79,87.96 69.13,87.96 69.26,88.09 69.26,90.53 69.69,90.96 69.69,91.58 69.94,91.83 70.17,91.83 70.88,92.54 71.87,92.54 ; v4(60.03,90.76) 60.5,90.28 60.5,90.05 60.38,89.93 59.82,89.93 59.69,89.81 59.69,89.22 59.44,88.97 59.15,88.97 58.9,89.22 58.41,89.22 MEM2.F2
  L3 w0.165: v4(68.92,91.34) 67.61,91.34 66.02,89.76 61.62,89.76 60.61,90.76 v4(60.03,90.76)
  BOTTOM w0.127: v4(60.03,90.76) 60.69,91.41 v2(60.94,91.41)
MDA51: length 31.5
  TOP w0.127: v4(74.2,92) 74.6,92.4 GPU1.F7 ; MEM2.G2 58.2,90.42 58.42,90.63 v4(58.42,90.8)
  L3 w0.165: v4(58.42,90.8) 58.19,90.8 58.07,90.93 58.07,91.84 58.19,91.96 58.72,91.96 58.82,91.87 58.82,91.33 58.94,91.21 60.2,91.21 60.22,91.18 61.21,91.18 61.37,91.01 61.37,90.71 61.54,90.54 61.87,90.54 62.03,90.71 62.03,91.01 62.2,91.18 62.53,91.18 62.69,91.01 62.69,90.47 62.86,90.3 63.19,90.3 63.35,90.47 63.35,91.01 63.52,91.18 63.85,91.18 64.01,91.01 64.01,90.43 64.18,90.26 64.51,90.26 64.67,90.43 64.67,91.01 64.84,91.18 65.17,91.18 65.33,91.01 65.33,90.45 65.5,90.29 65.83,90.29 65.99,90.45 65.99,91.01 66.16,91.18 66.72,91.18 66.97,91.43 66.97,92 67.12,92.16 67.62,92.16 67.96,91.81 68.38,91.81 68.71,92.14 69.37,92.14 69.59,91.93 69.59,91.31 69.93,90.97 71.19,90.97 71.36,90.8 71.36,90.4 71.52,90.24 72.03,90.24 72.19,90.4 72.19,91.55 72.36,91.71 72.71,91.71 72.88,91.55 72.88,90.7 73.04,90.53 73.39,90.53 73.55,90.7 73.55,91.84 73.72,92 v4(74.2,92)
  BOTTOM w0.127: v4(74.2,92) 73.52,92 v2(73.2,92.32)
MDA52: length 28.8
  TOP w0.127: v4(51.72,91.5) 51.81,91.58 52.85,91.58 MEM2.H8 ; v4(71.02,89.62) 71.06,89.65 71.06,89.78 72.08,90.8 GPU1.A5
  L3 w0.165: v4(51.72,91.5) 52.96,91.5 53.13,91.66 53.13,91.81 53.29,91.98 53.78,91.98 53.94,91.81 53.94,91.43 54.11,91.27 54.64,91.27 54.99,90.91 54.99,89.71 55.55,89.15 56.19,89.15 57.5,87.84 58.77,87.84 58.95,88.02 58.95,88.25 59.07,88.38 59.59,88.38 59.72,88.25 59.72,87.94 60.48,87.18 62.01,87.18 62.07,87.24 66.81,87.24 67.47,87.91 67.47,89.39 68.04,89.95 69.14,89.95 69.47,89.62 v4(71.02,89.62)
MDA53: length 31.7
  TOP w0.127: v1(69.63,86.74) 69.63,86.86 v4(71.06,88.29) 71.06,88.62 71.57,89.13 71.85,89.13 72.61,89.89 72.61,90.13 72.87,90.39 73.39,90.39 GPU1.E5 ; MEM2.F7 54.01,89.43 54.92,88.52 v4(54.92,88.51)
  L3 w0.165: v4(71.06,88.29) 68.03,85.26 59.54,85.26 57.92,86.89 56.52,86.89 56.14,86.5 53.97,86.5 53.8,86.67 53.8,86.99 53.97,87.15 54.87,87.15 54.99,87.28 54.99,87.6 54.87,87.73 54.33,87.73 54.17,87.89 54.17,88.62 54.3,88.74 54.79,88.74 54.92,88.62 v4(54.92,88.51)
MDA54: length 29.8
  TOP w0.127: v4(71.72,88.69) 71.72,87.44 71.89,87.28 72.26,87.28 72.43,87.44 72.43,89.3 73,89.87 GPU1.C3 ; MEM2.H7 54.73,91.22 55,90.95 55,90.4 54.94,90.35 54.94,89.72 55.01,89.65 55.01,89.12 v4(55.67,88.46)
  L3 w0.165: v4(55.67,88.46) 55.67,88.24 56.69,87.23 58.11,87.23 59.6,85.73 67.83,85.73 68.1,86 68.1,86.24 67.73,86.6 67.73,86.83 67.97,87.07 68.2,87.07 68.56,86.7 68.8,86.7 69.03,86.94 69.03,87.17 68.76,87.44 68.76,87.68 68.99,87.91 69.22,87.91 69.5,87.64 69.73,87.64 70.9,88.8 71.61,88.8 v4(71.72,88.69)
MDA55: length 29.8
  TOP w0.127: GPU1.E1 73.8,88.77 72.99,87.96 v4(72.94,87.96) ; v4(52.81,90.01) 53.21,89.62 MEM2.F8
  L3 w0.165: v4(52.81,90.01) 52.81,88.24 53.25,87.8 53.25,86.08 54.04,85.29 55.46,85.29 56.06,85.88 56.06,85.99 56.68,86.62 57.67,86.62 59.51,84.78 68.27,84.78 71.45,87.96 v4(72.94,87.96)
  BOTTOM w0.127: v2(73.73,87.97) 72.94,87.97 v4(72.94,87.96)
MDA56: length 33.2
  TOP w0.127: v4(75.01,92) 75.4,92.39 GPU1.G7
  BOTTOM w0.127: MEM4.D7 57.6,87.64 58.97,87.64 59.18,87.85 60.12,87.85 62.2,89.93 62.38,89.93 63,89.32 63.18,89.32 63.36,89.49 63.36,89.67 62.74,90.29 62.74,90.47 62.92,90.65 63.1,90.65 63.69,90.06 63.87,90.06 64.05,90.24 64.05,90.42 63.46,91.01 63.46,91.19 63.64,91.37 63.82,91.37 64.47,90.72 64.65,90.72 64.83,90.9 64.83,91.08 64.18,91.73 64.18,91.91 64.65,92.37 65.46,92.37 65.64,92.19 65.64,91.43 65.77,91.3 66.02,91.3 66.15,91.43 66.15,92.47 66.28,92.6 66.53,92.6 66.66,92.47 66.66,91.43 66.78,91.3 67.04,91.3 67.16,91.43 67.16,92.45 67.29,92.57 67.55,92.57 67.67,92.45 67.67,91.43 67.8,91.3 68.05,91.3 68.18,91.43 68.18,92.25 68.31,92.37 71.07,92.37 v2(71.08,92.38) 71.08,92.37 71.59,92.37 72.41,91.56 74.57,91.56 v4(75.01,92)
MDA57: length 32.4
  TOP w0.127: GPU1.G6 75.02,91.22 v4(75.02,91.22)
  BOTTOM w0.127: v4(75.02,91.22) 74.99,91.19 74.99,91.15 74.54,90.7 v2(71.13,90.7) 68.95,90.7 68.83,90.57 68.83,89.43 68.7,89.3 68.45,89.3 68.32,89.43 68.32,90.83 68.19,90.96 67.94,90.96 67.81,90.83 67.81,89.43 67.68,89.3 67.43,89.3 67.3,89.43 67.3,90.81 67.18,90.94 66.92,90.94 66.79,90.81 66.79,89.43 66.67,89.3 66.41,89.3 66.29,89.43 66.29,90.44 66.12,90.61 65.11,90.61 64.86,90.36 64.86,90.18 65.43,89.61 65.43,89.43 65.25,89.25 65.07,89.25 64.5,89.82 64.32,89.82 64.14,89.64 64.14,89.46 64.59,89.02 64.59,88.84 64.41,88.66 64.23,88.66 63.78,89.11 63.6,89.11 63.42,88.93 63.42,88.75 63.77,88.4 63.77,88.22 63.59,88.04 63.41,88.04 63.07,88.39 62.89,88.39 62.58,88.08 60.84,88.08 60.25,87.5 60.07,87.5 59.43,86.85 58.38,86.85 MEM4.C8
MDA58: length 31.2
  TOP w0.127: GPU1.G1 75.2,89 75.2,88.61 75.03,88.44 75.03,87.23 v1(75.57,86.69) 75.85,86.42 v4(76.48,86.42)
  BOTTOM w0.127: MEM4.A2 53.21,85.35 53.66,84.91 53.66,84.6 56.73,81.52 66.95,81.52 69.39,83.96 v2(73.57,83.96) 74.03,83.96 v4(76.48,86.42)
MDA59: length 31.7
  TOP w0.127: GPU1.G3 74.97,89.57 74.97,88.71 74.56,88.29 v4(74.56,88.27)
  BOTTOM w0.127: MEM4.A7 57.58,85.25 60.08,85.25 60.33,85.51 60.59,85.51 60.69,85.4 60.69,84.78 60.81,84.66 61.29,84.66 61.41,84.78 61.41,85.76 62.39,86.74 v2(63.32,86.74) 64.44,86.74 64.6,86.9 65.05,86.9 65.31,86.64 65.49,86.64 65.77,86.93 65.77,87.11 65.25,87.63 65.25,87.81 65.48,88.04 65.66,88.04 66.3,87.4 66.3,87.39 66.43,87.27 66.68,87.27 66.81,87.39 66.81,87.58 66.94,87.7 68.36,87.7 68.49,87.58 68.49,87.39 68.62,87.27 68.87,87.27 69,87.39 69,88.4 69.12,88.52 69.38,88.52 69.5,88.4 69.5,87.39 69.63,87.27 69.89,87.27 70.01,87.39 70.01,88.38 70.14,88.51 70.39,88.51 70.52,88.38 70.52,87.39 70.65,87.27 70.9,87.27 71.03,87.39 71.03,87.58 71.16,87.7 71.73,87.7 71.85,87.59 71.85,87.42 71.98,87.29 72.24,87.29 72.37,87.42 72.37,88.88 72.6,89.11 73.72,89.11 v4(74.56,88.27)
MDA60: length 33.9
  TOP w0.127: GPU1.J6 77,91.56 77.41,91.15 v4(77.43,91.15)
  BOTTOM w0.127: v4(77.43,91.15) 77.43,90.32 77.26,90.15 76.7,90.15 76.57,90.02 76.57,89.86 76.45,89.73 76.19,89.73 76.07,89.86 76.07,90.76 75.94,90.89 75.68,90.89 75.56,90.76 75.56,89.84 75.43,89.72 75.18,89.72 75.05,89.84 75.05,90.11 74.92,90.24 74.67,90.24 74.54,90.11 74.54,89.82 74.41,89.69 74.16,89.69 74.03,89.82 74.03,90.02 73.91,90.15 70.96,90.15 70.57,89.75 70.57,89.1 70.35,88.88 70.12,88.88 70,89.01 70,89.59 69.87,89.72 69.62,89.72 69.49,89.59 69.49,89.01 69.36,88.88 68.56,88.88 68.43,88.75 68.43,88.19 68.3,88.07 68.05,88.07 67.92,88.19 67.92,88.75 67.8,88.88 67.54,88.88 67.42,88.75 67.42,88.19 67.29,88.07 67.03,88.07 66.91,88.19 66.91,88.75 66.78,88.88 66.53,88.88 66.4,88.75 66.4,88.31 66.27,88.18 66.02,88.18 65.89,88.31 65.89,88.75 65.76,88.88 65.14,88.88 64.71,88.44 v2(64.71,88.02) 64.71,87.54 64.44,87.27 63.94,87.27 63.81,87.4 63.81,87.5 63.68,87.62 63.02,87.62 62.89,87.5 62.89,87.22 62.76,87.09 62.11,87.09 61.99,87.22 61.99,87.62 61.89,87.72 60.93,87.72 60.28,87.08 60.28,86.43 59.91,86.05 58.38,86.05 MEM4.B8
MDA61: length 32.6
  TOP w0.127: GPU1.J1 77.12,89.08 v4(77.12,88.49)
  BOTTOM w0.127: v4(77.12,88.49) 77.12,87.54 76.73,87.15 76.28,87.15 74.45,85.32 69.19,85.32 68.89,85.02 68.77,85.02 67.18,83.43 66.66,83.43 66.53,83.3 66.53,82.68 66.41,82.55 66.15,82.55 66.03,82.68 66.03,83.3 65.9,83.43 65.64,83.43 65.52,83.3 65.52,83.02 65.39,82.9 65.14,82.9 65.01,83.02 65.01,83.3 64.88,83.43 63.52,83.43 62.68,82.59 59.05,82.59 v2(59.04,82.61) 59.03,82.59 57.04,82.59 54.47,85.17 54.47,86.48 54.13,86.81 53.62,86.81 MEM4.C2
MDA62: length 32.5
  TOP w0.127: GPU1.J3 77,90.04 76.79,90.25 76.54,90.25 76.38,90.1 76.38,89.91 76.55,89.74 76.55,89.01 76.7,88.87 v4(76.7,87.71)
  BOTTOM w0.127: v4(76.7,87.71) 76.37,87.38 76.19,87.38 74.51,85.7 68.61,85.7 v2(67.16,84.25) 66.68,83.77 63.31,83.77 62.6,83.07 59.43,83.07 59.31,83.2 59.31,83.67 59.18,83.8 58.92,83.8 58.8,83.67 58.8,83.2 58.67,83.07 58.42,83.07 58.29,83.2 58.29,83.66 58.16,83.79 57.91,83.79 57.78,83.66 57.78,83.2 57.65,83.07 57.31,83.07 54.73,85.66 54.73,86.67 54.17,87.22 MEM4.C3
MDA63: length 33.2
  TOP w0.127: v4(78.05,87.73) 77.96,87.81 77.96,87.81 77.63,88.14 77.63,88.41 77.59,88.44 77.59,88.65 77.43,88.81 77.43,90.37 GPU1.J5
  BOTTOM w0.127: v4(78.05,87.73) 77.18,86.87 76.33,86.87 74.15,84.69 v2(71.27,84.69) 69.3,84.69 69.11,84.5 69.09,84.5 66.65,82.06 64.31,82.06 64.18,82.19 64.18,82.85 64.06,82.97 63.8,82.97 63.67,82.85 63.67,82.19 63.55,82.06 56.99,82.06 54.01,85.03 MEM4.A3
MDAT: length 5
  TOP w0.102: U109.79 136.21,48.12 135.57,47.47 135.57,47.46 135.56,47.45 135.56,45.61 v1(135.52,45.57) 135.03,45.09 RN3.2
ME_CNTL: length 114.2
  TOP w0.102: v3(141.36,62.1) 141.36,62.53 140.61,63.27 U109.7 ; R80254.1 139.92,86.4 v3(142.65,89.13)
  L3 w0.127: v3(107.58,113.54) 106.38,112.35 106.38,109.4 107.08,108.7 117.41,108.7 118.64,107.47 126.22,107.47 128.1,109.35 138.03,109.35 140.11,107.26 140.11,102.51 140.88,101.75 140.88,101.38 141.35,100.91 141.35,100.2 142.97,98.57 142.97,89.45 v3(142.65,89.13) ; v3(141.36,62.1) 142.31,63.06 142.31,68.16 144.53,70.38 144.53,73.79 145.68,74.93 145.68,84.4 148.98,87.71 v3(148.98,88.62)
  L4 w0.127: v3(142.65,89.13) 142.68,89.13 143.19,88.62 v3(148.98,88.62)
  BOTTOM w0.102: R1836.2 107.16,121.28 106.69,120.81 v2(106.69,120.27) 106.54,120.12 106.54,116.86 107.58,115.82 v3(107.58,113.54)
ME_CNTL1: length 5.7
  BOTTOM w0.152: R1836.1 109.19,121.79 v2(110.37,121.79) 112.84,121.79 Q9644.B
MEM_CALRP0: length 4.7
  TOP w0.102: GPU1.K25 78.13,107.13 v4(78.27,107.13)
  BOTTOM w0.102: v2(77.55,106.48) 78.21,107.13 v4(78.27,107.13) 79.38,108.25 79.38,109.26 R80081.2
MEM_RST: length 98.2
  TOP w0.102: R1204.2 84.42,77.34 R1891.2 v3(85.25,77.98) ; MEM2.T2 58.96,98.57 58.96,101.92 58.72,102.16 57.46,102.16 57.1,101.8 56.74,101.8 56.05,102.48 55.69,102.48 55.31,102.1 v3(55.31,101.58) 54.56,101.58 54.28,101.3 51.04,101.3 50.83,101.09 v3(50.45,101.09) 50.45,101.6 50.71,101.86 50.71,102.43 52.16,103.87 52.16,104.63 MEM1.T2
  L3 w0.127: v3(50.45,101.09) 48.01,101.09 46.55,99.63 46.55,91.07 46.96,90.66 46.96,88.24 51.6,83.6 68.35,83.6 69.38,84.63 82.38,84.63 v3(82.84,85.09)
  BOTTOM w0.102: v3(85.25,77.98) 84.36,78.87 84.36,83.57 v3(82.84,85.09) ; MEM4.T2 53.21,99.99 v2(53.39,100.16) 53.8,100.58 54.31,100.58 v3(55.31,101.58) 55.45,101.72 55.45,102.25 55.69,102.48 55.98,102.48 56.11,102.62 58.36,102.62 59.15,103.41 59.15,104.96 58.81,105.3 58.62,105.3 58.24,105.68 MEM3.T2
MIC2-L: length 4.1
  TOP w0.203: C139.1 160.36,82.68 161.07,81.97 161.07,81.13 v1(160.76,80.82) 160.79,80.79 U6.47
MIC2-L-1: length 12.8
  TOP w0.203: v3(160.18,85.12) 159.93,84.86 C139.2 ; R225.1 v3(169.83,83.95)
  L3 w0.203: v3(160.18,85.12) 160.79,84.51 169.27,84.51 v3(169.83,83.95)
  BOTTOM w0.203: v2(160.99,85.12) v3(160.18,85.12)
MIC2-R: length 5.5
  TOP w0.203: C138.1 159.29,82.04 160.15,82.04 v3(160.46,81.74) 160.15,81.43 160.15,80.29 160.39,80.05 U6.48
  BOTTOM w0.203: v2(159.65,81.74) v3(160.46,81.74)
MIC2-R-1: length 25.4
  TOP w0.203: v3(167.17,73.79) 167.17,73.34 R627.1 ; v3(159.16,85.09) 159.14,85.09 158.66,84.6 C138.2
  L3 w0.203: v3(159.16,85.09) 160.23,84.02 166.83,84.02 167.55,83.31 168.26,83.31 169.58,82 169.58,74.68 168.69,73.79 v3(167.17,73.79)
  BOTTOM w0.203: v2(158.53,85.6) 158.55,85.6 159.06,85.09 v3(159.16,85.09)
MIC2-VREFO-L: length 21.3
  TOP w0.203: U6.1 159.57,79.23 v3(159.42,79.38) ; R223.1 v3(169.83,84.96)
  L3 w0.203: v3(169.83,84.96) 169.71,85.09 162.97,85.09 161.83,86.23 160.43,86.23 159.8,85.6 158.95,85.6 158.66,85.3 158.66,82.04 159.93,80.77 159.93,79.88 v3(159.42,79.38)
  BOTTOM w0.203: v3(159.42,79.38) v2(160.33,79.38)
MIC2-VREFO-R: length 4.5
  TOP w0.203: R262.1 167.9,74.64 v3(167.9,75.36) 167.9,75.67 167.67,75.9 167.32,76.25 U6.30
  BOTTOM w0.203: v2(167.9,74.52) v3(167.9,75.36)
MIC-CAP: length 4.9
  TOP w0.203: 165.62,78.97 U6.36
  TOP w0.254: 165.62,78.97 v3(166.53,79.88) 166.66,80.01 168.05,80.01 C154.1
  BOTTOM w0.254: v2(167.17,80.47) 166.58,79.88 v3(166.53,79.88)
MINI_POWER_CTRL: length 180
  TOP w0.102: v3(165.79,205.87) 165.29,206.38 R15.2 ; U109.55 129.89,54.17 130.08,54.36 130.08,54.48 130.35,54.75 130.89,54.75 131.22,54.42 v3(131.22,54.1)
  L3 w0.127: v3(131.22,54.1) 134.65,57.53 135.93,57.53 141.3,62.89 141.3,67.68 143.76,70.15 143.76,74.31 145.3,75.85 145.3,87.34 148.79,90.83 148.79,102.27 151.33,104.81 151.33,106.85 v3(152.05,107.57)
  BOTTOM w0.102: v3(152.05,107.57) 149.4,110.22 149.4,114.51 151.63,116.74 160.04,116.74 164.02,120.71 164.02,147.9 166.38,150.26 v2(166.38,203.94) 166.38,205.29 v3(165.79,205.87) ; v3(131.22,54.1) 131.66,53.67 RN6.4
MLPS_EN#: length 13.5
  TOP w0.102: GPU1.R5 81.47,90.47 81.47,88.62 83.76,86.33 85.6,86.33 86.84,87.58 89.16,87.58 89.69,87.05 v1(89.72,87.05) 89.72,86.19 R1882.1
MODEL_ID_DET: length 4.2
  TOP w0.102: U4101.50 90.52,52.58 89.58,51.64 R79722.1 89.5,50.69 v1(89.52,50.67) 89.59,50.6 89.59,49.75 R79723.2
MPCIE_DISABLE_N: length 220.9
  TOP w0.102: v3(130.46,54.1) 130.13,53.77 U109.56 ; v3(163.48,207.77) 160.18,211.07 155.99,211.07 155.81,211.25 155.8,211.25 155.53,211.52 155.53,211.53 147.33,219.74 131.12,219.74 129.19,217.81 R1620.1
  L3 w0.127: v3(130.46,54.1) 134.25,57.89 135.93,57.89 141,62.96 141,67.93 143.5,70.43 143.5,74.42 144.1,75.02 144.1,87.4 145.45,88.75 145.45,95.76 v3(147.48,97.79)
  BOTTOM w0.102: RN6.3 131.55,53.01 v3(130.46,54.1) ; v3(163.48,207.77) 163.23,207.52 v2(163.23,205.99) 163.23,201.78 163.58,201.42 163.58,163.53 164.46,162.65 164.46,151.04 161.77,148.35 161.77,144.61 161.02,143.86 161.02,123.16 156.6,118.75 150.94,118.75 146.79,114.6 146.79,103.11 148.37,101.53 148.37,98.68 v3(147.48,97.79)
MPV18: length 21.9
  TOP w0.381: v4(78.25,92.82) 78.33,92.82 78.71,93.2 GPU1.L8
  TOP w0.508: L50.2 75.79,82.49 v3(76.11,82.8)
  BOTTOM w0.508: v3(76.11,82.8) 76.11,82.55 77.5,81.15 81.31,81.15 81.82,81.66 81.82,84.2 80.61,85.41 C786.1 C790.1 C791.1 80.4,90.26 80.4,91.52 v2(79.54,92.38) 79.09,92.82 v4(78.25,92.82)
MS_INS#: length 4.6
  BOTTOM w0.102: U14.31 175.79,148.05 176.06,148.32 177.82,148.32 178.47,148.97 TP205.1
MVREFDA: length 8.3
  TOP w0.356: v4(78.31,107.88) 78.29,107.9 78.1,107.9 GPU1.K26
  TOP w0.508: R1890.2 78.16,114.39 C760.1 78.48,113.39 v3(78.58,113.28)
  BOTTOM w0.508: v3(78.58,113.28) R1888.1 v2(78.58,110.57) 78.58,109.59 78.85,109.33 78.85,108.41 v4(78.31,107.88)
MVREFSA: length 14.4
  TOP w0.356: GPU1.J26 77,107.59 77.35,107.24 v4(77.4,107.19)
  TOP w0.508: v3(76.36,115.64) 76.95,115.05 R1200.2
  BOTTOM w0.305: 74.74,110.34 77.41,110.34 77.92,109.83 77.92,109.33 76.89,108.3 76.89,107.7 v4(77.4,107.19)
  BOTTOM w0.508: v3(76.36,115.64) 75.15,114.43 C761.1 R1889.1 75.15,112.85 74.47,112.16 74.47,110.61 v2(74.58,110.49) 74.59,110.49 74.74,110.34
NGFF_ALERT#: length 267.4
  TOP w0.089: 75.25,144.07 75.64,144.45 75.64,144.82 75.6,144.92 75.6,145.12 75.66,145.25 75.66,145.46 CPU1.H2
  TOP w0.102: v3(164.5,209.68) 161.32,212.85 155.89,212.85 147.66,221.08 129.42,221.08 128.05,219.71 R1717.1 ; 75.25,144.07 74.89,144.07 v3(73.06,142.24) 73.06,141.54 R1617.1
  L4 w0.127: v3(73.06,142.24) 73.96,141.34 73.96,139.04 75.3,137.69 75.3,135.58 76.57,134.31 76.57,132.45 85.71,123.32 86.12,123.32 87.61,121.84 112.37,121.84 120.6,113.6 120.6,109.85 121.56,108.89 134.35,108.89 135.07,108.17 145.11,108.17 v3(149.26,104.01)
  BOTTOM w0.102: v3(149.26,104.01) 148.69,104.58 148.69,114.8 151.39,117.5 159.58,117.5 163,120.92 163,147.89 165.67,150.56 165.67,200.3 164.73,201.24 164.73,203.99 164.96,204.22 v2(164.96,208.71) 164.96,209.22 v3(164.5,209.68)
NGFF_ALERT_N: length 6
  TOP w0.102: NGFF1.62 119.25,220 120.16,220.9 121.8,220.9 v1(121.88,220.83) 122.99,219.71 R1717.2
NGFF_BT_DISABLE: length 248
  TOP w0.102: R1621.1 129.07,217.3 130.97,219.2 146.95,219.2 v1(150.07,216.08) 155.41,210.74 159.49,210.74 v3(162.47,207.77) ; CPU1.W4 81.6,146.64 v4(81.25,146.98)
  L4 w0.127: v4(81.25,146.98) 81.25,146.88 79.07,144.69 79.07,133.48 86.74,125.81 87.71,125.81 88.08,125.44 111.21,125.44 122.33,114.32 122.33,112.68 122.88,112.14 147.67,112.14 161.64,126.11 163.62,126.11 166.38,128.86 166.38,156.24 162.97,159.64 162.97,202.69 164.5,204.22 165.64,204.22 166.28,204.85 166.28,206.25 165.9,206.63 163.61,206.63 v3(162.47,207.77)
NGFF_CLKREQ0_N: length 6.5
  TOP w0.102: NGFF1.53 109.71,217.75 108.67,218.8 108.14,218.8 108.12,218.82 108.11,218.82 107.91,219.02 107.91,219.03 107.75,219.18 107.75,220.02 v1(107.07,220.7) 106.45,221.32 R1931.1
NGFF_CLKREQ0_NGFF#: length 43.3
  TOP w0.102: Q1229.S 143.64,224.89 R1932.2 v1(141.94,224.98) 141.5,225.42 108.12,225.42 106.03,223.33 R1931.2
NGFF_CLKREQ1_N: length 8.7
  TOP w0.102: v1(125.79,221.44) 125.79,221.42 125.45,221.08 R1925.2 123.22,220.34 122.07,221.5 NGFF1.68
NGFF_CLKREQ1_N_TP: length 1.4
  TOP w0.102: R1925.1 126.59,220.6 TP208.1
NGFF_DETECT_PCIE: length 224.3
  TOP w0.102: v3(156.24,215.01) 156.83,215.6 156.83,216.31 147.59,225.54 147.48,225.65 108.02,225.65 105.57,223.2 105.57,220.79 R1155.2 ; R80219.1 99.98,138.52 v3(99.5,139) 99.5,139.98 97.28,142.19 97.28,143.98 95.51,145.76 95.51,147.21 94.33,148.39 CPU1.BB7
  L3 w0.127: v3(158.4,180.47) 157.13,180.47 156.5,179.83 156.5,162.94 157.45,161.99 157.45,130.75 155.5,128.8 147.07,128.8 146.76,128.49 131.26,128.49 130.97,128.78 111.54,128.78 109.63,130.68 108.62,130.68 100.3,139 v3(99.5,139)
  BOTTOM w0.102: v3(158.4,180.47) 157.44,181.43 157.44,190.51 156.62,191.32 v2(156.62,202.95) 156.62,205.16 156.98,205.52 156.98,211.86 155.86,212.98 155.86,214.63 v3(156.24,215.01)
NGFF_DETECT_PCIE_C: length 6.4
  TOP w0.102: R1155.1 106.19,219.61 106.84,219.61 v1(107.04,219.41) 106.9,219.27 R1709.2 107.81,218.44 107.91,218.34 107.92,218.34 108.12,218.14 108.65,218.14 109.53,217.25 NGFF1.51
NGFF_DETECT_USB: length 238.2
  TOP w0.102: v3(143.92,199.52) 143.92,199.65 142.53,201.04 v1(120.51,201.04) R1154.2 ; CPU1.U6 81.06,147.41 v4(81.29,147.64)
  L4 w0.127: v4(81.29,147.64) 81.67,147.25 81.67,146.77 79.32,144.41 79.32,133.59 86.85,126.06 88.07,126.06 88.44,125.69 111.32,125.69 122.59,114.42 122.59,112.79 122.98,112.39 147.57,112.39 161.54,126.36 163.52,126.36 166.12,128.97 166.12,156.11 162.72,159.51 162.72,197.23 158.78,201.17 145.58,201.17 v3(143.92,199.52)
NGFF_DETECT_USB_C: length 10.9
  TOP w0.102: R1154.1 115.54,199.78 115.27,199.51 v1(115.04,199.51) 114.77,199.51 114.4,199.89 R1209.2 114.4,204.03 113.67,204.75 NGFF1.1
NGFF_PCIE0_RXN: length 3.9
  TOP w0.102: R1712.1 107.3,214.99 108.6,214.99 108.72,215.11 109.36,215.11 109.5,215.25 NGFF1.43
NGFF_PCIE0_RXP: length 4.4
  TOP w0.102: 107.98,214.78 107.3,214.78 R1711.1 ; 107.98,214.78 108.69,214.78 108.8,214.89 109.36,214.89 109.5,214.75 NGFF1.41 ; 107.98,214.78 v1(107.98,214.35)
NGFF_PCIE0_TXN: length 4.2
  TOP w0.102: NGFF1.37 109.5,213.75 109.36,213.61 108.28,213.61 107.63,212.96 107.3,212.96 R1714.1
NGFF_PCIE0_TXP: length 4.6
  TOP w0.102: v1(108.39,212.83) 108.1,213.12 ; 108.1,213.12 108.37,213.39 109.36,213.39 109.5,213.25 NGFF1.35 ; 108.1,213.12 107.72,212.74 107.3,212.74 R1713.1
NGFF_PCIE1_RXN: length 4
  TOP w0.102: NGFF1.67 109.5,221.25 109.36,221.11 109.05,221.11 108.77,221.39 107.83,221.39 107.73,221.49 107.73,221.87 107.86,222 TP82.1
NGFF_PCIE1_RXP: length 4.3
  TOP w0.102: TP81.1 107.26,222 107.51,221.74 107.51,221.4 107.74,221.17 108.68,221.17 108.96,220.89 109.36,220.89 109.5,220.75 NGFF1.65
NGFF_PCIE1_TXN: length 2.8
  TOP w0.102: NGFF1.61 109.5,219.75 109.36,219.61 109.23,219.61 108.87,219.96 108.78,220.05 108.63,220.05 108.36,220.32 TP80.1
NGFF_PCIE1_TXP: length 2.9
  TOP w0.102: NGFF1.59 109.5,219.25 109.36,219.39 109.14,219.39 108.72,219.81 108.69,219.84 108.49,219.84 108.36,219.71 TP79.1
NGFF_PEWAKE0_N: length 16
  TOP w0.102: R1719.1 R1718.2 122.49,222.03 v1(122.46,222.03) 122.45,222.05 118.47,222.05 NGFF1.70 118.42,222 116.37,222 112.62,218.25 NGFF1.55
NGFF_POWER_CTRL_1: length 13.7
  TOP w0.102: v3(155.99,211.71) 160.31,211.71 163.94,208.08 163.94,207.58 163.93,207.57 R15.1
  BOTTOM w0.102: v3(155.99,211.71) v2(155.13,211.71) 154.78,211.37 Q3.G
NGFF_POWER_CTRL_V2: length 5.4
  BOTTOM w0.102: R1716.1 C864.1 v2(151.82,206.88) 150.52,208.18 Q128.B
NGFF_REFCLKN0: length 4.6
  TOP w0.102: NGFF1.49 109.5,216.75 109.36,216.61 108.42,216.61 108.08,216.94 ; v1(108.39,217.25) 108.08,216.94 ; 108.08,216.94 108,217.02 107.52,217.02 107.42,217.13 107.42,217.32 107.32,217.42 R23.1
NGFF_REFCLKN1: length 4
  TOP w0.102: NGFF1.73 109.5,222.75 109.36,222.61 109.07,222.61 108.8,222.88 107.86,222.88 107.73,223.01 107.73,223.29 107.96,223.52 TP84.1
NGFF_REFCLKP0: length 4.6
  TOP w0.102: 108.69,216.39 108.33,216.39 107.91,216.81 107.52,216.81 107.42,216.71 107.42,216.51 107.32,216.41 R22.1 ; 108.69,216.39 v1(108.69,215.98) ; 108.69,216.39 109.36,216.39 109.5,216.25 NGFF1.47
NGFF_REFCLKP1: length 4.4
  TOP w0.102: NGFF1.71 109.5,222.25 109.36,222.39 108.98,222.39 108.71,222.67 107.77,222.67 107.51,222.92 107.51,223.35 107.35,223.52 TP83.1
NGFF_W_DISABLE1_N: length 7.4
  TOP w0.102: R1620.2 123.22,217.81 122.46,218.57 120.75,218.57 120.74,218.56 v1(120.68,218.56) 120.62,218.5 NGFF1.56
NGFF_W_DISABLE2_N: length 5.4
  TOP w0.102: R1621.2 123.35,217.3 122.65,218 122.25,218 v1(122.24,217.99) 122.24,218 NGFF1.54
NGFFCLK_REQ_N: length 184.6
  TOP w0.102: v3(156.37,215.9) 148.37,223.9 Q1229.D
  L4 w0.127: v3(152.18,196.09) 160.82,196.09 162.47,194.44 162.47,159.26 164.82,156.91 164.82,132.42 149.39,116.99 140.9,116.99 140.58,116.99 137.51,113.92 137.43,113.92 137.43,113.92 133.57,113.92 133.57,113.92 127.53,113.92 111.27,130.18 v3(108.62,130.18)
  BOTTOM w0.102: v3(152.18,196.09) 152.18,197.61 v2(155.74,201.17) 155.74,204.6 156.75,205.61 156.75,211.71 155.63,212.83 155.63,215.16 v3(156.37,215.9) ; v3(108.62,130.18) 107.86,129.41 107.41,129.41 R79760.2 R80066.2
OCS_48M_1: length 3.8
  TOP w0.254: OSC2.4 114.77,61.72 v3(114.76,61.72) L9525.2
  BOTTOM w0.254: v2(114.76,62.53) v3(114.76,61.72)
OCS_48M_2: length 5.9
  TOP w0.254: OSC2.1 115.72,58.1 C12369.1 R80151.2 v3(111.79,58.1)
  BOTTOM w0.254: v2(110.95,58.1) v3(111.79,58.1)
ODTA0: length 45.8
  TOP w0.102: v1(50.44,109.6) 50.74,109.9 51.33,109.9 v4(51.68,110.26) 51.89,110.47 52.4,110.47 MEM1.K1 ; GPU1.L18 78.57,101.4 v4(78.19,101.02)
  L3 w0.127: v4(78.19,101.02) 78.19,101.75 77.63,102.32 77.63,102.6 77.01,103.22 77.01,103.73 77.48,104.2 77.54,104.2 77.91,104.57 77.91,106.89 77.85,106.96 77.85,108.13 77.57,108.4 77.23,108.4 76.98,108.15 76.98,108.15 76.45,107.62 76.42,107.62 76.08,107.27 74.68,107.27 73.52,108.43 69.18,108.43 68.74,108.88 62.21,108.88 61.43,109.66 57.49,109.66 56.65,110.5 56.65,111.08 55.71,112.01 v4(55.62,112.01) 55.37,112.01 55.25,111.9 54.86,111.9 54.53,111.57 54.53,111.54 53.86,110.87 52.66,110.87 52.04,110.26 v4(51.68,110.26)
  L4 w0.127: v4(55.62,112.01) 55.88,112.01 57.45,110.45 57.97,110.45 58.11,110.58 v4(59.38,110.58)
  BOTTOM w0.102: MEM3.K1 59.27,110.48 v4(59.38,110.58)
ODTA1: length 46.5
  TOP w0.102: v4(78.16,98.94) 77.8,99.3 GPU1.K16 ; v4(59.44,93.49) 58.81,92.86 MEM2.K1
  L3 w0.127: v3(51.69,93.53) 54,93.53 54.26,93.27 55.06,93.27 55.21,93.12 v4(56.15,93.12) 56.15,93.48 56.02,93.6 56.01,93.6 55.81,93.81 55.81,94.09 55.91,94.19 56.47,94.19 56.66,93.99 57.03,93.99 57.16,94.12 57.16,94.39 57.28,94.52 57.54,94.52 57.66,94.39 57.66,94.12 57.79,93.99 58.04,93.99 58.17,94.12 58.17,94.39 58.3,94.52 58.55,94.52 58.68,94.39 58.68,94.12 58.81,93.99 59.58,93.99 59.97,94.38 59.97,94.85 60.1,94.98 60.9,94.98 61.25,94.63 66.56,94.63 66.73,94.47 69.57,94.47 69.63,94.52 70.53,94.52 70.91,94.14 72.65,94.14 73.14,93.65 74.4,93.65 74.78,94.04 76.42,94.04 76.43,94.03 77.05,94.03 77.12,93.96 77.55,93.96 77.82,94.23 77.82,94.58 77.79,94.61 77.79,95.43 77.27,95.95 77.27,96.16 77.5,96.39 77.5,96.68 77.37,96.8 77.19,96.8 76.99,97.01 76.99,97.21 77.12,97.34 77.56,97.34 77.78,97.12 78.24,97.12 78.78,97.66 78.78,98.32 v4(78.16,98.94)
  L4 w0.127: v4(56.15,93.12) 56.15,93.44 56.35,93.64 59.29,93.64 v4(59.44,93.49)
  BOTTOM w0.102: MEM4.K1 52.41,92.83 51.72,93.53 v3(51.69,93.53) 50.96,93.53 50.94,93.5 50.48,93.5 50.18,93.2 v2(49.94,93.2)
OS_MODE_SEL: length 153.2
  TOP w0.089: CPU1.AC2 83.77,145.61 83.6,145.38 83.56,145.28 83.56,144.91 83.59,144.83 83.59,144.64 83.92,144.3 83.92,142.42
  TOP w0.102: v3(82.02,125.5) 82.02,125.5 80.98,125.5 79.23,123.75 73.38,123.75 73.01,123.37 73.01,122.54 70.8,120.33 66.08,120.33 62.94,123.47 46.93,123.47 46.7,123.24 46.21,123.24 45.88,123.57 38.13,123.57 v3(37.24,124.46) ; 83.92,142.42 84.15,142.2 84.15,140.59 84.15,140.58 84.15,140.09 84.34,139.9 84.34,139.22 v4(84.74,138.81) ; SCA1.109 58.12,55.93 v3(58.2,56.01)
  L3 w0.127: v3(37.24,124.46) 37.24,123.41 34.95,121.11 34.95,90.22 36.94,88.22 36.94,85.81 45.68,77.07 45.68,69.5 57.06,58.12 57.06,57.51 57.44,57.13 57.44,56.77 v3(58.2,56.01)
  BOTTOM w0.102: R80178.2 81.59,125.5 82.02,125.5 v3(82.02,125.5) v2(82.02,127.33) 82.02,128.07 85.01,131.05 85.01,132.42 84.31,133.12 84.31,138.38 v4(84.74,138.81)
