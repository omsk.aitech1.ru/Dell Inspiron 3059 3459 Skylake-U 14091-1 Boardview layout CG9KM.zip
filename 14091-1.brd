# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_S3_N: length 599.1
  TOP w0.102: CPU1.AP15 89.25,152.7 v4(89.57,152.37) ; v3(120.1,125.48) 120.1,130.31 120.78,130.99 120.78,178.2 106.86,192.13 104.33,192.13 103.16,193.29 v3(103.16,193.35) ; v3(24.49,140.34) 23.66,139.51 R80126.1 ; R80140.1 13.81,180.78 14.26,181.23 v3(14.51,181.23) ; v3(105.82,50.67) 105.82,50.9 104.96,51.77 104.68,51.77 104.17,52.28 104.17,58.42 103.79,58.8 103.79,60.48 103.18,61.09 102.55,61.09 102.29,61.34 102.29,62.96 101.88,63.37 99.09,63.37 98.12,64.34 96.45,64.34 95.61,65.18 91.36,65.18 R79712.1 90.8,64.62 v3(90.8,63.91) ; U109.68 131.81,50.38 132.61,51.18 v3(133.26,51.18) ; v3(151.8,99.44) 151.8,101.32 152.92,102.43 152.92,108.23 152.64,108.51 152.64,111.06 151.35,112.34 151.05,112.34 149.77,113.63 149.77,116.08 v3(147.1,118.75)
  L3 w0.127: v3(151.8,99.44) 150,97.64 150,87.56 147.23,84.79 147.23,73.94 146.08,72.8 146.08,70.85 144,68.77 144,61.12 143.17,60.29 140.08,60.29 136.43,56.64 135.48,56.64 133.26,54.42 v3(133.26,51.18) ; v3(124.37,14.48) 124.66,14.77 126.12,14.77 126.61,15.27 126.61,17.53 126.23,17.91 126.23,34.71 v3(125.38,35.56)
  L4 w0.127: v4(89.57,152.37) 89.99,152.79 91.62,152.79 95.54,148.87 95.54,147.29 105.92,136.91 108.24,136.91 110.84,134.3 110.84,134.2 111.63,133.41 112.63,133.41 120.1,125.95 v3(120.1,125.48) 120.23,125.48 129.09,116.61 134.68,116.61 136.32,116.61 139.72,120.02 145.83,120.02 v3(147.1,118.75) ; v3(78.28,64.81) 89.89,64.81 v3(90.8,63.91) ; 14.38,181.23 13.81,181.81 13.81,201.49 12.26,203.03 12.26,223.72 16.59,228.05 69.7,228.05 74.2,223.55 74.2,215.8 v3(78.29,211.71) ; 14.38,181.23 v3(14.51,181.23) ; 14.38,181.23 14.28,181.23 13.91,180.86 13.91,179.41 14.13,179.2 15.07,179.2 15.74,178.52 15.74,164.57 19.72,160.6 19.72,145.77 21.25,144.23 21.46,144.23 24.49,141.21 v3(24.49,140.34) ; v3(151.8,99.44) 158.28,99.44 158.59,99.76 158.59,107.51 v3(162.47,111.38) ; v3(105.82,50.67) 105.91,50.58 121.97,50.58 122.57,51.18 128.81,51.18 129.32,51.69 132.75,51.69 v3(133.26,51.18)
  BOTTOM w0.102: v3(162.47,111.38) 161.58,110.49 R80112.2 ; R80118.1 v3(78.29,211.71) 77.93,211.35 77.93,208.53 79.79,206.68 79.79,204.4 80.48,203.71 85.5,203.71 91.5,197.71 98.99,197.71 v2(102.14,194.56) 103.16,193.55 v3(103.16,193.35) ; R79789.1 74.65,72.77 77.12,72.77 77.91,71.99 77.91,65.19 v3(78.28,64.81) ; R1878.2 125.5,11.63 R718.1 123.91,13.22 123.91,14.02 v3(124.37,14.48) ; v3(133.26,51.18) 133.71,50.72 133.71,47.47 133.31,47.07 130.67,47.07 124.57,40.97 124.57,36.37 v3(125.38,35.56)
SLP_S3_N_EC: length 3.2
  TOP w0.102: U4101.30 90.92,62.99 v1(91.66,63.73) 91.66,64.59 R79712.2
SLP_S3_N_R3: length 2.4
  TOP w0.102: v3(134.93,50.38) 135.01,50.3 U109.76
  BOTTOM w0.102: TP9917.1 135.03,50.27 v3(134.93,50.38)
SLP_S4_N: length 527.6
  TOP w0.102: CPU1.BA16 93.81,153.86 93.89,153.77 95.31,153.77 96.02,153.06 100.68,153.06 100.96,153.34 103.84,153.34 110.57,146.61 110.57,134.44 110.88,134.14 110.88,127.65 108.03,124.8 108.03,121.13 108.1,121.07 110.14,119.03 v3(110.14,118.75) ; R79713.1 91.59,49.72 v3(91.6,49.73) ; v3(102.4,193.35) 102.4,193.11 103.73,191.77 106.71,191.77 120.43,178.05 120.43,131.14 118.96,129.67 118.96,124.19 120.66,122.48 129.1,122.48 v3(132.9,118.68) ; v3(158.15,175.01) 158.15,176.72 R80247.1 ; R1951.1 130.84,46.48 v3(130.97,46.61)
  L3 w0.127: v3(126.78,35.56) 126.31,36.03 125.19,36.03 124.87,35.72 124.87,35.05 125.76,34.16 125.76,17.08 124.55,15.88 v3(124.37,15.88)
  L4 w0.127: v3(162.47,110.62) 158.97,107.12 158.97,99.6 158.43,99.06 158.12,99.06 154.59,99.06 154.21,98.68 v3(151.8,98.68) 151.67,98.68 149.35,101 143.08,101 139.24,104.84 137.87,104.84 137.71,104.99 136.18,104.99 136,104.81 133.98,104.81 132.79,106.01 124.9,106.01 124.05,106.86 118.43,106.86 114.97,110.32 114.97,116.36 112.11,119.21 110.61,119.21 v3(110.14,118.75) ; v3(130.97,46.61) 130.12,45.76 117.57,45.76 116.59,46.74 101,46.74 97.47,50.27 92.13,50.27 v3(91.6,49.73) ; v3(132.9,118.68) 137.03,122.81 153.12,122.81 160.29,129.99 160.29,163.72 157.51,166.5 157.51,174.37 v3(158.15,175.01)
  BOTTOM w0.102: R80111.2 162.72,110.36 v3(162.47,110.62) ; v3(110.14,118.75) 110.6,119.2 132.38,119.2 v3(132.9,118.68) ; v3(151.8,98.68) 151.8,91.59 150.48,90.27 150.48,72.18 151.37,71.29 151.37,64.36 151.12,64.12 151.12,46.95 149.39,45.21 149.39,39.47 148.85,38.94 144.3,38.94 142.02,41.22 140.75,41.22 139.61,42.37 136.84,42.37 134.3,44.91 132.67,44.91 v3(130.97,46.61) 130.72,46.61 127.67,43.56 127.67,36.45 v3(126.78,35.56) ; Q1217.5 123.99,16.26 v3(124.37,15.88) ; R80117.1 77.84,212.72 77.58,212.46 77.58,206.1 80.36,203.33 85.33,203.33 91.5,197.15 v2(98.36,197.15) 98.79,197.15 102.4,193.55 v3(102.4,193.35)
SLP_S4_N_C: length 5
  TOP w0.102: R297.1 131.86,46.82 v1(131.8,46.88) 132.29,47.37 132.31,47.37 132.53,47.6 133.7,47.6 134.21,48.11 U109.74
SLP_S4_N_EC: length 2.9
  TOP w0.102: U4101.51 90.92,52.31 90.58,51.97 v1(90.58,51.59) R79713.2
SLP_S4_N_SIO: length 3.7
  TOP w0.102: R297.2 131.86,44.12 131.55,43.81 v1(131.48,43.81) 131.33,43.81 130.84,44.3 R1951.2 R1950.2
SLP_S5_N: length 174.1
  TOP w0.089: CPU1.AY16 92.69,153.83 93.14,153.56 93.58,153.56
  TOP w0.102: v3(121.57,46.61) 121.57,46.6 122.58,45.59 124.24,45.59 125.41,44.42 129.08,44.42 129.32,44.66 129.32,45.28 R1950.1 ; 93.58,153.56 95.11,153.56 95.82,152.86 101,152.86 101.28,153.14 103.54,153.14 110.14,146.54 110.14,134.37 110.52,133.99 110.52,127.8 107.68,124.95 107.68,120.45 v3(109.38,118.75)
  L3 w0.127: v3(119.59,108.61) 124.65,108.61 126.44,110.4 138.48,110.4 143.99,104.89 143.99,88.9 143.16,88.07 143.16,80.31 141.64,78.78 141.64,71.15 137.28,66.79 137.28,64.85 131.11,58.67 130.81,58.67 128.81,56.67 128.81,52.29 127.44,50.93 126.7,50.93 125.9,50.13 125.9,50.13 125.62,49.85 125.62,49.85 122.85,47.08 122.52,47.08 122.05,46.61 v3(121.57,46.61)
  BOTTOM w0.102: v3(109.38,118.75) 109.38,117.58 v2(110.07,116.88) 112.64,116.88 116.11,113.41 116.11,109.47 116.97,108.61 v3(119.59,108.61)
SLP_SUSB: length 398.2
  TOP w0.102: v3(20.99,153.92) 20.53,153.47 20.53,151.08 20.8,150.81 PR5217.1 ; U109.3 142.21,65.7 142.22,65.71 142.22,67.26 v3(143.04,68.07) ; CPU1.AN15 88.6,152.7 v4(88.92,152.37) ; R80234.1 14.7,154.37 v3(14.64,154.31) ; v3(105.95,113.56) 104.34,113.56 100.8,117.09 91.09,117.09 89.57,118.62 PR5245.2
  L3 w0.127: v3(20.99,153.92) 20.61,154.31 v3(14.64,154.31) ; v3(129.19,12.45) 124.62,12.45 123.9,13.17 123.9,16.07 124.25,16.42 124.56,16.42 124.84,16.7 124.84,29.63 123.6,30.86 v3(123.6,35.56)
  L4 w0.127: v3(143.04,71.88) 142.82,71.67 137.62,71.67 137.4,71.44 136.37,71.44 135.83,71.97 128.52,71.97 125.64,69.09 v3(123.73,69.09) ; v3(105.95,113.56) 103.82,115.7 82.59,115.7 71.16,127.13 70.63,127.13 67.02,127.13 64.85,124.96 46.18,124.96 44.02,124.96 37.51,131.46 37.51,131.62 35.66,133.47 35.66,134.96 30.54,140.08 26.77,140.08 20.11,146.74 20.11,153.05 v3(20.99,153.92) ; v3(143.67,118.75) 142.78,119.63 139.88,119.63 137.32,117.08 136.47,116.23 128.48,116.23 112.38,132.33 112.38,132.35 v3(111.79,132.94) 111.77,132.97 111.57,132.97 111.51,133.03 111.47,133.03 110.46,134.05 110.46,134.08 108.01,136.53 105.54,136.53 95.16,146.91 95.16,148.65 92.2,151.61 91.6,151.61 91.27,151.94 89.39,151.94 88.96,152.37 v4(88.92,152.37)
  BOTTOM w0.102: v3(123.6,35.56) 123.08,35.56 121.5,37.15 121.5,41.95 122.03,42.48 122.03,42.86 121.33,43.56 120.42,43.56 117.56,46.42 117.56,46.8 121.42,50.66 121.42,60.5 121.7,60.78 121.7,67.06 v2(121.71,67.06) v3(123.73,69.09) ; v3(111.79,132.94) 111.79,127.25 105.82,121.28 105.82,113.69 v3(105.95,113.56) ; R1980.2 143.05,7.44 133.4,7.44 130.46,10.38 130.46,11.18 v3(129.19,12.45) ; v3(143.04,68.07) v3(143.04,71.88) 142.58,72.34 142.58,72.83 144.15,74.41 144.15,118.26 v3(143.67,118.75)
SLP_SUSB_C: length 8.9
  TOP w0.152: Q9650.6 14.88,160.54 14.57,160.85 R80236.2 14.57,162.88 14.92,163.22 15.79,163.22 17.56,161.46 v1(17.56,160.6) 17.62,160.54 R80235.1
SLP_SUSB_R: length 6.5
  TOP w0.152: R80234.2 R80232.1 ; R80232.1 15.59,156.72 15.53,156.78 Q9650.2 ; R80232.1 16.47,156.21 v1(17.03,156.77) 17.62,157.37 R80233.1
SLP_WLAN_N: length 4.2
  TOP w0.102: CPU1.BB17 97.96,154.43 TP9915.1
SM_DRAMRST#: length 19.2
  TOP w0.102: v4(90.22,152.38) 90.55,152.05 CPU1.AT13
  BOTTOM w0.102: v4(90.22,152.38) 90.23,152.38 90.63,151.97 91.04,151.97 91.54,152.46 91.93,152.46 95.19,149.2 v2(98.2,149.2) 105.91,149.2 R80074.2 R80075.1
SM_DRAMRST#_R: length 150.6
  TOP w0.102: DIMM1.30 140.25,181.85 140.27,181.84 140.86,181.84 v4(140.87,181.83) ; v3(158.4,178.44) 157.89,178.94 157.89,180.34 156.38,181.85 DIMM2.30 153.19,181.85 v4(153.14,181.9)
  L3 w0.127: v4(140.87,181.83) 140.88,181.83 141.36,181.36 152.59,181.36 v4(153.14,181.9)
  BOTTOM w0.102: v3(158.4,178.44) 159.52,177.32 159.52,176.04 159.52,176.04 159.52,152 159.52,152 159.52,151.67 157.45,149.6 157.45,146.11 v2(156.5,145.16) 155.61,144.27 155.61,124.47 154.74,123.6 127.41,123.6 110.14,140.86 110.14,141.73 108.82,143.05 103.71,143.05 101.81,144.96 101.81,146.12 102.88,147.19 106.33,147.19 106.9,147.76 R80075.2 ; v4(140.87,181.83) 140.27,181.23 C1217.1 ; C1301.1 153.29,182.05 v4(153.14,181.9)
SM_INTRUDER#: length 28.4
  TOP w0.102: v4(89.57,153.29) 89.25,153.61 CPU1.AP16
  L3 w0.127: v3(107.86,137.41) 106.44,138.83 106.44,138.85 93.89,151.41 93.89,152.04 92.21,153.71 90,153.71 v4(89.57,153.29)
  BOTTOM w0.102: v2(109.86,137.9) 109.32,137.35 R80038.2 107.92,137.35 v3(107.86,137.41)
SM_RCOMP_0: length 4.6
  TOP w0.305: v4(89.57,155.12) 89.57,154.98 CPU1.AR18
  BOTTOM w0.203: R80076.1 92.7,155.85 91.65,155.85 v2(91.63,155.83) 91.6,155.85 91.2,155.85 91.18,155.87 90.32,155.87 v4(89.57,155.12)
SM_RCOMP_1: length 5.5
  TOP w0.305: CPU1.AT18 90.22,154.99 v4(90.22,155.12)
  BOTTOM w0.203: v4(90.22,155.12) 90.68,155.58 91.06,155.58 91.39,155.25 93.55,155.25 v2(93.76,155.04) 93.86,154.94 R80078.1
SM_RCOMP_2: length 4.9
  TOP w0.305: v4(90.87,155.12) 91.2,154.79 CPU1.AU18
  BOTTOM w0.203: v4(90.87,155.12) 91.04,154.95 92.25,154.95 v2(92.54,154.66) 92.62,154.58 93.33,154.58 93.99,153.92 R80077.1
SMB0_CVT_CLK: length 6.1
  TOP w0.102: C3456.1 38.01,23.44 v3(38.08,23.37) 38.08,23.3 38.49,22.89 39.64,22.89 R79633.1
  BOTTOM w0.102: v2(38.9,22.93) 38.46,23.37 v3(38.08,23.37) 38.08,23.93 37.55,24.46 U120.6
SMB0_CVT_DATA: length 5.5
  TOP w0.102: R79634.1 38.44,22.44 38.35,22.53 38,22.88 37.93,22.88 37.43,23.38 v3(37.32,23.38) 37.12,23.58 C43.1
  BOTTOM w0.102: v2(37.73,22.61) 37.32,23.01 v3(37.32,23.38) 36.73,23.97 U120.7
SMB_CLK_MAIN: length 382.7
  TOP w0.102: Q123.6 100,85.99 100.36,86.36 v3(100.36,86.76) ; v3(165.01,129.29) 163.57,127.85 DIMM2.202 153.87,127.85 153.58,128.14 152.58,128.14 v4(152.08,127.64) ; v3(86.39,65.66) 86.39,65.91 86.16,66.14 85.78,66.14 85.51,66.41 U6701.4 ; Q4.S 154.02,117.67 152.62,119.06 R79991.2 152.62,121.3 152.26,121.67 147.86,121.67 142.65,126.87 141.26,126.87 140.28,127.85 DIMM1.202 138.52,127.85 138.31,128.06 136.8,128.06 v4(136.34,127.6) ; R9912.2 54.52,221.49 v3(56.8,223.77)
  L3 w0.127: v3(165.01,129.29) 164.16,130.14 164.16,153.53 165.3,154.67 165.3,193.89 155.25,203.94 127.69,203.94 126.33,205.31 114.54,205.31 113.79,204.56 109.15,204.56 109.12,204.52 90.03,204.52 89.92,204.64 85.15,204.64 79.26,210.52 79.26,214.12 78.65,214.74 78.65,216.41 79.79,217.55 79.79,218.49 79.79,223.28 78.49,224.57 59.76,224.57 59.09,223.9 58.45,223.9 57.86,223.3 57.4,223.3 56.93,223.77 v3(56.8,223.77) ; v4(152.08,127.64) 151.57,127.13 146.88,127.13 146.52,126.77 137.55,126.77 136.72,127.6 v4(136.34,127.6) 134.78,127.6 134.34,127.16 132.28,127.16 131.92,126.81 125.45,126.81 125.1,127.15 101.74,127.15 99.68,125.09 v3(99.68,124.84)
  BOTTOM w0.102: v3(99.68,124.84) 99.68,124.58 103.39,120.88 103.39,91.37 100.36,88.35 v3(100.36,86.76) 98.71,85.11 98.71,80.77 99.73,79.76 99.73,72 97.76,70.04 94.38,70.04 90.2,65.86 89.11,65.86 88.86,66.12 86.85,66.12 v3(86.39,65.66) 84.72,63.98 v2(84.72,62.48) 84.72,61.32 83.09,59.7 83.09,57.4 84.16,56.34 Q9501.1
SMB_CLK_RESUME: length 240.1
  TOP w0.102: v4(80.19,148.29) 79.97,148.06 CPU1.R7 ; v3(128.68,218.44) 128.05,219.07 R14.1 ; v3(100.49,124.84) 100.62,124.97 R1837.2 ; v3(148.98,125.86) 148.98,125.76 150.64,124.1 155.46,124.1 160.36,119.2 160.37,119.2 160.64,118.93 160.64,118.5 159.71,117.58 159.4,117.58 158.74,116.92 157.65,116.92 157.31,117.26 157.31,117.46 155.2,119.57 Q4.D
  L3 w0.127: v3(157.39,179.45) 156.88,178.94 156.88,163.1 157.83,162.15 157.83,130.59 154.11,126.87 150,126.87 v3(148.98,125.86) 148.45,126.39 136.66,126.39 136.24,126.81 132.56,126.81 132.18,126.43 125.27,126.43 124.93,126.77 102.42,126.77 v3(100.49,124.84)
  L4 w0.127: v3(100.49,124.84) 100.02,124.37 87.66,124.37 86.98,125.05 86.42,125.05 78.3,133.17 78.3,139.59 77.57,140.32 77.57,144.34 80.62,147.39 80.62,147.86 v4(80.19,148.29)
  BOTTOM w0.102: v3(128.68,218.44) 128.68,217.17 126.88,215.37 126.88,209.83 128.3,208.41 134.27,208.41 146.36,196.32 v2(147.18,196.32) 151.12,196.32 157.08,190.36 157.08,179.76 v3(157.39,179.45)
SMB_DATA_MAIN: length 390.6
  TOP w0.102: v4(134.15,127.61) 135.42,127.61 136.26,128.45 DIMM1.200 142.35,128.45 148.12,122.68 155.04,122.68 R124.2 156.37,120.71 156.37,119.12 157.82,117.67 Q9628.S ; v3(57.61,223.77) 57.56,223.77 54.14,220.34 R9911.2 ; v4(151.29,127.64) 152.11,128.45 DIMM2.200 163.41,128.45 v3(165.01,130.05) ; v3(85.63,65.66) 85.33,65.96 U6701.6 ; v3(98.2,84.07) 97.58,84.69 Q123.3
  L3 w0.127: v3(98.92,124.84) 98.92,125.09 101.36,127.53 125.26,127.53 125.61,127.19 131.86,127.19 132.28,127.61 v4(134.15,127.61) 134.61,128.08 146.41,128.08 146.86,127.64 v4(151.29,127.64) ; v3(57.61,223.77) 57.77,223.77 58.32,224.32 58.95,224.32 59.59,224.96 78.65,224.96 80.17,223.44 80.17,218.33 80.17,217.33 79.07,216.22 79.07,215.83 79.64,215.25 79.64,210.68 85.31,205.02 90.08,205.02 90.19,204.9 108.96,204.9 109,204.94 113.63,204.94 114.38,205.69 126.49,205.69 127.85,204.32 151.76,204.32 155.4,204.32 165.68,194.05 165.68,154.36 164.54,153.21 164.54,130.52 v3(165.01,130.05)
  BOTTOM w0.102: v3(98.92,124.84) 103.03,120.73 103.03,91.52 98.2,86.7 v3(98.2,84.07) 98.2,80.78 99.37,79.61 99.37,72.15 97.62,70.39 94.23,70.39 90.06,66.22 89.26,66.22 89.01,66.47 86.44,66.47 v3(85.63,65.66) v2(84.74,64.76) 84.11,64.14 84.11,61.21 82.71,59.82 82.71,57.66 81.59,56.54 81.59,53.95 81.84,53.71 Q9501.4
SMB_DATA_RESUME: length 231.6
  TOP w0.102: R1622.1 v3(127.8,218.44) ; CPU1.R8 79.97,148.71 v4(80.21,148.96) ; Q9628.D 159.16,119.57 R1838.2 159.29,119.63 155.18,123.75 149.99,123.75 v3(148.65,125.09)
  L3 w0.127: v3(157.51,178.44) 157.26,178.18 157.26,163.26 158.21,162.31 158.21,130.44 154.18,126.4 150.13,126.4 149.51,125.79 149.51,125.72 148.89,125.09 v3(148.65,125.09) 147.74,126 136.41,126 135.99,126.43 133.45,126.43 133.07,126.05 125.06,126.05 124.72,126.39 102.7,126.39 100.68,124.37 97.53,124.37 v3(97.06,124.84)
  L4 w0.127: v4(80.21,148.96) 80.21,148.93 80.84,148.3 80.84,147.23 78.68,145.07 78.68,133.33 86.58,125.43 87.55,125.43 88.14,124.84 v3(97.06,124.84)
  BOTTOM w0.102: v3(127.8,218.44) 127.8,216.78 126.53,215.51 126.53,209.68 128.16,208.05 134.12,208.05 146.52,195.66 v2(149.03,195.66) 151.28,195.66 156.73,190.21 156.73,179.22 v3(157.51,178.44)
SMBUS_ISP: length 96.8
  TOP w0.102: v3(85.11,55.74) 85.69,55.16 R9563.1 R9557.2 85.06,54.36 84.18,54.36 Q9502.5 Q9502.2 ; v3(149.68,56.35) 150.12,56.79 150.12,59.54 149.79,59.87 148.25,59.87 R257.2 C182.1 146.96,58.47 146.34,58.47 145.63,57.77 U109.115
  L4 w0.127: v3(85.11,55.74) 85.11,57.45 85.48,57.81 87.66,57.81 89.06,59.21 93.38,59.21 96.64,55.95 96.64,55.09 102.54,49.19 134.41,49.19 135.45,50.23 135.45,50.5 137.4,52.45 146.34,52.45 149.69,55.8 149.69,56.34 v3(149.68,56.35)
  BOTTOM w0.102: v3(85.11,55.74) 85.66,55.19 v2(85.66,54.76) 85.66,54.58 85.43,54.36 Q9501.2 Q9501.5
SMBUS_MS: length 6
  TOP w0.102: U109.123 143.15,60.97 v3(142.78,61.34)
  BOTTOM w0.102: v3(142.78,61.34) 143.42,61.98 143.42,62.74 v2(143.59,62.91) 143.73,63.06 R80218.1 R80217.2
SML0_CLK: length 19
  TOP w0.102: v3(80.04,137.94) 80.41,138.3 81.56,138.3 83.24,139.99 83.24,140.93 RN1807.5 ; CPU1.R9 79.95,149.65 v4(80.19,149.65)
  BOTTOM w0.102: v3(80.04,137.94) 79.46,138.52 v2(79.46,138.53) 79.03,138.96 79.03,143.88 79.84,144.69 79.84,147.41 79.8,147.45 79.8,147.95 79.79,147.96 79.79,149.24 v4(80.19,149.65)
SML0_DATA: length 4.1
  TOP w0.089: 82.13,144.57 82.13,144.8 81.83,145.1 CPU1.W2
  TOP w0.102: 82.13,144.57 82.13,143.31 82.23,143.21 v1(82.23,142.66) 82.07,142.51 RN1807.6
SML1_CLK: length 5.7
  TOP w0.089: v4(81.52,143.13) 81.29,143.35 81.29,144.18 81.55,144.44 81.55,144.75 81.6,144.87 81.6,145.16 81.57,145.23 81.57,145.43 81.61,145.54 81.61,145.71 81.78,145.93 CPU1.W3
  TOP w0.102: RN1807.7 81.57,143.07 v4(81.52,143.13)
  BOTTOM w0.102: v2(81.52,142.32) v4(81.52,143.13)
SML1_DATA: length 5.2
  TOP w0.089: 81.05,143.31 81.05,144.19 81.36,144.5 81.38,144.54 81.38,144.79 81.38,144.8 81.42,144.92 81.42,145.12 81.39,145.19 81.39,145.47 81.42,145.57 81.42,146.05 CPU1.V3
  TOP w0.102: 81.05,143.31 81.05,142.66 v1(80.91,142.52) 80.92,142.51 RN1807.8
SNB: length 3.3
  BOTTOM w0.508: v2(40.39,38.86) 40.14,39.12 R79619.2 38.84,40.69 C35.1
SO_1: length 7.4
  TOP w0.102: R9506.2 73.42,59.73 v1(74.38,59.73) 75.9,59.73 78.39,62.23 U9501.2
SP1: length 7.3
  BOTTOM w0.089: R79844.1 169.77,138.68 170.64,138.68 v2(170.7,138.73) 171.05,139.09 171.05,140 173.79,142.74 U14.15
SP2: length 5.7
  BOTTOM w0.089: R79845.1 170.51,139.95 v2(170.53,139.98) 170.54,139.98 173.38,142.82 U14.16
SP3: length 4.8
  BOTTOM w0.102: R79846.1 170.43,141.92 v2(171.05,141.3) 171.12,141.3 172.7,142.88 U14.17
SP4: length 3.5
  BOTTOM w0.102: U14.19 171.77,144.94 171.28,144.45 171.28,143.98 v2(171.09,143.8) 170.12,143.8 R79847.1
SP5: length 2.9
  BOTTOM w0.102: R79848.1 170.87,144.91 v2(170.98,145.01) 171.31,145.34 U14.20
SP6: length 3.9
  BOTTOM w0.102: R79849.1 170.16,147.83 v2(171.15,146.84) 171.23,146.76 171.23,146.3 171.79,145.74 U14.21
SP7: length 5.3
  BOTTOM w0.102: U14.29 174.98,148.77 175.72,149.5 176.49,149.5 176.97,149.02 v2(177.45,149.02) 177.6,149.17 177.6,149.77 R79851.1
SPDIF_IC: length 131.4
  TOP w0.102: v3(159.29,68.58) 159.8,68.58 v1(160.13,68.91) 160.46,69.24 160.46,71.78 161.59,72.91 U6.16 ; SCA1.68 54.87,72.9 55.27,73.29 v3(55.27,73.78)
  L4 w0.102: v3(55.27,73.78) 57.16,71.88 61.42,71.88 65.2,68.11 86.82,68.11 89.29,65.65 96.64,65.65 100.13,62.15 100.83,62.15 102.43,60.55 110.55,60.55 112.69,58.41 112.69,58.1 114.03,56.76 121.23,56.76 123.15,58.67 124.11,58.67 125.46,60.02 127.29,60.02 128.33,58.98 140.83,58.98 141.59,58.22 145.14,58.22 145.8,57.56 146.78,57.56 147.62,58.4 147.62,59.98 152.23,64.59 154.13,64.59 155.51,63.22 158.26,63.22 159.24,64.2 159.24,65.51 158.83,65.91 158.83,68.12 v3(159.29,68.58)
SPEAKER1_L1: length 15.4
  TOP w0.203: U9615.3 155.13,62.74 R79812.2 153.78,63.02 152.65,63.02 152.41,62.77 152.41,60.58 152.69,60.3 152.8,60.3 153.53,59.57 v1(153.53,59.18) 153.53,57.4 154.11,56.82 155.25,56.82 155.68,57.25 156.29,57.25 156.73,56.82 156.73,56.69 157.13,56.29 C241.1
SPEAKER1_R1: length 11.6
  TOP w0.203: U9615.9 162.3,63.24 162.47,63.07 R79813.2 162.47,63.37 162.9,63.8 164.38,63.8 164.7,63.48 164.7,60.45 166.45,58.7 166.45,58.6 v1(166.49,58.56) 166.49,57.52 C12263.1
SPEED_100*_CON: length 7.1
  TOP w0.254: RJ1.12 70.9,21.66 70.9,25.27 v3(70.85,25.32) 70.9,25.37 UR6.2
  BOTTOM w0.254: v2(70.04,25.32) v3(70.85,25.32)
SPEED_100_N: length 99.5
  TOP w0.203: U16.26 36.88,11.64 v3(36.52,11.28)
  TOP w0.254: v3(51.47,4.83) 51.21,4.57 v1(51.21,3.68) 52.05,2.84 84.28,2.84 85.01,3.57 85.01,13.23 85.98,14.2 85.98,28.02 84.64,29.36 82.58,29.36 81.34,30.61 78.39,30.61 78.01,30.23 78.01,28.19 77.69,27.88 U12.6 UR6.1
  L4 w0.254: v3(51.47,4.83) 50.33,5.97 46.07,5.97 41.89,10.14 41.89,10.85 40.5,12.24 37.48,12.24 v3(36.52,11.28)
SPEED_1000*_CON: length 8
  TOP w0.254: RJ1.11 71.92,21.69 71.92,25.15 v3(71.74,25.32) 71.92,25.5 71.92,27.24 UR7.2
  BOTTOM w0.254: v2(71.74,24.08) v3(71.74,25.32)
SPEED_1000_N: length 94.1
  TOP w0.203: U16.25 36.48,12 v3(35.76,11.28)
  TOP w0.254: UR7.1 77.76,27.3 78.33,27.88 U12.1 81.12,27.88 82.2,28.96 84.47,28.96 85.58,27.85 85.58,14.37 84.6,13.39 84.6,3.8 84.06,3.25 53.93,3.25 v1(53.51,3.67) v3(52.36,4.83)
  L4 w0.254: v3(35.76,11.28) 37.13,12.65 40.67,12.65 42.3,11.02 42.3,10.31 46.13,6.48 50.71,6.48 v3(52.36,4.83)
SPI_CLK: length 27
  TOP w0.102: R352.1 61.96,132.72 63.63,131.04 v1(64.3,131.04) 71.11,131.04 71.56,130.59 80.31,130.59 83.09,133.37 83.09,134.09 83.8,134.8 85.34,134.8 R1806.1
SPI_CLK_1: length 20.9
  TOP w0.102: R352.2 59.52,132.72 58.99,132.18 v3(58.1,132.18) 57.69,131.78 45.44,131.78 44.68,131.01 44.68,129.79 45.06,129.41 46.32,129.41
  BOTTOM w0.102: v2(57.87,131.39) 58.1,131.62 v3(58.1,132.18)
SPI_CLK_CPU: length 14.7
  TOP w0.089: 91.8,143.11 91.57,143.34 91.57,144.84 91.8,145.07 CPU1.AV2
  TOP w0.102: 91.8,143.11 91.8,141.44 90.15,139.8 90.15,136.99 87.9,134.74 87.9,134.32 v1(87.61,134.04) 86.99,134.04 R1806.2
SPI_CS0_N: length 41.5
  TOP w0.102: v3(62.77,132.85) 62.77,132.58 63.76,131.59 71.24,131.59 71.76,131.07 80.11,131.07 82.58,133.55 82.58,134.26 83.6,135.28 85.57,135.28 R1812.2 ; SRCON1.1 60.03,126.87 60.23,126.67 62.26,126.67 63.53,127.94 v3(63.53,128.14)
  BOTTOM w0.102: v3(63.53,128.14) v2(63.53,129.82) 63.53,132.08 62.82,132.79 62.82,132.8 v3(62.77,132.85)
SPI_CS_CPU_N0: length 13.5
  TOP w0.089: 91.29,143.74 91.37,143.81 91.37,145.66 91.31,145.79 CPU1.AU3
  TOP w0.102: 91.29,143.74 91.29,141.62 89.67,140 89.67,137.19 87.79,135.31 v1(87.59,135.31) 86.74,135.31 R1812.1
SPI_HOLD_CPU: length 16.8
  TOP w0.089: 90.85,144.03 90.85,146.38 CPU1.AU4
  TOP w0.102: R1811.2 84.73,136.72 v1(84.82,136.8) 85.85,136.8 R1834.2 86.74,135.92 88.07,135.92 89.44,137.28 89.44,140.09 91.05,141.71 91.05,143.82 90.85,144.03
SPI_IO2: length 17.7
  TOP w0.102: R351.2 64.87,129.16 65.13,129.42 79.88,129.42 v1(80.23,129.08) 80.4,128.91 R1809.1
SPI_IO3: length 25.7
  TOP w0.102: R1811.1 83.84,135.84 82.35,134.36 82.35,133.64 80.67,131.95 77.43,131.95 v1(77.15,131.67) 76.77,131.3 71.86,131.3 71.33,131.82 63.85,131.82 63.23,132.45 63.23,133.12 62.92,133.43 62.12,133.43 R348.1
SPI_MISO: length 25.1
  TOP w0.102: R79978.2 62.34,127.13 63.03,127.81 63.03,128.28 63.4,128.66 64.69,128.66 65.23,129.19 79.3,129.19 80.09,128.4 83.45,128.4 v1(83.8,128.75) 83.95,128.91 R1807.1
SPI_MISO_ROM_1: length 8.2
  TOP w0.102: R79978.1 57.21,127.13 v3(56.19,128.14) SRCON1.2
  BOTTOM w0.102: v2(55.38,128.14) v3(56.19,128.14)
SPI_MOSI: length 23.5
  TOP w0.102: R1808.1 83.31,132.91 80.51,130.11 71.36,130.11 71.01,130.45 v1(69.15,130.45) 63.53,130.45 62.29,131.7 R79977.1
SPI_MOSI_1: length 17.3
  TOP w0.102: SRCON1.5 45.7,131.06 45.91,131.27 58.78,131.27 59.67,132.16 v3(60.13,132.16) 60.59,131.7 R79977.2
  BOTTOM w0.102: v2(60.13,131.34) v3(60.13,132.16)
SPI_SI_CPU: length 20.4
  TOP w0.089: 92.46,143.41 92.54,143.48 92.54,143.89 92.09,144.34 92.09,146.02 CPU1.AV3
  TOP w0.102: R1808.2 84.17,134.24 v1(84.64,134.24) 84.74,134.14 R1826.2 85.63,133.29 R1824.2 86.71,133.41 R1825.1 87.73,133.35 88.38,134 88.38,134.54 90.74,136.89 90.74,139.44 90.74,139.44 90.74,139.7 92.46,141.43 92.46,143.41
SPI_SI_XDP: length 194.4
  TOP w0.102: v3(57.82,129.46) 58.4,130.05 61.83,130.05 62.49,130.71 62.95,130.71 63.19,130.47 63.19,130.47 63.44,130.23 68.26,130.23 68.61,129.88 80.79,129.88 82.2,131.29 v1(82.53,131.29) 82.86,131.62 82.86,132.07 83.23,132.44 84.7,132.44 R1826.1 ; R9910.2 47.33,224.47 R9909.2 47.39,225.06 v3(47.02,225.43)
  L3 w0.127: v3(42.2,133.1) 39.63,135.66 24.01,135.66 16.67,143 16.67,150.24 12.37,154.54 12.37,183.56 13.03,184.21 13.03,186.6 14.74,188.32 14.74,200.81 12.61,202.95 12.61,218.56 17.68,223.63 28.21,223.63 28.9,224.32 33.23,224.32 33.57,224.66 46.26,224.66 v3(47.02,225.43)
  L4 w0.127: v3(42.2,133.1) 45.16,130.14 57.14,130.14 v3(57.82,129.46)
SPI_SO_CPU: length 20.8
  TOP w0.102: R1807.2 87.26,128.91 v1(87.69,129.34) 88.35,130 88.35,133.32 88.84,133.82 88.84,134.35 91.19,136.7 91.19,139.25 91.19,139.25 91.19,139.47 92.93,141.21 92.93,144.11 92.86,144.18 92.86,145.05 92.69,145.22 92.69,145.64 CPU1.AW3
SPI_WP_CPU: length 24.1
  TOP w0.089: 92.74,143.01 92.74,144.02 92.27,144.5 92.27,144.9 92.36,145 CPU1.AW2
  TOP w0.102: 92.74,143.01 92.7,142.97 92.7,141.34 91.07,139.7 91.07,139.67 90.97,139.57 90.97,139.35 90.96,136.79 88.61,134.44 88.61,133.91 88.12,133.42 88.12,131.7 v1(87.68,131.25) 87.27,130.84 87.27,129.79 87.27,129.79 87.02,129.54 82.9,129.54 R1827.2 R1809.2
SPI_WP_N_1: length 12.2
  TOP w0.102: 53.9,129.41 55.41,129.41 56.1,128.71 56.48,128.71 v3(57.06,128.14) R79981.1 R343.2 61.34,128.65 62.83,128.65 R351.1
  BOTTOM w0.102: v2(57.87,128.14) v3(57.06,128.14)
SPI_WP_XDP: length 185.1
  TOP w0.102: R9928.1 42.2,224.73 v3(42.2,225.43) ; v3(57.06,129.41) 57.46,129.01 58.05,129.01 58.83,129.79 62.36,129.79 v1(62.72,130.15) 62.87,130 68.17,130 68.52,129.65 81.36,129.65 R1827.1
  L3 w0.127: v3(42.2,225.43) 41.69,224.92 33.47,224.92 33.12,224.57 28.77,224.57 28.09,223.89 17.07,223.89 12.35,219.17 12.35,202.7 14.49,200.56 14.49,188.45 12.01,185.97 12.01,154.52 16.42,150.11 16.42,142.87 23.87,135.41 39.12,135.41 v3(41.44,133.1)
  L4 w0.127: v3(57.06,129.41) 56.59,129.88 45.03,129.88 42.31,132.6 41.93,132.6 v3(41.44,133.1)
SPKR_DET: length 75.3
  TOP w0.102: v3(164.75,38.86) 164.75,38.16 R80237.1 ; U109.59 128.08,52.57 127.82,52.83 v3(127.67,52.83)
  L4 w0.127: v3(152.18,43.18) 152.93,43.93 152.93,46.62 152.18,47.37 152.18,51.09 151.29,51.98 151.29,55.85 150.1,57.05 149.08,57.05 147.06,55.03 145.41,55.03 144.05,56.39 140.62,56.39 140.18,56.83 135.46,56.83 132,53.38 128.21,53.38 v3(127.67,52.83)
  BOTTOM w0.102: R283.1 128.62,51.88 v3(127.67,52.83) ; v3(152.18,43.18) 151.65,42.65 151.65,38.89 150.22,37.46 150.22,34.52 152.41,32.33 161.65,32.33 v2(161.68,32.31) 162.12,32.31 165.11,35.29 165.11,38.51 v3(164.75,38.86)
SPKR_DET_C: length 12.9
  TOP w0.102: SPK1.6 163.51,30.38 165.87,32.74 v1(165.87,36.83) 165.64,37.06 164.54,37.06 R80237.2
SPKR_IN_L: length 7.4
  TOP w0.203: 155.96,53.31 156.34,53.31 156.7,53.67 156.7,54.2 156.98,54.48 C241.2 158.05,53.57 158.3,53.57 159.05,52.82 U9625.6 ; 155.96,53.31 v1(155.96,53.29) ; 155.96,53.31 155.79,53.49 155.79,54.47 C243.2
SPKR_IN_R: length 8.2
  TOP w0.203: U9625.31 162.95,50.14 163.1,50.29 163.1,50.8 165.56,53.26 166.2,53.26 166.43,53.49 v1(166.43,53.57) C12263.2
SPKR_L+_C: length 9.5
  TOP w0.711: 152.05,32.89 SPK1.1
  TOP w0.762: L7.2 154.08,37.52 R79982.1 C253.1 154.08,34.92 v3(152.86,33.71) 152.05,32.89
  BOTTOM w0.508: v3(152.86,33.71) v2(152.86,34.52)
SPKR_L+_SNB: length 4.3
  TOP w0.508: v3(152.31,38.86) 151.54,38.1 v1(151.54,38.02) 151.54,37.29 152.26,36.58 R79982.2
  BOTTOM w0.508: C255.1 152.43,38.73 v3(152.31,38.86)
SPKR_L-_C: length 9.3
  TOP w0.711: 153.55,32.61 SPK1.2
  TOP w0.762: L8.2 155.23,37.64 R79983.1 C254.1 155.23,34.29 v3(154.53,33.59) 153.55,32.61
  BOTTOM w0.508: v3(154.53,33.59) v2(154.53,34.42)
SPKR_L-_SNB: length 6.1
  TOP w0.508: v3(157.13,38.86) 156.75,38.48 R79983.2
  BOTTOM w0.508: C256.1 155.35,37.85 v2(155.33,37.87) 156.32,38.86 v3(157.13,38.86)
SPKR_OUT_L+: length 8.7
  TOP w0.305: 157.21,46.05 U9625.16
  TOP w0.762: 157.21,46.05 v1(155.53,44.37) 154.72,43.56 C244.2 C12262.1 154.72,41.1 L7.1
SPKR_OUT_L-: length 8.1
  TOP w0.305: 157.99,44.32 158.55,44.88 U9625.18
  TOP w0.762: L8.1 155.86,40.21 C252.1 C242.2 155.86,43.05 157.13,44.32 v1(157.28,44.32) 157.99,44.32
SPKR_OUT_R+: length 7.6
  TOP w0.305: 162.59,46.1 162.39,46.3 U9625.25
  TOP w0.762: L10.1 162.47,40.59 C257.1 C235.2 162.59,42.8 v1(162.59,44.35) 162.59,46.1
SPKR_OUT_R-: length 7
  TOP w0.305: U9625.23 161.05,44.85 161.2,44.7
  TOP w0.762: 161.2,44.7 v1(161.2,44.02) C239.2 C12264.1 161.2,41.35 L11.1
SPKR_R+_C: length 12.1
  TOP w0.711: C259.1 v3(161.32,34.24) 160.84,34.24 159.65,33.05 157.61,33.05 156.55,31.98 SPK1.4
  TOP w0.762: C259.1 R79985.1 161.32,37.52 L10.2
  BOTTOM w0.508: v2(161.32,35.05) v3(161.32,34.24)
SPKR_R+_SNB: length 5.5
  TOP w0.508: v3(163.86,38.86) 162.97,37.97 162.97,36.7 R79985.2
  BOTTOM w0.508: C261.1 163.1,37.72 v2(164.27,37.72) 164.27,38.15 163.86,38.56 v3(163.86,38.86)
SPKR_R-_C: length 12
  TOP w0.711: SPK1.3 155.05,31.6
  TOP w0.762: 155.05,31.6 155.05,32.11 157.13,34.19 v3(159.11,34.19) 159.16,34.19 160.18,35.2 C12334.1 R79986.1 160.18,37.64 L11.2
  BOTTOM w0.508: v2(159.11,35.03) v3(159.11,34.19)
SPKR_R-_SNB: length 6.1
  TOP w0.508: v3(158.4,38.86) 158.66,38.61 R79986.2
  BOTTOM w0.508: C12265.1 v2(160.15,37.85) 159.14,38.86 v3(158.4,38.86)
SPV10: length 14.4
  TOP w0.254: v4(76.59,93.58) 76.57,93.58 76.2,93.2 GPU1.H8
  TOP w0.508: v1(71.98,81.69) L51.2 71.94,82.84 C787.1 72,83.99 C789.1 C785.1 72,86.17 72.95,87.12 v4(72.95,87.23)
  L4 w0.356: v4(76.59,93.58) 76.38,93.37 76.38,91.8 73.56,88.98 73.56,87.83 72.96,87.23 v4(72.95,87.23)
SPV18: length 12
  TOP w0.254: v4(75.79,92) 75.8,92.01 75.81,92.01 GPU1.H7
  TOP w0.508: L49.2 73.21,82.89 C788.1 73.14,83.99 C792.1 C793.1 73.14,86.32 73.74,86.92 v1(73.74,87) 73.79,86.95 v4(74.54,86.95)
  L3 w0.508: v4(75.79,92) 75.79,91.13 73.94,89.28 73.94,87.55 v4(74.54,86.95)
SST_HOLDJ_1: length 24
  TOP w0.102: SRCON1.7 44.48,128.14 44.19,128.43 44.19,131.21 45.24,132.26 57.03,132.26 v3(57.06,132.28) 57.49,132.72 58.83,132.72 59.85,133.73 R348.2 R79980.2
  BOTTOM w0.102: v2(56.24,132.28) v3(57.06,132.28)
SSTCMP: length 4.4
  BOTTOM w0.102: R45.1 31.64,26.11 v2(32.06,26.11) 32.31,26.11 33.01,25.42 U120.11
SSTCMP_1: length 2.9
  BOTTOM w0.102: R45.2 29.69,28.26 C5.1 28.81,28.45 v2(28.23,29.03)
STATUS: length 6.2
  BOTTOM w0.102: U120.8 36.23,23.19 37.63,21.79 38.97,21.79 v2(39.25,21.51) 38.63,20.89 R61.1
SUS_CLK: length 200.6
  TOP w0.102: v3(111.93,134.5) 111.91,134.5 111.41,135 111.41,147.73 104.31,154.84 103.09,154.84 R80062.2 ; v3(159.16,207.72) 157.72,209.17 155.46,209.17 146.39,218.24 131.78,218.24 129.7,216.15 R1710.1
  BOTTOM w0.102: v3(111.93,134.5) 123.31,123.11 154.94,123.11 156.09,124.27 156.09,143.82 157.93,145.66 157.93,149.4 160.1,151.57 160.1,183.65 160,183.75 160,193.73 158.83,194.89 v2(158.83,204.72) 158.83,207.39 v3(159.16,207.72)
SUS_CLK_PCH: length 8.6
  TOP w0.089: CPU1.BA17 93.86,154.43 94.12,154.17 94.56,154.17
  TOP w0.102: R80062.1 101.54,154.18 100.34,154.18 v1(100.34,154.18) 100.34,154.18 99.66,154.18 99,153.52 97.79,153.52 97.14,154.17 94.56,154.17
SUS_LED_GREEN_C: length 24.1
  TOP w0.254: v3(26.2,22.61) 27.05,21.75 PWRCN1.7 30.51,21.75 31.37,22.61 31.78,22.61 v1(32.42,23.24) 32.99,23.24 Q68.D
  L3 w0.254: v3(26.2,22.61) 26.73,22.07 26.73,13.11 v3(26.7,13.08)
  BOTTOM w0.254: v3(26.7,13.08) 26.7,13.97 R730.2 28.25,14.1 v2(28.25,13.59) 28.42,13.42 R729.2
SUS_LED_GREEN_C2: length 2.8
  BOTTOM w0.254: R735.2 29.62,16 30.16,15.47 30.16,15.32 v2(30.18,15.29) 29.7,14.81 R730.1
SUS_PWR_ACK: length 130.2
  TOP w0.102: v4(88.92,150.55) 89.25,150.87 CPU1.AP11 ; R80191.2 v3(101.63,130.81)
  L4 w0.127: v4(88.92,150.55) 89.38,150.09 91.75,150.09 94.08,147.77 94.08,146.49 100.17,140.4 100.17,137.72 100.86,137.03 100.86,131.58 v3(101.63,130.81) 104.55,130.81 106.67,132.93 108.15,132.93 109.37,131.71 111.06,131.71 111.39,131.71 128.01,115.09 134.05,115.09 137.03,115.09 140.1,118.16 141.38,118.16 141.39,118.16 141.69,118.16 v3(142.27,118.75)
  BOTTOM w0.102: R1949.2 138.98,68.9 v2(139.55,69.46) 140.75,70.66 140.75,72.91 142.04,74.2 142.04,118.52 v3(142.27,118.75)
SUS_PWR_ACK_SIO: length 4.7
  TOP w0.102: U109.13 138.21,65.91 v3(138.21,65.91)
  BOTTOM w0.102: R1949.1 v2(138.21,66.8) v3(138.21,65.91) 137.38,65.09 R79836.1
SUS_WARNB: length 131.3
  TOP w0.102: v3(100.58,130.05) 100.58,129.13 R80039.2 R80191.1 ; R1948.2 v3(146.59,71.88) ; CPU1.AR13 89.9,151.79 v4(89.57,151.46)
  L3 w0.127: v3(100.58,130.05) 100.58,133.64 98.79,135.43 98.79,138.88 98.84,138.93 98.84,143.13 91.39,150.58 91.39,150.62 90.97,151.04 89.99,151.04 v4(89.57,151.46)
  L4 w0.127: v3(100.58,130.05) 105.23,130.05 105.82,130.64 111.34,130.64 127.68,114.3 133.72,114.3 137.35,114.3 140.43,117.37 141.06,117.37 144.08,117.37 v3(145.45,118.75)
  BOTTOM w0.102: v3(145.45,118.75) 145.45,117.32 v2(145.42,117.3) 145.45,117.27 145.45,116.94 145.22,116.71 145.22,88.16 146.13,87.25 146.13,72.34 v3(146.59,71.88)
SUS_WARNB_SIO: length 11.3
  TOP w0.102: R1948.1 146.15,69.72 143.92,69.72 143.42,69.22 142.81,69.22 140.37,66.78 v1(139.23,66.78) 138.72,66.27 138.72,65.66 138.61,65.55 U109.12
SUSCLK_NGFF: length 5.5
  TOP w0.102: NGFF1.50 120.37,217 v1(120.48,216.89) 120.59,216.78 122.39,216.78 123.02,216.15 R1710.2
SW_ON_N_SIO: length 8.3
  TOP w0.102: R334.1 126.08,47.94 v1(126.14,47.88) 126.21,47.94 R277.2 127.55,47.5 130.94,47.5 131.53,48.08 132.01,48.08 132.21,48.28 U109.69
SYS_3VSB: length 4.7
  TOP w0.102: v3(131.35,50.42) 131.41,50.36 U109.67
  BOTTOM w0.102: R79930.1 130.34,49.09 130.34,50.45 v2(130.59,50.7) 131.07,50.7 v3(131.35,50.42)
SYS_FAN_TACH1_1: length 4.3
  TOP w0.102: FANC3.3 16.91,209.73 R76.2 R80.2
SYS_FAN_TACH1_2: length 4.3
  TOP w0.102: v1(18.55,207.44) 17.83,207.44 R73.2 R76.1 18.21,209.11 18.59,208.72 R74.2
SYS_PRES: length 4.8
  TOP w0.102: BAT2.7B 34.3,61.89 R79647.2 35.35,62.67 v1(36.13,61.9)
SYS_PWROK: length 338.3
  TOP w0.102: CPU1.B6 72.39,147.27 71.13,147.27 70.75,146.88 70.75,146.46 70.8,146.41 70.8,145.57 70.54,145.31 70.54,142.4 70.08,141.94 69.46,141.94 68.77,141.25 67.99,141.25 66.52,139.78 R80033.1 66.34,139.27 58.93,139.27 54.74,135.08 44.94,135.08 v3(42.96,133.1) ; R9908.1 48.72,223.96 48.72,225.37 v3(48.67,225.43) ; R80192.1 136.43,72.07 136.72,72.36 139,72.36 v3(139.23,72.14)
  L3 w0.127: v3(42.96,133.1) 40.01,136.04 24.17,136.04 17.07,143.14 17.07,150.4 12.76,154.72 12.76,183.4 13.41,184.05 13.41,186.43 15.27,188.29 15.27,220.69 16.87,222.29 27.53,222.29 29.18,223.94 33.39,223.94 33.73,224.28 47.53,224.28 v3(48.67,225.43)
  L4 w0.127: v3(42.96,133.1) 45.54,130.52 71.91,130.52 72.35,130.07 72.4,130.07 83.57,118.91 93.92,118.91 94.61,119.6 112.27,119.6 115.35,116.52 115.35,110.48 118.59,107.24 124.21,107.24 124.93,106.51 140.03,106.51 v3(140.88,105.66)
  BOTTOM w0.102: v3(140.88,105.66) 140.88,103.38 v2(141.08,103.17) 141.33,102.92 141.33,74.5 139.68,72.85 139.68,72.59 v3(139.23,72.14)
SYSTEM_FAN_PWM1_1: length 17.3
  TOP w0.102: R71.2 12.23,219.52 R68.2 13.75,219.46 D1.A 13.88,219.07 12.1,217.3 12.1,207.52 12.43,207.19 FANC3.4
TCK: length 6.8
  TOP w0.102: v3(96.65,63.78) 93.27,63.78 92.12,62.64 U4101.27
  BOTTOM w0.102: v3(96.65,63.78) 96.3,63.42 TP4130.1
TDI: length 2.9
  TOP w0.102: v3(92.24,60.5) 92.69,60.96 92.7,60.96 92.92,61.18 U4101.25
  BOTTOM w0.102: TP4128.1 91.73,61.01 v3(92.24,60.5)
TDO: length 2.5
  TOP w0.102: U4101.24 93.32,60.83 v3(93,60.5)
  BOTTOM w0.102: TP4127.1 v3(93,60.5)
TESTEN: length 6.8
  TOP w0.356: GPU1.K7 77.86,92.4 v4(78.22,92.03)
  BOTTOM w0.508: v4(78.22,92.03) 78.96,91.29 v2(78.96,90.91) R1897.1 79.03,87.19 R302.1
THERMAL_SHUT#_SIO: length 323.3
  TOP w0.102: R80256.2 81.76,221.93 82.2,222.38 Q9642.C 82.2,227.13 83.16,228.08 111.12,228.08 112.27,226.94 150.54,226.94 v3(164.5,212.98)
  L4 w0.127: v3(85.76,74.96) 85.76,73.41 87.49,71.68 88.88,71.68 92.29,68.28 92.57,68.28 92.57,68.27 93.41,68.27 93.41,68.28 97.59,68.28 101.07,64.8 101.79,64.8 102.12,64.47 130.54,64.47 130.83,64.76 133.76,64.76 134.78,65.77 v3(134.78,65.91)
  BOTTOM w0.102: R1920.1 87.54,78.79 85.76,77.01 v3(85.76,74.96) ; v3(134.78,65.91) 134.78,66.21 140.37,71.8 140.37,73.03 141.69,74.35 141.69,119.57 143.23,121.11 155.76,121.11 158.76,124.1 158.76,144.8 159.13,145.16 159.13,148.9 161.3,151.08 161.3,184.15 161.25,184.2 161.25,200.46 160.82,200.89 160.82,209.3 v2(163.01,211.49) v3(164.5,212.98)
THERMTRIP#_CPU: length 6
  TOP w0.089: CPU1.C63 72.65,180.09 72.42,180.09 72.34,180.01 71.92,180.01 71.8,179.96 71.79,179.96 70.9,179.96 70.86,179.99
  TOP w0.102: 70.86,179.99 70.37,180.49 v4(69.91,180.49) 69.03,180.49 R420.2
  BOTTOM w0.102: v2(69.12,180.49) v4(69.91,180.49)
THERMTRIP#_EC: length 54.8
  TOP w0.102: Q9642.E 83.19,222.6 82.65,222.06 R80256.1 82.09,221.06 80.74,221.06 79.5,219.81 79.5,218.56 77.2,216.26 v1(77.2,212.9) 77.2,209.6 78.8,208 v3(78.8,206.78) ; v3(64.42,182.12) 65.37,181.17 R419.2 65.7,181.18 67.46,181.18 R420.1
  L3 w0.127: v3(78.8,206.78) 76.17,204.16 76.17,201.83 63.93,189.59 63.93,182.61 v3(64.42,182.12)
THERMTRIP#_EC_N: length 7.7
  TOP w0.152: Q9642.B 81.22,222.28 v1(77.76,218.82) 77.58,218.82 76.26,220.14 R80158.2
TMDS_3V3: length 29.1
  TOP w0.102: SCA1.1 68.99,55.12 69.55,54.56 71.9,54.56 C12187.1 ; C12187.1 71.7,53.95 70.62,53.95 v3(70.14,53.47) ; C12187.1 72.42,54.67 C12185.1 72.42,55.69 R9531.1 ; SCA1.20 68.18,65.4 67.6,64.82 67.6,63.75 66.81,62.97 v3(66.81,61.87)
  BOTTOM w0.102: L9502.2 66.94,51.59 68.26,51.59 v3(70.14,53.47) 70.14,54.86 69.63,55.37 v2(69.63,57.81) 68.65,57.81 C12186.1 67.93,58.53 67.93,61.01 67.54,61.39 67.29,61.39 66.81,61.87 v3(66.81,61.87)
TMS: length 7.2
  TOP w0.102: U4101.26 92.52,62.62 93.2,63.3 96.93,63.3 v3(97.42,63.78)
  BOTTOM w0.102: v3(97.42,63.78) 97.57,63.63 TP4129.1
TP1_AY4: length 16.6
  TOP w0.089: CPU1.AY4 93.44,146.33 93.73,146.33 94.01,146.05 94.01,145.68 94.22,145.47 94.44,145.47 95.28,144.62 95.28,144.4
  TOP w0.102: TP610.1 100.03,133.86 98.1,135.79 98.1,139.69 95.54,142.25 95.54,144.15 95.28,144.4
TP2_BB3: length 13.6
  TOP w0.102: TP611.1 99.21,135 98.33,135.88 98.33,139.78 95.92,142.19 95.92,144.25 94.36,145.8 CPU1.BB3
TP4_BB5: length 16
  TOP w0.102: TP609.1 100.87,135.64 100.62,135.64 99.04,137.21 99.04,140.08 97.05,142.07 97.05,143.9 95.14,145.82 95.14,146.83 94.75,147.21 CPU1.BB5
TP5_AU5: length 20.8
  TOP w0.089: CPU1.AU5 91.24,147.35 92.2,146.39 93.09,146.39 93.36,146.11 93.36,145.88 93.61,145.63 93.79,145.63 93.99,145.44 93.99,145.01 94.41,144.58
  TOP w0.102: 94.41,144.58 95.03,143.97 95.03,142.44 97.87,139.59 97.87,135.69 100.34,133.22 100.77,133.22 101.13,132.87 101.13,132.46 TP607.1
TP6_AT5: length 1.6
  TOP w0.102: CPU1.AT5 90.55,147.48 v4(90.87,147.8)
  BOTTOM w0.102: v4(90.87,147.8) 90.97,147.7 TP608.1
TP3131_GVDD: length 6.1
  TOP w0.203: C12266.2 160.69,55.44 R396.1 162.34,53.78 R398.2 162.57,53.12 v1(162.25,52.8) 162.24,52.79 162.24,52.78 161.63,52.17 161.25,52.17 161.05,51.97 U9625.2
TP_DDPC_CTRLDATA: length 3.6
  TOP w0.102: v4(79.13,148.38) 78.94,148.38 CPU1.N8
  BOTTOM w0.102: TP9919.1 78.74,145.83 78.74,147.98 v4(79.13,148.38)
TP_DET: length 156.6
  TOP w0.102: U109.118 143.38,58.97 142.93,59.41 v3(142.93,59.44) ; v1(26.65,3.38) 26.65,10.45 v3(26.7,10.5) TOUCH1.1
  L3 w0.127: v3(126.14,40.13) 128.43,42.42 134.04,42.42 137.39,45.77 138.83,45.77 142.78,49.72 142.78,51.32 144.01,52.55 144.01,58.26 142.93,59.34 v3(142.93,59.44)
  L4 w0.127: v3(26.7,10.5) 28.86,10.5 30.94,12.59 30.94,13.49 33.75,16.29 35.25,16.29 37.75,18.8 42.71,18.8 43.68,19.77 44.78,19.77 45.51,19.03 57.04,19.03 63.24,25.23 69.27,25.23 70.07,24.43 86.14,24.43 86.94,25.23 105.13,25.23 114.6,34.71 116.63,34.71 118.37,36.45 122.28,36.45 122.66,36.83 123.13,36.83 126.14,39.84 v3(126.14,40.13)
  BOTTOM w0.102: R1785.2 26.79,10.41 v3(26.7,10.5)
TP_GPU_CLKREQ#: length 3.9
  TOP w0.102: v4(80.68,92.71) 80.37,92.4 GPU1.N7
  BOTTOM w0.102: TP158.1 81.82,90.25 81.82,91.42 81.32,91.91 81.32,92.06 v4(80.68,92.71)
TP_L_BKLTEN: length 5.8
  TOP w0.102: CPU1.R12 79.85,151.32 v4(80.2,150.97)
  BOTTOM w0.102: v4(80.2,150.97) 80.86,150.31 80.86,147.22 80.68,147.04 TP9904.1
TP_L_VDDEN: length 2
  TOP w0.102: v4(81.26,151.52) 80.81,151.97 CPU1.U13
  BOTTOM w0.102: TP9905.1 81.3,151.52 v4(81.26,151.52)
TP_NGFF_COEX1: length 5.6
  TOP w0.102: TP39.1 123.35,215.14 122.19,216.29 120.1,216.29 119.9,216.5 NGFF1.48
TP_NGFF_COEX2: length 4.1
  TOP w0.102: NGFF1.46 121.47,216 TP38.1
TP_NGFF_COEX3: length 2.6
  TOP w0.102: TP196.1 120.7,215.5 NGFF1.44
TP_NGFF_LED1: length 2.5
  TOP w0.102: TP63.1 120.05,206 NGFF1.6
TP_NGFF_LED2: length 4.2
  TOP w0.102: NGFF1.16 120.08,208.5 120.45,208.13 121.93,208.13 TP64.1
TP_NGFF_MLDIR: length 4.2
  TOP w0.102: TP62.1 107.6,207.9 108.49,207.9 109.34,208.75 NGFF1.17
TP_PMODE_XDP_RST_R_N: length 5.6
  TOP w0.102: XDP1.46 30.83,222.78 v3(30.73,222.88)
  BOTTOM w0.102: R9933.1 R9930.2 30.96,223.96 v2(31,223.93) 31.07,223.85 31.07,223.22 v3(30.73,222.88)
TP_SIO_VIN2: length 11.2
  TOP w0.102: U109.93 141.81,48.21 142.37,47.65 142.86,47.65 143.11,47.4 144.71,47.4 145.51,46.6 145.51,46.46 145.89,46.08 C12385.1 R80250.1 146.21,43.37 TP107.1 146.15,42.55 R80251.1
TPA3113_SD: length 11.2
  BOTTOM w0.152: Q9622.6 156.16,41.26 155.89,41.53 155.89,42.64 156.21,42.97 v2(158.96,42.97) 159.63,42.97 159.67,42.93 161.01,42.93 R390.2 R79871.1 163.04,43.94 Q12.G
TPA3113_SD1#: length 19.6
  TOP w0.152: U9625.29 162.85,49.15 162.95,49.05 163.63,49.05 v3(164.12,49.53)
  BOTTOM w0.152: Q12.D 164.94,45.02 164.43,44.51 R79919.1 ; Q12.D 162.59,46.23 162.21,45.85 162.21,44.7 161.96,44.45 R79984.2 ; Q12.D 164.94,47.88 R381.1 164.18,49.47 v3(164.12,49.53) 164.96,50.37 v2(164.96,50.85) 164.96,51.36 163.86,52.45 C245.1 163.01,52.55 Q9626.G
TPA3131_BSNL: length 4.5
  TOP w0.305: C242.1 158.17,43.46 v1(158.45,43.46) 159.05,44.06 U9625.19
TPA3131_BSNR: length 4
  TOP w0.305: C239.1 159.67,44.11 159.75,44.19 v1(159.75,44.2) 159.75,44.2 160.55,44.99 U9625.22
TPA3131_BSPL: length 7.3
  TOP w0.305: U9625.15 156.52,47.65 156.12,47.24
  TOP w0.508: 156.12,47.24 156.12,46.49 154.2,44.58 153.78,44.58 v1(153.2,43.99) C244.1
TPA3131_BSPR: length 6.2
  TOP w0.305: U9625.26 163.21,47.65 163.48,47.37 163.48,44.45
  TOP w0.508: 163.48,44.45 163.99,43.94 v1(163.99,43.87) C235.1
TPA3131_FAULT#: length 4
  TOP w0.102: U9625.30 163.24,49.65 v3(163.36,49.53)
  BOTTOM w0.102: v3(163.36,49.53) 162.92,49.53 v2(162.03,48.64) R381.2
TPA3131_GAIN: length 4.8
  TOP w0.203: U9625.3 160.55,52.11 161.11,52.67 v1(161.11,53.59) 161.11,54.13 R396.2 160.31,54.61 159.89,55.03 R79988.1
TPA3131_LINN: length 3.5
  TOP w0.203: U9625.5 159.55,53.1 v1(159.58,53.13) 158.4,54.3 C240.2
TPA3131_LINN_1: length 2.7
  TOP w0.203: R387.2 158,56.41 C240.1 158.45,55.96 159.39,55.96 v1(159.57,56.13)
TPA3131_MUTE: length 5.3
  TOP w0.203: U9625.7 158.55,52.05 v3(158.15,52.45)
  BOTTOM w0.203: R79989.2 156.46,52.48 v2(157.28,52.48) 157.31,52.45 v3(158.15,52.45) R388.1 158.21,51.56 Q9626.D
TPA3131_PLIMIT: length 6.4
  TOP w0.203: U9625.1 161.88,51.49 v1(163.53,53.13) 163.66,53.26 R79987.2 163.08,54.17 R398.1 161.86,55.38 C250.2
TPA3131_RINN: length 7.1
  TOP w0.203: U9625.32 162.39,51.16 162.59,51.36 162.83,51.36 164.8,53.33 v1(164.8,53.49) 164.8,55.12 C236.2
TPA3131_RINN_1: length 2.7
  TOP w0.203: v1(165.82,54.89) 165.82,54.93 165.39,55.36 165.26,55.49 C236.1 R382.2
TPA3131_SYNC: length 2.9
  TOP w0.102: U9625.11 156.37,49.65 155.61,50.41 TP109.1
TSVDD: length 7.7
  TOP w0.254: GPU1.AD17 89,101 v4(88.73,101.27)
  BOTTOM w0.254: L47.2 94.08,100.46 v2(93.48,100.46) 93.07,100.46 92.01,101.52 C758.1 C759.1 89.98,101.27 v4(88.73,101.27)
USB2_C_N1: length 10.2
  TOP w0.102: 164.55,105.07 165.3,105.07 165.7,104.67 166.54,104.67 166.77,104.43 TR5205.4 ; 164.55,105.07 v1(164.55,104.72) ; 164.55,105.07 160.65,105.07 159.74,104.16 159.03,104.16 158.63,103.76 R80101.1
USB2_C_P1: length 10.3
  TOP w0.102: R80100.1 158.63,104.78 159.03,104.37 159.65,104.37 160.56,105.28 161.15,105.28 ; 161.15,105.28 165.39,105.28 165.79,104.88 166.54,104.88 166.77,105.12 TR5205.1 ; 161.15,105.28 v1(161.15,105.64)
USB2_IN_N1: length 4.1
  BOTTOM w0.102: 165.18,104.16 164.64,104.16 164.5,104.02 U9628.11 ; 165.18,104.16 v2(165.18,103.86) ; 165.18,104.16 165.46,104.16 165.97,104.67 166.54,104.67 166.77,104.43 TR4.1
USB2_IN_P1: length 4.1
  BOTTOM w0.102: U9628.10 164.5,104.52 164.64,104.37 165.37,104.37 165.88,104.88 166.07,104.88 ; 166.07,104.88 166.54,104.88 166.77,105.12 TR4.4 ; 166.07,104.88 v2(166.07,105.18)
USB2_N0: length 116.1
  TOP w0.102: CPU1.AB9 83.06,149.37 v4(83.38,149.04) ; 158.22,112.15 162.94,112.15 165.11,109.98 165.11,108.33 166.4,107.04 166.76,107.04 167.07,106.72 TR3.4 ; 158.22,112.15 v1(158.22,111.79) ; 158.22,112.15 157.58,112.15 156.13,113.6 156.07,113.66 156.07,114.22 155.86,114.43 v3(155.85,114.43)
  L3 w0.089: 84.03,146.41 84.03,146.43 84.07,146.47 84.07,147.08 83.85,147.29 83.85,149.15 83.81,149.19 83.7,149.3 83.46,149.3 83.38,149.23 v4(83.38,149.04)
  L3 w0.127: 84.03,146.41 84.03,146.16 83.81,145.94 83.81,136.16 84.48,135.5 84.48,130.87 85,130.35 95.36,119.99 113.32,119.99 113.8,119.51 125.61,119.51 127.44,117.67 155.03,117.67 155.86,116.84 155.86,114.44 v3(155.85,114.43)
USB2_N1: length 115
  TOP w0.102: CPU1.AD6 84.27,147.41 v4(84.46,147.6) ; R80101.2 156.5,103.76 v3(156.37,103.89)
  L3 w0.089: v4(84.46,147.6) 84.64,147.78 84.82,147.78 84.95,147.65 84.95,146.2 84.91,146.17 84.91,146.15
  L3 w0.127: v3(156.37,103.89) 156.12,104.13 155.62,104.13 155.19,104.56 155.19,106.26 156.17,107.24 156.17,109.14 157.63,110.6 157.63,118.25 156.44,119.45 126.71,119.45 125.89,120.27 114.33,120.27 113.9,120.7 95.64,120.7 85.19,131.16 85.19,140.86 84.53,141.52 84.53,145.2 84.91,145.58 84.91,146.15
  BOTTOM w0.102: v2(155.56,103.66) 156.14,103.66 v3(156.37,103.89) 156.5,103.76 R80101.2
USB2_N2: length 221.4
  TOP w0.089: v4(85.35,143.77) 85.57,143.54 85.89,143.54 86.06,143.72 86.06,144.79 86,144.92 86,145.07 86.02,145.11 86.07,145.25 86.07,145.44 86,145.57 86,145.72 86.02,145.76 86.02,145.77 86.07,145.9 86.07,145.9 86.1,145.97 86.45,146.31 CPU1.AH3
  TOP w0.102: TR7.1 105.78,37.81 v3(105.82,37.85)
  L3 w0.127: v4(85.35,143.77) 85.61,143.5 85.72,143.5 86.15,143.07 86.15,131.56 96.04,121.67 114.58,121.67 114.95,121.3 126.23,121.3 127.03,120.5 157.03,120.5 158.59,118.93 158.59,95.03 158.44,94.87 148.1,84.54 148.1,68.45 145.08,65.43 145.08,48.62 139.44,42.98 136.38,42.98 135.17,41.77 135.17,39.79 133.37,37.99 128.94,37.99 128.62,38.3 120.69,38.3 119.38,39.61 114.94,39.61 113.29,41.26 106.29,41.26 105.49,40.46 105.49,38.18 v3(105.82,37.85)
  BOTTOM w0.102: v2(105.8,36.96) 105.8,37.03 105.82,37.06 v3(105.82,37.85)
USB2_N3: length 223.9
  TOP w0.102: CPU1.AD9 84.23,149.37 v4(84.46,149.59) ; TR5.4 107.26,37.81 v3(107.22,37.85)
  L3 w0.089: 85.95,146.26 85.95,146.28 85.99,146.32 85.99,148.21 84.9,149.3 84.9,149.78 84.79,149.89 84.56,149.89 84.46,149.78 v4(84.46,149.59)
  L3 w0.127: 85.95,146.26 85.95,144.65 86.58,144.02 86.58,131.92 96.4,122.1 114.79,122.1 115.1,121.79 126.65,121.79 127.16,121.28 156.87,121.28 159.02,119.13 159.02,94.83 149.26,85.07 149.26,68.32 147.1,66.16 147.1,65.91 145.58,64.39 145.58,48.5 139.62,42.55 136.56,42.55 135.81,41.8 135.81,39.76 133.52,37.48 128.79,37.48 128.53,37.74 123.24,37.74 122.21,36.72 121.15,36.72 119.24,38.62 114.6,38.62 112.89,40.33 112.73,40.49 108.95,40.49 107.63,39.16 107.63,38.25 v3(107.22,37.85)
  BOTTOM w0.102: v4(84.46,149.59) 84.6,149.59 v2(85.33,148.87)
USB2_N4: length 163.6
  TOP w0.102: v1(159.93,184.45) 159.93,184.11 ; 159.93,184.11 164.92,184.11 165.55,184.75 165.55,188.88 164.39,190.04 164.39,190.51 164.16,190.74 TR1.1 ; 159.93,184.11 158.87,184.11 158.42,183.67 158.42,182.77 v3(158.15,182.5) ; CPU1.AJ1 87.32,144.69 88.39,143.62 88.39,143.02 88.2,142.82 88.04,142.82 87.92,142.95 87.92,143.59 87.75,143.75 87.52,143.75 v4(87.28,143.51)
  L3 w0.127: v3(158.15,182.5) 158.4,182.25 158.4,181.8 159,181.19 159,127.65 154.67,123.31 127.54,123.31 127.17,123.68 116,123.68 115.84,123.84 97.17,123.84 89.07,131.94 89.07,141.46 87.7,142.83 87.7,143.37 87.56,143.51 v4(87.28,143.51)
USB2_N5: length 214.2
  TOP w0.102: v3(44.86,111.12) 44.61,111.38 41.11,111.38 40.29,110.57 40.29,78.69 37.99,76.39 34.51,76.39 33.82,77.09 31.78,77.09 31.53,76.83 31.53,76.07 27.85,72.39 27.08,72.39 26.07,71.37 26.07,55.63 26.87,54.83 27.5,54.83 30.89,51.44 30.89,46.86 27.72,43.69 26.58,43.69 26.36,43.47 23.95,43.47 23.27,42.8 23.27,40.64 22,39.37 22,18.94 24.92,16.03 28.33,16.03 29.54,14.82 31.49,14.82 31.76,14.55 31.76,14.07 TR9.4 ; v4(85.54,147.15) 85.44,147.15 85.18,147.41 CPU1.AF6
  L3 w0.127: v3(83.83,120.32) 83.4,120.32 83.2,120.12 77.92,120.12 70.8,127.24 53.22,127.24 45.77,119.79 45.77,111.65 45.48,111.37 45.11,111.37 v3(44.86,111.12)
  BOTTOM w0.102: v4(85.54,147.15) 85.54,147.29 85.42,147.42 85.2,147.42 85.03,147.26 85.03,146.6 86.75,144.88 86.75,136.09 ; 86.75,136.09 86.75,134.98 88.27,133.45 88.27,129.69 89.06,128.91 89.06,126.24 84.2,121.37 84.2,121.12 83.7,120.62 83.7,120.45 v3(83.83,120.32) ; 86.75,136.09 v2(87.1,136.09)
USB2_N6: length 215.4
  TOP w0.102: 124.09,199.52 142.38,199.52 145.04,196.85 146.64,196.85 146.93,197.14 146.93,197.45 v3(147.23,197.74) ; 124.09,199.52 v1(124.09,199.14) ; 124.09,199.52 120.3,199.52 118.37,197.59 109.1,197.59 108.79,197.9 TR12.4 ; CPU1.AH1 86.47,145 86.56,144.91 86.56,142.81 85.91,142.16 85.91,141.21 86.16,140.96 87.27,140.96 v4(87.28,140.97)
  L3 w0.127: v3(147.23,197.74) 146.98,197.5 146.98,197.34 147.25,197.07 152.47,197.07 155.49,194.04 155.49,191.63 159.98,187.14 159.98,127.15 154.98,122.15 127.31,122.15 126.91,122.56 115.48,122.56 115.16,122.87 96.74,122.87 88.02,131.59 88.02,140.97 87.84,141.15 87.44,141.15 87.28,141 v4(87.28,140.97)
USB2_NGFF_N6: length 8.8
  TOP w0.102: TR12.3 108.79,200.92 107.86,201.85 ; v1(107.55,201.55) 107.86,201.85 ; 107.86,201.85 107.62,202.09 107.62,204.79 108.43,205.61 109.36,205.61 109.5,205.75 NGFF1.5
USB2_NGFF_P6: length 8.7
  TOP w0.102: 107.84,203.84 107.84,204.7 108.52,205.39 109.36,205.39 109.5,205.25 NGFF1.3 ; 107.84,203.84 v1(108.24,203.84) ; 107.84,203.84 107.84,202.18 108.98,201.03 109.23,201.03 109.47,200.8 TR12.2
USB2_OUT_N1: length 3.8
  BOTTOM w0.102: U9628.2 160.18,104.02 160.04,104.16 158.61,104.16 R80116.1 158.21,102.81 v2(158.28,102.74)
USB2_OUT_P1: length 3.1
  BOTTOM w0.102: 159.29,104.37 158.61,104.37 R80115.1 ; 159.29,104.37 v2(159.29,104.7) ; 159.29,104.37 160.04,104.37 160.18,104.52 U9628.3
USB2_P0: length 116.1
  TOP w0.102: CPU1.AB10 83.09,150.02 v4(83.38,149.72) ; v3(156.61,114.45) 156.28,114.12 156.28,113.75 157.67,112.37 163.03,112.37 165.32,110.07 165.32,109.37 ; TR3.1 166.95,107.4 166.8,107.25 166.49,107.25 165.32,108.42 165.32,109.37 ; v1(165.72,109.37) 165.32,109.37
  L3 w0.089: v4(83.38,149.72) 83.61,149.49 83.78,149.49 84.04,149.22 84.04,147.37 84.26,147.16 84.26,146.47 84.3,146.43 84.3,146.41
  L3 w0.127: v3(156.61,114.45) 156.13,114.93 156.13,116.95 155.14,117.94 127.55,117.94 125.72,119.77 113.91,119.77 113.43,120.26 95.47,120.26 84.74,130.98 84.74,135.61 84.08,136.27 84.08,145.83 84.3,146.05 84.3,146.41
