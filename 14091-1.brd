# Allegro board 14091-1.brd (continued)
## Nets (continued)
VCC5_PANEL: C4254.2 C6716.2 C6717.1 F2.2 LVDS1.2 LVDS1.3 Q9647.S R2.2 R79687.1 R79690.1 R80239.1
VCC5_USB: C249.2 C1769.1 F14.1 F15.1 F17.1 Q43.1 Q43.2 Q43.3 R1729.1 R1782.1 R80104.1
VCC_CORE: C1039.1 C1040.1 C1041.1 C1042.1 C1043.1 C1044.1 C1045.1 C1046.1 C1047.1 C1048.1 C1049.1 C1050.1 C1051.1 C1052.1 C1053.1 C1054.1 C1055.1 C12382.1 CPU1.A30 CPU1.A34 CPU1.A39 CPU1.A44 CPU1.AK33 CPU1.AK35 CPU1.AK37 CPU1.AK38 CPU1.AK40 CPU1.AL33 CPU1.AL37 CPU1.AL40 CPU1.AM32 CPU1.AM33 CPU1.AM35 CPU1.AM37 CPU1.AM38 CPU1.G30 CPU1.G32 CPU1.G33 CPU1.G35 CPU1.G37 CPU1.G38 CPU1.G40 CPU1.G42 CPU1.J30 CPU1.J33 CPU1.J37 CPU1.J40 CPU1.K33 CPU1.K35 CPU1.K37 CPU1.K38 CPU1.K40 CPU1.K42 CPU1.K43 G1.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1036.1 PC1037.1 PC1038.1 PC1076.1 PC12370.1 PC12371.1 PC12372.1 PC12373.1 PC12374.1 PC12375.1 PC12376.1 PC12377.1 PC12378.1 PC12379.1 PC12380.1 PC12381.1 PC12382.1 PC12383.1 PC12384.1 PC12385.1 PC12386.1 PC12387.1 PC12388.1 PC12389.1 PC12390.1 PC12391.1 PC12392.1 PC12393.1 PG4702.2 PL4701.2 PT4701.1 PT4703.1 R80017.1
VCC_FAN: C48.1 F5.2 FANC3.2 R80.1 R101.2
VCC_VTT: PC5104.1 PC5113.1 PR8506.2 PR8507.2 PU5104.2 PU5104.20
VCCCORE_SENSE: CPU1.E32 PG4607.2 R80017.2
VCCCOREG0: CPU1.K32 TP701.1
VCCCOREG1: CPU1.AK32 TP702.1
VCCGT_SENSE: CPU1.J70 PG4601.2 R80016.2
VCCIO_EN_C_1: Q9634.G Q9635.6 R80159.1
VCCIO_EN_C_2: Q9635.2 R80126.2
VCCIO_EN_C_3: PC12440.1 Q9635.5 R80127.2 R80243.1
VCCIO_EN_C_4: PR8509.2 Q9635.1 Q9635.3
VCCIO_VR_FB: CPU1.AM23 R80020.2
VCCK_1V2: C12169.1 C12183.2 C12195.1 C12196.1 L9504.2 L9523.1 SCA1.60 SCA1.73 SCA1.120
VCCRTCEXT: C2112.1 CPU1.BB10
VCCSA_SENSE: CPU1.H20 PG4603.2 R80022.2
VCCSENSE_EDRAM_VR: CPU1.AC63 R80012.2
VCCSENSE_EOPIO_VR: CPU1.AL63 R80014.2
VCCST_GD_1: Q9654.2 R80252.2
VCCST_GD_2: Q9654.5 Q9654.6 R80253.1
VCCST_GD_CPU: CPU1.B65 R80044.2
VCCST_GD_R: Q9654.3 R9903.1 R80043.2 R80044.1 U9626.4
VCCSTG_EN: D5212.1 PC12439.1 Q9634.D R80160.1 U704.4
VCCSTU_EN: D5212.2 PC12441.1 Q9652.D R80245.1 U706.4
VCCSTU_EN_C_1: Q9652.G Q9653.6 R80244.1
VCCSTU_EN_C_2: Q9653.2 R80247.2
VCCSTU_EN_C_3: PC12442.1 Q9653.5 R80246.1
VCCSTU_EN_C_4: PR8527.2 Q9653.1 Q9653.3
VDDC_CT: C779.1 C780.1 C781.1 GPU1.AA20 GPU1.AA21 GPU1.AB20 GPU1.AB21 L48.2
VSS_AY3: CPU1.AY3 R606.2
VSS_AY71: CPU1.AY71 R602.2
VSS_MECH: GPU1.A32 GPU1.AM1 GPU1.AM32
VSSCORE_SENSE: CPU1.E33 PG4606.2 R80015.1
VSSGT_SENSE: CPU1.J69 PG4604.2 R80018.1
VSSIO_VR_FB: CPU1.AM22 R80019.1
VSSSA_SENSE: CPU1.H21 PG4602.2 R80021.1
VSSSENSE_EDRAM_VR: CPU1.AE63 R80011.1
VSSSENSE_EOPIO_VR: CPU1.AJ62 R80013.1
0D95V_VGA_PWR: PC8403.1 PC8404.1 PC8405.1 PG8401.1 PG8403.1 PG8405.1 PL8401.2
0D95V_VGA_S0: C798.1 C799.1 C800.1 C801.1 C802.1 C803.1 C804.1 GPU1.L23 GPU1.L24 GPU1.L25 GPU1.L26 GPU1.M22 GPU1.N22 GPU1.N23 GPU1.N24 GPU1.R21 GPU1.R22 GPU1.T22 GPU1.U21 GPU1.U22 GPU1.V22 L51.1 L53.1 PG8403.2 PG8405.2 R1161.2 R1162.2
1D0V_S5: C747.1 C749.1 PC5209.1 PG5202.1 PL5201.2 PT5202.1 PT5203.1 R1112.1 R1114.1 R1120.1 R1121.1 R1122.1 R1125.1 R1130.1 R1131.1 R1132.1 R1133.1 R1134.1 R1136.1 R9901.1 R80023.1 R80053.1 U704.1 U704.2 U704.9 U706.1 U706.2 U706.9
1D8V_EDRAM: CPU1.G61 CPU1.H63 R80010.2
1D8V_S0: C316.2 R542.2 R80010.1 U105.4
1D8V_S5: PC5225.2 PC5226.1 PC5227.1 PR1689.1 PU5302.3 PU5302.4 R1111.1 R1118.1 R1128.1 R1129.1 R1138.1 R2107.2 U105.1 U105.2 U105.5 U105.6
1D8V_SIP_S5: C2108.1 CPU1.AA1 R2107.1
1D8V_VCCPGPPF: CPU1.AF16 R1138.2
1D8V_VGA_S0: C794.1 C795.1 C796.1 C797.1 GPU1.AM30 L47.1 L48.1 L49.1 L50.1 L52.1 PC8501.1 PC12186.1 PR5309.2 PR5310.2 PR5311.2 PU8501.5 PU8501.9 R935.1 R943.2 R1211.2 R1900.2 R80083.2
1D35V_S3: C501.1 C705.1 C706.1 C707.1 C708.1 C709.1 C710.1 C742.1 C743.1 C744.1 C745.1 C1207.1 C1208.1 C1209.1 C1212.1 C1213.1 C1219.1 C1223.1 C1224.1 C1225.1 C1226.1 C1227.1 C1228.1 C1229.1 C1230.1 C1231.1 C1232.1 C1233.1 C1234.1 C1235.1 C1236.1 C1239.1 C1240.1 C1241.1 C1245.1 C1246.1 C1312.1 C1313.1 C1314.1 C1315.1 C1316.1 C1317.1 C1318.1 CPU1.AU23 CPU1.AU28 CPU1.AU35 CPU1.AU42 CPU1.BB23 CPU1.BB32 CPU1.BB41 CPU1.BB47 CPU1.BB51 DIMM1.75 DIMM1.76 DIMM1.81 DIMM1.82 DIMM1.87 DIMM1.88 DIMM1.93 DIMM1.94 DIMM1.99 DIMM1.100 DIMM1.105 DIMM1.106 DIMM1.111 DIMM1.112 DIMM1.117 DIMM1.118 DIMM1.123 DIMM1.124 DIMM2.75 DIMM2.76 DIMM2.81 DIMM2.82 DIMM2.87 DIMM2.88 DIMM2.93 DIMM2.94 DIMM2.99 DIMM2.100 DIMM2.105 DIMM2.106 DIMM2.111 DIMM2.112 DIMM2.117 DIMM2.118 DIMM2.123 DIMM2.124 PC701.1 PC702.1 PC703.1 PC5109.1 PC12434.1 PC12435.1 PC12436.1 PC12437.1 PC12438.1 PL5101.2 PR5108.1 PR5116.1 PR5122.1 PT5101.1 PT5102.1 R705.1 R1212.1 R1218.1 R1304.1 R80026.2 R80074.1 R80243.2 R80246.2 U501.5
1D35V_VCCSFR_OC: C718.1 CPU1.AL23 R80026.1
1D35V_VDDQ_CPUCLK: C715.1 C719.1 CPU1.AM40 R705.2
1D35V_VGA_S0: C186.1 C214.1 C216.1 C486.1 C489.1 C500.1 C514.1 C540.1 C557.1 C612.1 C616.1 C623.1 C627.1 C765.1 C766.1 C767.1 C768.1 C769.1 C770.1 C771.1 C772.1 C773.1 C774.1 C775.1 C776.1 C777.1 C778.1 C1851.1 C1852.1 C1853.1 C1856.1 C1857.1 C1858.1 C1859.1 C6710.1 C6711.1 GPU1.H13 GPU1.H16 GPU1.H19 GPU1.J9 GPU1.J10 GPU1.J23 GPU1.J24 GPU1.K9 GPU1.K10 GPU1.K23 GPU1.K24 GPU1.L11 GPU1.L12 GPU1.L13 GPU1.L20 GPU1.L21 GPU1.L22 MEM1.A1 MEM1.A8 MEM1.B2 MEM1.C1 MEM1.C9 MEM1.D2 MEM1.D9 MEM1.E9 MEM1.F1 MEM1.G7 MEM1.H2 MEM1.H9 MEM1.K2 MEM1.K8 MEM1.N1 MEM1.N9 MEM1.R1 MEM1.R9 MEM2.A1 MEM2.A8 MEM2.B2 MEM2.C1 MEM2.C9 MEM2.D2 MEM2.D9 MEM2.E9 MEM2.F1 MEM2.G7 MEM2.H2 MEM2.H9 MEM2.K2 MEM2.K8 MEM2.N1 MEM2.N9 MEM2.R1 MEM2.R9 MEM3.A1 MEM3.A8 MEM3.B2 MEM3.C1 MEM3.C9 MEM3.D2 MEM3.D9 MEM3.E9 MEM3.F1 MEM3.G7 MEM3.H2 MEM3.H9 MEM3.K2 MEM3.K8 MEM3.N1 MEM3.N9 MEM3.R1 MEM3.R9 MEM4.A1 MEM4.A8 MEM4.B2 MEM4.C1 MEM4.C9 MEM4.D2 MEM4.D9 MEM4.E9 MEM4.F1 MEM4.G7 MEM4.H2 MEM4.H9 MEM4.K2 MEM4.K8 MEM4.N1 MEM4.N9 MEM4.R1 MEM4.R9 PC8502.1 PC12188.1 PC12191.1 PR8502.2 PT8501.1 PU8501.3 PU8501.4 R203.2 R230.2 R885.2 R928.2 R945.2 R1200.1 R1204.1 R1890.1 R1922.2 R1924.2 R80087.2
1P8V_PWR_PG: PR8511.1 R1689.1
3D3V_1D8V_VCCHDA: C2111.1 CPU1.AJ19 R1118.2 R1135.2 R1910.1
3D3V_1D8V_VCCPGPPA: CPU1.AK15 R1109.2 R1111.2
3D3V_1D8V_VCCPGPPD: CPU1.Y15 R1108.2 R1129.2
3D3V_1D8V_VCCPSPI: CPU1.AJ16 R1126.2 R1128.2
3D3V_AUX_EC: L9526.1 PR8519.1 PR8520.1 Q9649.D R79706.1 R80230.2 R80231.2 U4101.11 U4101.22 U4101.38 U4101.44 U4101.56
3D3V_AUX_S5: PC4516.1 PG4506.2
3D3V_RUN_FFS: C6701.1 C6702.1 C6703.1 R6701.2 U6701.1 U6701.7 U6701.8 U6701.14
3D3V_VCCPDSW: CPU1.AD17 CPU1.AD18 CPU1.AJ17 R80034.1 R80036.1 R80037.1 R80040.2 R80041.2 R80049.1
3D3V_VCCPGPPB: CPU1.AG15 R1116.2
3D3V_VCCPGPPC: C2106.1 CPU1.Y16 R1123.2
3D3V_VCCPGPPE: C2107.1 CPU1.T16 R1124.2
3D3V_VCCPGPPG: CPU1.AD15 R1137.2
3D3V_VCCPRIM: C2105.1 CPU1.AJ21 CPU1.V19 R1127.2 R80046.1
3D3V_VCCPRTCPRIM: C2109.1 C2110.1 CPU1.AK17 R1115.2
3D3V_VGA_S0: C753.1 C782.1 C783.1 C784.1 GPU1.AA17 GPU1.AA18 GPU1.AB17 GPU1.AB18 PR4.1 PR6.1 PR15.1 PR19.1 PR96.1 PR102.1 PR103.1 PR5304.1 PR5480.1 PR5482.1 PR5485.1 PR5486.1 PR8404.1 PR8501.1 PR8514.1 PR8516.1 Q77.D Q123.2 Q123.5 R302.2 R1159.2 R1167.1 R1883.1 R1885.1 R1887.1 R1892.2 R1893.2 R1895.2 R80086.2 RN16.3(B) RN16.4(B) U49.3 U49.7 U49.8
3P3V_SPI: C12261.1 R341.1 R342.2 R343.1 R79980.1 SRCON1.8 U9624.8
14MHZ_IN_SCALAR: C9520.1 R9547.2 SCA1.128 X9502.3
14MHZ_OUT_SCALAR: R9547.1 R80242.1 SCA1.127
14MHZ_OUT_SCALAR_C: C9522.1 R80242.2 X9502.1
1117 ADJ: R1592.1 R2081.2 U119.1
62882_COMP_R: PC6.2 PR8.1
62882_FB_VSEN: PC11.1 PR20.2
62882_NTC_R: PR5.2 PR60.1
62883AGND: PC5.1 PC9.2 PC20.1 PC58.2 PC60.2 PC12176.2 PC12180.1 PR1.1 PR2.1 PR5.1 PR9.2 U9.40 U9.41
+V_VREF_PATH1: C1256.2 R1214.1
+V_VREF_PATH2: C1328.2 R1306.1
+V_VREF_PATH3: C1257.2 R1221.1
+VGA_CORE_PHASE1: PG3.1 PR5489.2
A20GATE: R249.1 U109.43
AC_IN: PQ4403.D PQ4404.2 PQ4406.D PR4434.2
AC_IN_KBC#: TP4124.1 U4101.29
AC_OK#: PQ4406.G PR4402.2 PU4404.5 R79855.1 U4101.37
AC_OK#_C: R79855.2 U109.99
AC_PRESENT: CPU1.AY15 R80036.2
AC_PROTECT: PQ4405.G PR4420.1 PR4427.2 PR5297.2 PR5298.1 PU4404.3
AD+_2: C260.2 PQ4205.C R1847.2 R1850.1 U110.4
AD+_G_1: PQ4404.5 PQ4404.6 PR4401.2
AD+_G_2: PR4401.1 PR4413.2 PU4403.4
AD+_TO_SYS: PG4401.1 PR4412.2 PR4413.1 PR4414.2 PR4415.1 PR4418.2 PR4419.2 PR4421.2 PR4429.2 PU4403.1 PU4403.2 PU4403.3
AD_IA: PR4431.2 R80216.1 R80220.1
AD_IA_EC: R80220.2 U4101.48
AD_IA_HW1: PQ4401.2 R79859.1 R80221.1 R80225.2
AD_IA_HW1_C: R79859.2 U109.106
AD_IA_HW1_EC: R80221.2 U4101.59
AD_IA_HW2: PQ4401.5 R79860.1 R80222.1 R80226.2
AD_IA_HW2_C: R79860.2 U109.107
AD_IA_HW2_EC: R80222.2 U4101.60
AD_JK: C260.1 C262.1 C597.1 D16.K DCIN1.1 DCIN2.1 DCIN2.2 DCIN2.3 DCIN2.8 DCIN2.9 DCIN2.10 PQ4205.E PR4214.1 R1847.1 U110.1 U110.2 U110.3
AD_OFF: PQ4403.G R80193.1 R80224.2 U4101.36
AD_OFF_C: R80193.2 U109.97
AD_OFF_L: PQ4204.C PQ4205.B
ADAPTOR_PSID: D19.3 R1846.2 R1851.2 R80207.1 U109.119
ADAPTOR_PSID_EC: R80207.2 U4101.12
ADAPTOR_PSID_R: Q47.S R1851.1
ADC_1V2: C12188.1 C12189.1 L9523.2 SCA1.23
ALL_SYS_PWRGD: PR8512.2 Q9636.D R80144.2 R80145.1 R80147.1 R80150.2 R80252.1 U9626.2
AMD_RST#: C752.1 GPU1.AL27 R1160.1
AMP_SPKR_L: R384.2 R385.1 R79835.1 U9615.4
AMP_SPKR_R: R383.2 R386.1 R79834.1 U9615.8
AMP_SWITCH_C_L: R79812.1 R79835.2
AMP_SWITCH_C_R: R79813.1 R79834.2
AUD_BEEP_C: C130.2 U6.2
AUD_BEEP_R: C130.1 R207.2 R208.2 R210.1
AUD_DMIC_CLK: C121.2 L54.2 WEBCM1.4
AUD_DMIC_CLK_R: R212.1 U6.12
AUD_DMIC_CLK_R_1: L54.1 R212.2
AUD_DMIC_DATA: C132.2 R222.1 WEBCM1.5
AUD_DMIC_DATA_R: R222.2 U6.13
AUD_GP3: R213.2 U6.3
AUD_LINK_BCLK: C126.2 R1907.1 U6.5
AUD_LINK_RST_N: R314.1 R1911.1 U6.6
AUD_LINK_RST_N_2: Q9622.1 Q9622.3
AUD_LINK_RST_N_R: C170.1 Q31.B R314.2
AUD_LINK_SDIN: CPU1.BA21 R209.1
AUD_LINK_SDIN_1: R209.2 U6.8
AUD_LINK_SDO: C1780.2 Q56.D R618.2 R1912.1
AUD_LINK_SDO_1: C1780.1 Q56.G R617.2
AUD_LINK_SDO_N: Q56.S R618.1 U6.4
AUD_LINK_SDO_R1: MEJ1.2 R153.1
AUD_LINK_SYNC: R1908.1 U6.9
AUD_REGREF: C129.1 U6.10
BAT_ALERT: BAT2.8B R79648.2
BAT_IN#: R80203.1 R80223.1 RN4301.2(A) U4101.5
BAT_IN#_1: BAT2.6B PC4304.1 PL4301.1 RN4301.7(B)
BAT_IN#_C: R80203.2 U109.98
BATA_SCL_1: BAT2.4B PC4305.1 PL4302.1 RN4301.5(B)
BATA_SDA_1: BAT2.5B PC4301.1 PL4303.1 RN4301.6(B)
BATLOW#: CPU1.AU13 R80034.2
BATT_AMBER_LED#: R79710.2 U4101.9
BATT_AMBER_LED#_C: PWRCN1.10 R389.2 R79710.1
BATT_WHITE_LED#: R79711.2 U4101.58
BATT_WHITE_LED#_C: PWRCN1.8 Q1214.C Q9631.3 R79711.1 R79726.2
BIOS_REQ: CPU1.AM5 R80177.2 SCA1.105
BIST_DISABLE: R531.2 R533.1 R79924.2 U109.112
BIST_DISABLE_1: Q9632.5 R79924.1
BIST_EN: Q9632.3 Q9632.6 Q9633.2 R524.2
BIST_EN_INV: Q9633.3 Q9633.6 R517.2 R80227.1 SCA1.63
BIST_EN_SIO: R282.1 R80227.2 U109.25
BIST_ENABLE: R79923.2 U109.113
BIST_ENABLE_1: Q9633.5 R523.1 R79806.2 R79923.1
BIST_PIN25: Q9651.G R79933.2 U109.24
BKLT_ADJ: C33.1 C87.1 R133.2 R79621.2
BKLT_EN: C88.1 Q22.C R138.2 R139.2 R79625.2
BKLT_EN1: Q22.B R135.2
BOARD1: R1661.2 R1663.1 U109.124
BOARD2: R1662.2 R79931.1 U109.125
BOARD3: R1659.2 R1660.1 U109.126
BOOT1_PHASE1: PC19.2 PR43.2
BP_PWRGD_RST#: C9901.1 R9926.1 XDP1.41
BPM_CPU_N0: CPU1.C55 XDP1.21
BPM_CPU_N1: CPU1.D55 XDP1.23
BPM_CPU_N2: CPU1.B54 TP9902.1
BPM_CPU_N3: CPU1.C56 TP9903.1
BQ24737_REGN: PC4416.2 PD4401.A PR5297.1 PU4404.16
BT+: BAT2.1B BAT2.2B BAT2.3B PC4302.1 PC4303.1 PC4402.1 PC4404.1 PC4414.1 PC4419.1 PG4403.1 PR4430.2 PU4405.5 PU4405.6 PU4405.7 PU4405.8
BUZZER_SPKR_R: C243.1 R207.1
CAGND: C4.1 C5.2 C8.2 C10.2 C43.2 C3455.2 C3456.2 C3457.2 C3458.2 R37.2 R61.2 R82.2 R79623.2 R79627.2 R79628.2 U120.15 U120.21
CASA0#: GPU1.G19 MEM1.K3 MEM3.K3
CASA1#: GPU1.G16 MEM2.K3 MEM4.K3
CATERR#_CPU: CPU1.D63 TP401.1
CBN: C150.2 U6.21
CBP: C150.1 U6.24
CE: R9503.1 R9504.1 R9505.1 SCA1.118
CE#_1: R9504.2 U9501.1
CFG: R1594.2 U118.23
CFG0: CPU1.E68 R9907.1 XDP1.9
CFG1: CPU1.B67 XDP1.11
CFG2: CPU1.D65 R80163.1 XDP1.15
CFG3: CPU1.D67 R604.1 R9902.1 XDP1.17
CFG4: CPU1.E70 R605.1 XDP1.27
CFG5: CPU1.C68 XDP1.29
CFG6: CPU1.D68 XDP1.33
CFG7: CPU1.C67 XDP1.35
CFG8: CPU1.F71 XDP1.10
CFG9: CPU1.G69 XDP1.12
CFG10: CPU1.F70 XDP1.16
CFG11: CPU1.G68 XDP1.18
CFG12: CPU1.H70 XDP1.28
CFG13: CPU1.G71 XDP1.30
CFG14: CPU1.H69 XDP1.34
CFG15: CPU1.G70 XDP1.36
CFG16: CPU1.E63 XDP1.6
CFG17: CPU1.F63 XDP1.4
CFG18: CPU1.E66 XDP1.24
CFG19: CPU1.F66 XDP1.22
CFG_RCOMP: CPU1.E60 R601.1
CHAR_CTL1: R80112.1 U9628.6
CHAR_CTL2: R80111.1 U9628.7
CHAR_CTL3: R80110.1 U9628.8
CHAR_EN: CPU1.D9 R80109.1 R80133.1 U9628.5
CHAR_ILIM_HI: R80107.1 U9628.16
CHAR_ILIM_LO: R80114.1 U9628.15
CHAR_ILIM_SEL: R80108.1 U9628.4
CHAR_STATUS: TP9914.1 U9628.9
CHAR_USBOC#: R80113.1 U9628.13
CHG_AGND: PC4401.2 PC4408.2 PC4410.2 PC4411.2 PC4412.2 PC4418.2 PQ4401.1 PQ4401.4 PR4408.2 PR4409.2 PR4410.2 PR4416.2
CHG_ON#: PQ4402.G PR4404.2 R80204.1 U4101.17
CHG_ON#_C: R80204.2 U109.101
CHG_SMB2_CLK: PR4432.2 PU4404.9 R306.1 RN4301.4(A) U4101.35
CHG_SMB2_DATA: PR4426.2 PU4404.8 R307.1 RN4301.3(A) U4101.34
CK_48M_SIO: OSC2.3 R79943.1
CK_48M_SIO_C: R79943.2 U109.34
CK_P_33M_EC: R79699.1 U4101.2
CKEA0: GPU1.K20 MEM1.K9 MEM3.K9
CKEA1: GPU1.J17 MEM2.K9 MEM4.K9
CLINK_CLK_LAN: NGFF1.42 TP67.1
CLINK_DATA_LAN: NGFF1.40 TP66.1
CLINK_RST_LAN_N: NGFF1.38 TP65.1
CLK: R9501.2 SCA1.115
CLK_1: R9501.1 U9501.6
CLK_CR_N: CPU1.D40 U14.6
CLK_CR_P: CPU1.C40 U14.5
CLK_GFX_N: CPU1.D42 GPU1.AK32
CLK_GFX_P: CPU1.C42 GPU1.AK30
CLK_GLAN_N: CPU1.B42 U16.16
CLK_GLAN_P: CPU1.A42 U16.15
CLK_WLAN_N: CPU1.D41 R23.2
CLK_WLAN_P: CPU1.C41 R22.2
CLKA0: GPU1.H26 MEM1.J7 MEM3.J7 R80089.1
CLKA0#: GPU1.H25 MEM1.K7 MEM3.K7 R1906.1
CLKA1: GPU1.G9 MEM2.J7 MEM4.J7 R1909.1
CLKA1#: GPU1.H9 MEM2.K7 MEM4.K7 R80090.1
CLKTESTA: C764.1 GPU1.K8
CLKTESTA_C: C764.2 R1207.1
CLKTESTB: C763.1 GPU1.L7
CLKTESTB_C: C763.2 R1206.1
CPU_A16_TP: CPU1.BB9 TP1902.1
CPU_A17_TP: CPU1.BA9 TP1901.1
CPU_B16_TP: CPU1.AP7 TP2011.1
CPU_B17_TP: CPU1.AP8 TP2012.1
CPU_C18_TP: CPU1.U8 TP2016.1
CPU_C19_TP: CPU1.U9 TP2017.1
CPU_D4_TP: CPU1.V1 TP1804.1
CPU_D5_TP: CPU1.V2 TP1805.1
CPU_DDR_EN: R504.2 U501.2
CPU_DDR_VTT_CNTL: CPU1.AW67 R504.1 R80162.1
CPU_FAN_CTRL_SIO: R68.1 U109.6
CPU_FAN_TACH_SIO: R74.1 U109.5
CPU_POPIRCOMP: CPU1.AT16 R80007.1
CPVEE: C1491.1 U6.20
CR_CLKREQ_R: R458.1 U14.2
CRCLK_REQ_N: R458.2 R79764.2 R80064.2
CSA0#_0: GPU1.H22 MEM1.L2 MEM3.L2
CSA1#_0: GPU1.G13 MEM2.L2 MEM4.L2
CSI2_COMP: CPU1.E13 R1501.1
CTF_TRIP: C755.2 Q48.B R80085.2
CTFB: Q48.C R354.2 R1920.2
DC_19V: C258.1 PC4403.2 PR4403.1 PR4412.1 PR4414.1 PR4417.1 PR4418.1 PR4419.1 PR4421.1 PR4424.1 PR4429.1 PR4433.1 PR8523.1 PU4403.5 PU4403.6 PU4403.7 PU4403.8 PU4405.4 R1848.1 U110.5 U110.6 U110.7 U110.8
DC_IN_D: PQ4404.3 PR4433.2
DCBATOUT: C32.1 F16.1 L6.1 PC24.1 PC61.1 PC4403.1 PC4406.1 PC4407.1 PC4417.1 PC4506.1 PC4507.1 PC12177.1 PC12178.1 PC12181.1 PG4402.1 PR101.1 PR4415.2 PR4458.1 PR4502.2 PR4511.1 PR4528.2 PR4529.2 PR4530.2 PR4531.2 PR4532.2 PR4701.2 PR4702.2 PR4703.2 PR4704.2 PR4705.2 PR4706.2 PR4801.1 PR4802.1 PR4803.1 PR4805.1 PR4806.1 PR4807.1 PR4808.1 PR4809.1 PR4810.1 PR4811.1 PR4812.1 PR5001.1 PR5002.1 PR5004.1 PR5112.1 PR5121.1 PR5127.1 PR5204.1 PR5215.1 PR5221.1 PR5258.1 PR5307.2 PR5308.2 PT2.1 PU1.5 PU1.6 PU1.7 PU1.8 PU2.5 PU2.6 PU2.7 PU2.8 PU4401.5 PU4401.6 PU4401.7 PU4401.8 PU4405.1 PU4405.2 PU4405.3 PU4501.11 R20.1 R26.1 R288.1 R733.1 R1777.1 R1778.1 R1780.1 R9601.1 R9602.1 R79631.1
DCBATOUT_VCCGTA: PC4801.1 PC4802.1 PC4803.1 PC4804.1 PR4638.2 PR4801.2 PR4802.2 PR4803.2 PR4809.2 PR4810.2 PT4803.1 PU4801.5 PU4801.6 PU4801.7 PU4801.8
DCBATOUT_VCCGTB: PC4805.1 PC4806.1 PC4807.1 PC4808.1 PR4805.2 PR4806.2 PR4807.2 PR4808.2 PR4811.2 PR4812.2 PT4804.1 PU4804.5 PU4804.6 PU4804.7 PU4804.8
DCBATOUT_VCCSA: PC5002.1 PC5003.1 PR5001.2 PR5002.2 PR5004.2 PU5001.5 PU5001.6 PU5001.7 PU5001.8
DCBATOUT_VCORE: PC4725.1 PC4726.1 PC4727.1 PC4728.1 PR4701.1 PR4702.1 PR4703.1 PR4704.1 PR4705.1 PR4706.1 PT4704.1 PU4701.5 PU4701.6 PU4701.7 PU4701.8 PU4704.5 PU4704.6 PU4704.7 PU4704.8
DCIN_EN: R2087.2 U118.13
DDC5V_HDMI: C12217.1 D5201.3 R5209.1 R5213.1 R5214.1 U5201.8
DDC5V_HDMI_R: D5201.2 R5217.2
DDC_WP: R5212.2 SCA1.39
DDC_WP_1: R5209.2 R5212.1 U5201.7
DDCBUF: R1598.2 R2089.1 U118.14
DDPB_CTRL_CLK_CONN: HDMI1.15 HDMI3.5 R2083.2 U29.1 U29.10 U118.32
DDPB_CTRL_DATA_CONN: HDMI1.16 HDMI3.4 R2084.2 U29.2 U29.9 U118.33
DDR0_PAR: CPU1.AT52 TP501.1
DDR1_PAR: CPU1.AP43 TP9908.1
DDR_VREF_S3: PR5125.1
DDSP_B_HPD_CONN: HDMI1.19 HDMI3.1 R80196.1 U29.4 U29.7 U118.28
DET_HDMI#: Q5008.G R5215.1 R5216.2 SCA1.37 U5202.2
DET_HDMI_C: HDMI2.11 HDMI4.9 R5215.2
DGPU_EN: PR8513.2 PR8515.2 PR8517.1
DGPU_HOLD_RST#: CPU1.AB2 D34.1 D34.2 R79921.1
DGPU_PWR_ EN#: CPU1.AB1 D5206.K R79922.1
DGPU_PWROK: PR6.2 PR8505.1 U9.1
DGPU_PWROK_S: CPU1.AB3 PR8518.1
DIMM_TMPIN2+: C231.2 R397.1 RT1.1 U109.86
DIMM_TMPIN2-: C231.1 R399.2 RT1.2
DISP_UTIL_CPU: CPU1.B52 R79778.2
DP_AUXN: NGFF1.20 TP73.1
DP_AUXN_C: C12175.2 R9530.1
DP_AUXP: NGFF1.22 TP72.1
DP_AUXP_C: C12176.2 R9527.1
DP_HPD: NGFF1.31 TP78.1
DP_LANE0N_C: C12180.2 SCA1.13
DP_LANE0P_C: C12179.2 SCA1.12
DP_LANE1N_C: C12182.2 SCA1.15
DP_LANE1P_C: C12181.2 SCA1.14
DP_LANE2N_C: C12373.2 SCA1.17
DP_LANE2P_C: C12371.2 SCA1.16
DP_LANE3N_C: C12374.2 SCA1.19
DP_LANE3P_C: C12372.2 SCA1.18
DP_ML0N: NGFF1.32 TP69.1
DP_ML0P: NGFF1.34 TP68.1
DP_ML1N: NGFF1.26 TP71.1
DP_ML1P: NGFF1.28 TP70.1
DP_ML2N: NGFF1.25 TP76.1
DP_ML2P: NGFF1.27 TP77.1
DP_ML3N: NGFF1.19 TP74.1
DP_ML3P: NGFF1.21 TP75.1
DPLL_PVDD: C827.1 C829.1 C830.1 GPU1.AF14 L52.2
DPLL_VDDC: C825.1 C826.1 C828.1 GPU1.AD14 L53.2
DPLVDS_BL_EN: R280.1 R1985.2 R9528.1 SCA1.126 U109.54
DPLVDS_HPD: R79925.1 SCA1.110
DPLVDS_PANEL_VCC: R39.2 R9545.1 SCA1.55
DPLVDS_PWMIN: Q9614.1 R79777.1 R79778.1
DPLVDS_PWMOUT: Q9614.4 R1984.2 SCA1.103
DQMA0: GPU1.E32 MEM3.E7
DQMA1: GPU1.E30 MEM3.D3
DQMA2: GPU1.A21 MEM1.D3
DQMA3: GPU1.C21 MEM1.E7
DQMA4: GPU1.E13 MEM4.E7
DQMA5: GPU1.D12 MEM2.D3
DQMA6: GPU1.E3 MEM2.E7
DQMA7: GPU1.F4 MEM4.D3
DRAM_RST: C839.1 GPU1.L10 R1205.1 R80082.1
DRAM_RST_R: C762.1 R1891.1 R80082.2
EAPD_DEPOP: R393.1 U6.14
EAPD_DEPOP_1: R391.1 R393.2 R394.1
EAPD_DEPOP_2: Q9622.5 R394.2
EAPD_DEPOP_2_D: Q9627.6 R79871.2
EC_3P3_CTL: C6724.2 PR8521.2 Q9648.G
EC_3P3_CTL_2: C6725.1 Q9649.G R80229.2
EC_3P3_CTL_3: Q9648.D R80228.1 R80229.1
EC_HDMI_PD_N: Q1249.G R2091.2 U109.105
EC_LAN_DISABLE_N: R1194.1 R79938.1 U109.58
EC_PECI: R79739.2 R79990.2
EC_PROCHOT#: PQ4405.D Q9641.G R80154.1 R80166.2 U109.8 U4101.14
EC_PWREN: PR8521.1 R321.1 R79936.2 U109.57
EC_SCI: R79709.1 U4101.15
EC_SCI#: CPU1.N9 R803.1 R79709.2
EC_SMB2_CLK: PR8519.2 R80209.1 U4101.32
EC_SMB2_DATA: PR8520.2 R80208.1 U4101.33
EC_SMI#: CPU1.G4 R1611.1 U4101.13
EC_VCORF: C4101.2 U4101.20
EDID_RDY: CPU1.J1 R80132.1 SCA1.41
EDP_AUX_CPU_N: C12175.1 CPU1.E45 R79172.1 R79755.2
EDP_AUX_CPU_P: C12176.1 CPU1.F45 R79171.2 R79756.1
EDP_HPD_CPU: CPU1.L10 R530.1 R79925.2 R79926.1
EDP_RCOMP_CPU: CPU1.E52 R801.2
EDP_TX_CPU_N0: C12180.1 CPU1.C47
EDP_TX_CPU_N1: C12182.1 CPU1.D46
EDP_TX_CPU_N2: C12373.1 CPU1.A45
EDP_TX_CPU_N3: C12374.1 CPU1.A47
EDP_TX_CPU_P0: C12179.1 CPU1.C46
EDP_TX_CPU_P1: C12181.1 CPU1.C45
EDP_TX_CPU_P2: C12371.1 CPU1.B45
EDP_TX_CPU_P3: C12372.1 CPU1.B47
EDRAM_OPIO_RCOMP: CPU1.H66 R80009.1
EESCL: RN9503.2(A) SCA1.56 U9502.6
EESDA: RN9503.3(A) SCA1.57 U9502.5
EMMC_RCOMP: CPU1.AT1 R1502.1
EOPIO_RCOMP: CPU1.H65 R80008.1
EQ: R1593.2 R2085.1 U118.17
ESPI_RST#: CPU1.BA11 TP9918.1
EXT_PWR_GATE#: CPU1.AM10 R80035.2
EXT_RST#: R79705.1 R79706.2 U4101.41
FALL_INT2: Q6701.2 Q6701.3 R6703.2
FFS_INT1: CPU1.J3 R6702.2 R79658.2 R79872.1
FFS_INT1_C: R79658.1 U6701.11
FFS_INT1_SIO: R79872.2 U109.110
FFS_INT2_APU: CPU1.J2 R79657.2
FFS_INT2_C: Q6701.5 R6704.2 R6706.1 R79657.1 R79668.1 U6701.9
FFS_INT2_Q: Q6701.6 R6705.2 R6706.2 SATAP1.5
FIVR_EN_R: R9906.2 R9907.2 XDP1.45
FLASH_WP: R9509.1 SCA1.108
FWH_ID0: LPC1.6 R1700.2
GPD2/LAN_WAKE#: CPU1.AM15 R80049.2
GPIO: R79850.1 U14.28
GPIO17_THERMAL_INT: GPU1.R6 R1884.2 R1887.2 R1896.2
GPIO19_CTF: GPU1.M2 R329.2 R1886.1
GPIO19_CTF_R: D7.3 R329.1 R1894.1 R1896.1 R80085.1
GPIO_8_ROMSO: GPU1.P10 R1169.1
GPIO_9_ROMSI: GPU1.P4 R1171.2
GPIO_10_ROMSCK: GPU1.P2 R1170.2
GPIO_22_ROMCS#: GPU1.N8 R1168.1
GPIO_SVC: GPU1.AJ11 TP165.1
GPIO_SVD: GPU1.AK12 TP163.1
GPIO_SVT: GPU1.AL11 TP164.1
GPIO_VGA_03_DATA: Q123.4 R1165.1 RN16.1(A)
GPIO_VGA_03_DATA_R: GPU1.U8 R1165.2
GPIO_VGA_04_CLK: Q123.1 R1166.1 RN16.2(A)
GPIO_VGA_04_CLK_R: GPU1.U7 R1166.2
GPP_B2/VRALERT#: CPU1.AM11 TP1708.1
GPP_B18/GSPI0_MOSI: CPU1.AR7 R2007.2
GPP_B22/GSPI1_MOSI: CPU1.AN5 R2012.2
GPP_B23/SML1ALERT#: CPU1.AM7 R1833.1
GPP_C2/SMBALERT#: CPU1.R10 R1832.1
GPP_C5/SML0ALERT#: CPU1.W1 R1822.2 R1823.1
GPU_CLKA0_T: C1855.2 R1906.2 R80089.2
GPU_CLKA1_T: C207.2 R1909.2 R80090.2
GPU_DMINUS: C524.2 GPU1.T2 R651.2 RT2.2
GPU_DPLUS: C524.1 GPU1.T4 R658.1 RT2.1 U109.85
GPU_GPIO16: GPU1.M4 TP155.1
GPU_SCL: GPU1.R1 TP149.1
GPU_SDA: GPU1.R3 TP150.1
GPU_THERM_SHUTDOWN*: PC12.1 PR19.2 PR8517.2 R354.1 U9.38
GPU_THERMAL_INT: R1884.1 R1885.2 U109.28
GPU_VCC3_CTL: C1864.2 D5206.A Q76.G R80092.1
GPU_VCC3_CTL_2: C836.1 Q77.G R1195.2
GPU_VCC3_CTL_3: Q76.D R1195.1 R80091.1
GPU_VREFG: C1846.1 GPU1.AC16 R1210.2 R1211.1
GPU_WAKEB: GPU1.AJ27 R1883.2
GPU_XO_IN: GPU1.AC22 R1880.1
GPU_XO_IN2: GPU1.AB22 R1881.1
H_CPUPWRGD: CPU1.A68 R80042.1
H_PROCHOT_N: PR4455.1 PR4663.1 PR4664.2 Q9641.D R401.2 R403.1 R80166.1
H_RCIN#: CPU1.AW13 R2021.2 R80130.1
H_VID0: GPU1.T8 PR40.1 PR5482.2 U9.31
H_VID1: GPU1.N1 PR103.2 PR5479.1 U9.32
H_VID2: GPU1.P8 PR102.2 PR5490.1 U9.33
H_VID3: GPU1.AK10 PR33.1 PR5480.2 U9.34
H_VID4: GPU1.AM10 PR31.1 PR5486.2 U9.35
H_VID5: GPU1.T9 PR26.1 PR96.2 U9.36
H_VID6: PR5478.1 PR5485.2 U9.37
HDA_BITCLK_CPU: CPU1.AY22 R1907.2
HDA_RST#_CPU: CPU1.AW22 R1911.2
HDA_SDOUT_CPU: CPU1.BB22 Q9644.C R153.2 R1910.2 R1912.2
HDA_SPKR: CPU1.AW5 R208.1 R2006.2
HDA_SYNC_CPU: CPU1.BA22 R1908.2
HDMI1_CK+: D5203.4 D5203.7 R5208.2 SCA1.9 TR5204.4
HDMI1_CK+_C: HDMI2.10 HDMI4.10 TR5204.3
HDMI1_CK-: D5203.5 D5203.6 R5207.2 SCA1.10 TR5204.1
HDMI1_CK-_C: HDMI2.12 HDMI4.8 TR5204.2
HDMI1_CTRL_CLK_CPU: CPU1.L13 R80194.2 U118.38
HDMI1_CTRL_DATA_CPU: CPU1.L12 R80195.2 R80257.2 U118.39
HDMI1_D0+: D5203.1 D5203.10 R5204.2 SCA1.4 TR5202.4
HDMI1_D0+_C: HDMI2.7 HDMI4.13 TR5202.3
HDMI1_D0-: D5203.2 D5203.9 R5206.2 SCA1.3 TR5202.1
HDMI1_D0-_C: HDMI2.9 HDMI4.11 TR5202.2
HDMI1_D1+: D5204.2 D5204.9 R5203.2 SCA1.6 TR5203.4
HDMI1_D1+_C: HDMI2.4 HDMI4.16 TR5203.3
HDMI1_D1-: D5204.1 D5204.10 R5205.2 SCA1.5 TR5203.1
HDMI1_D1-_C: HDMI2.6 HDMI4.14 TR5203.2
HDMI1_D2+: D5204.5 D5204.6 R5201.2 SCA1.8 TR5201.4
HDMI1_D2+_C: HDMI2.1 HDMI4.19 TR5201.3
HDMI1_D2-: D5204.4 D5204.7 R5202.2 SCA1.7 TR5201.1
HDMI1_D2-_C: HDMI2.3 HDMI4.17 TR5201.2
HDMI1_DATA_CPU_N0: C12213.1 CPU1.E55
HDMI1_DATA_CPU_N1: C12211.1 CPU1.E58
HDMI1_DATA_CPU_N2: C12209.1 CPU1.F53
HDMI1_DATA_CPU_N3: C12215.1 CPU1.F56
HDMI1_DATA_CPU_P0: C12212.1 CPU1.F55
HDMI1_DATA_CPU_P1: C12210.1 CPU1.F58
HDMI1_DATA_CPU_P2: C12208.1 CPU1.G53
HDMI1_DATA_CPU_P3: C12214.1 CPU1.G56
HDMI1_DATA_IC_N0: C12213.2 U118.2
HDMI1_DATA_IC_N1: C12211.2 U118.5
HDMI1_DATA_IC_N2: C12209.2 U118.7
HDMI1_DATA_IC_N3: C12215.2 U118.10
HDMI1_DATA_IC_P0: C12212.2 U118.1
HDMI1_DATA_IC_P1: C12210.2 U118.4
HDMI1_DATA_IC_P2: C12208.2 U118.6
HDMI1_DATA_IC_P3: C12214.2 U118.9
HDMI1_OUT_HPD: CPU1.L9 R80255.1 U118.3
HDMI1_SCL: R9533.2 R9534.2 R9546.1 R80172.2
HDMI1_SDA: R9532.2 R9535.2 R9536.1 R80171.2
HDMI_5V: C12216.1 D5201.1 D5202.3 HDMI2.18 HDMI4.2 R5218.1 R9510.1 R80238.1
HDMI_DET1: R9510.2 R9511.1
HDMI_DET_SIO: Q5008.D R8514.2 U109.108
HDMI_HDCP_READY: R5218.2 R5219.1 SCA1.114 U5202.1
HDMI_HPDET: HDMI2.19 HDMI4.1 R5219.2 R80197.1
HDMI_IN_DET#_R: Q5008.S R8515.1
HDMI_LANE0_DN: HDMI1.3 HDMI3.17 TR16.2 U28.2 U28.9
HDMI_LANE0_DP: HDMI1.1 HDMI3.19 TR16.3 U28.1 U28.10
HDMI_LANE0_IC_DN: TR16.1 U118.29
HDMI_LANE0_IC_DP: TR16.4 U118.30
HDMI_LANE1_DN: HDMI1.6 HDMI3.14 TR17.2 U28.5 U28.6
HDMI_LANE1_DP: HDMI1.4 HDMI3.16 TR17.3 U28.4 U28.7
HDMI_LANE1_IC_DN: TR17.1 U118.26
HDMI_LANE1_IC_DP: TR17.4 U118.27
HDMI_LANE2_DN: HDMI1.9 HDMI3.11 TR18.2 U6706.4 U6706.7
HDMI_LANE2_DP: HDMI1.7 HDMI3.13 TR18.3 U6706.5 U6706.6
HDMI_LANE2_IC_DN: TR18.1 U118.24
HDMI_LANE2_IC_DP: TR18.4 U118.25
HDMI_LANE3_DN: HDMI1.12 HDMI3.8 TR19.2 U6706.1 U6706.10
HDMI_LANE3_DP: HDMI1.10 HDMI3.10 TR19.3 U6706.2 U6706.9
HDMI_LANE3_IC_DN: TR19.1 U118.21
HDMI_LANE3_IC_DP: TR19.4 U118.22
HDMI_OUT_DDC_VCC: C12370.1 D5205.K R2083.1 R2084.1
HDMI_SCL_IN: HDMI2.15 HDMI4.5 R5210.1 U5203.1
HDMI_SCL_IN_C: C12219.1 R5210.2 R5213.2 R80172.1 U5201.6
HDMI_SDA_IN: HDMI2.16 HDMI4.4 R5211.1 U5203.2
HDMI_SDA_IN_C: C12218.1 R5211.2 R5214.2 R80171.1 U5201.5
HM_VCCP: G1.2 R260.1
HM_VCCP_R: C184.1 R260.2 U109.95
HP_MUTE: R79920.1 R80170.2 SCA1.64
HP_MUTE_D: Q9627.3 R79919.2
HP_MUTE_L: Q9627.4 R79920.2
HPOL_CON: C134.1 Q57.1 R220.2 R221.1 R223.2 R225.2 UHS1.1
HPOR_CON: C159.1 Q57.2 R262.2 R281.1 R284.2 R627.2 UHS1.2
HPOUT-JD: R267.1 UHS1.6
HPOUT-L: R220.1 U6.26
HPOUT-R: R284.1 U6.27
HSI_C_DN8: C325.1 U14.8
HSI_C_DP8: C324.1 U14.7
HSI_LAN_DN1_R: C1808.1 U16.18
HSI_LAN_DP1_R: C1805.1 U16.17
ICH_RSMRST_N_R: R291.2 U109.82
IMS: LVDS1.4 R79832.2 R80137.1
INIT_3V: LPC1.2 R1699.2
IO_SMI_N: R79928.2 U109.9
ISEN1: R51.2 U120.17
ISEN2: R53.2 U120.16
ISEN3: R56.2 U120.14
ISEN4: R59.2 U120.13
ISET: R1596.2 R2086.1 U118.34
ISP_CLK1: Q9501.6 Q9502.6 R9540.2
ISP_DAT1: Q9501.3 Q9502.3 R9541.2
ISW: C10.1 R79630.2 U120.19
ISW_1: Q1250.1 Q1250.2 Q1250.3 R27.1 R79622.1 R79630.1
ITP_PMODE: CPU1.E8 R9932.2 R9933.2
JACK_PSID: DCIN1.3 DCIN2.4 DCIN2.11 L15.1
JDREF: R268.1 U6.35
JENK#: TP4125.1 U4101.28
JTAG_TCK_VGA: GPU1.L3 R963.1
JTAG_TDI_VGA: GPU1.L5 R1892.1
JTAG_TDO_VGA: GPU1.K4 R1895.1
JTAG_TMS_VGA: GPU1.L1 R80086.1
JTAG_TRST#_VGA: GPU1.L6 R1893.1
KBCLK: RN3.3(A) U109.78
KBRST_N: R80130.2 U109.42
KDAT: RN3.4(A) U109.77
L_AD0: CPU1.AY13 LPC1.5 R79703.2 RN1.1(A) U109.38
L_AD1: CPU1.BA13 LPC1.7 R79702.2 RN1.2(A) U109.39
L_AD2: CPU1.BB13 LPC1.9 R79701.2 RN1.3(A) U109.40
L_AD3: CPU1.AY12 LPC1.11 R79700.2 RN1.4(A) U109.41
L_BKLTCTL: CPU1.R11 R79777.2
L_FRAME_N: LPC1.13 R324.2 R327.1 R1801.1 R79698.2 U109.37
L_FRAME_N_R: CPU1.BA12 R1801.2
LAD0_FWH0_EC: R79703.1 U4101.62
LAD1_FWH1_EC: R79702.1 U4101.63
LAD2_FWH2_EC: R79701.1 U4101.64
LAD3_FWH3_EC: R79700.1 U4101.1
LAN_DISABLE_N: CPU1.AW17 R774.1 R80054.1
LAN_DISABLE_N_1: C591.1 Q102.B R774.2 R1180.1
LAN_DISABLE_N_2: Q101.B Q102.C R764.1 R1180.2
LAN_DISABLE_N_3: Q100.C Q101.C R775.2 R776.1
LAN_DISABLE_N_4: C593.1 PC140.2 Q44.G R776.2
LAN_DISABLE_V3: C863.1 Q100.B R1183.1 R1194.2
LAN_LEDACT_R#: RJ1.10 UR5.2
LAN_MDI0_C_DN: RJ1.2 XF1.2
LAN_MDI0_C_DP: RJ1.1 XF1.1
LAN_MDI0_DN: U10.3 U16.2 XF1.11
LAN_MDI0_DP: U10.4 U16.1 XF1.12
LAN_MDI1_C_DN: RJ1.6 XF1.6
LAN_MDI1_C_DP: RJ1.3 XF1.5
LAN_MDI1_DN: U10.1 U16.5 XF1.7
LAN_MDI1_DP: U10.6 U16.4 XF1.8
LAN_MDI2_C_DN: RJ1.5 XF2.5
LAN_MDI2_C_DP: RJ1.4 XF2.6
LAN_MDI2_DN: P5480.2 U11.3 XF2.8
LAN_MDI2_DN_R: P5480.1 U16.7
LAN_MDI2_DP: P5479.2 U11.4 XF2.7
LAN_MDI2_DP_R: P5479.1 U16.6
LAN_MDI3_C_DN: RJ1.8 XF2.1
LAN_MDI3_C_DP: RJ1.7 XF2.2
LAN_MDI3_DN: P5482.2 U11.1 XF2.12
LAN_MDI3_DN_R: P5482.1 U16.10
LAN_MDI3_DP: P5481.2 U11.6 XF2.11
LAN_MDI3_DP_R: P5481.1 U16.9
LAN_RSET: R412.2 U16.31
LAN_XTALI: C1800.1 R407.2 U16.28 X4.1
LAN_XTALO: R407.1 R80241.1 U16.29
LAN_XTALO_C: C1799.1 R80241.2 X4.3
LANCLK_REQ_N: R413.2 R79759.2 R80065.2
LANCLK_REQ_U_N: R413.1 U16.12
LDR: R65.2 U120.1
LDR_1: Q1250.4 R65.1
LDRQ#: R79935.1 U109.2
LDRQ#_EC: R79704.1 U4101.61
LED_5VSB: LED2.A R1767.2
LEDC_ISET: R82.1 U120.12
LFRAMEJ_FW4_EC: R79698.1 U4101.3
LINE2-VREFO: R261.1 R272.1 U6.29
LINEOUT-JD: LOUT1.Q R266.1
LINEOUT-L: R429.1 U6.19
LINEOUT-R: R428.1 U6.18
LINEOUT_C-L: L62.1 R429.2
LINEOUT_C-R: L20.1 R428.2
LINEOUT_CON-L: C268.1 L62.2 LOUT1.4 Q46.1
LINEOUT_CON-R: C267.1 L20.2 LOUT1.1 Q46.2
LINK_ACTIVITY_N: U12.4 U16.27 UR5.1
LINK_PWR: R79618.1 RJ1.9
LPC_CLK0: R79699.2 R80072.1 R80183.2
LPC_CLK0_R: CPU1.AW9 R80072.2
LPC_CLK1: R80073.1 U109.44
LPC_CLK1_R: CPU1.AY9 R80073.2
LPC_CLK_D: LPC1.1 R80183.1
LPC_CLKRUN#_CPU: CPU1.AW11 R80067.1 R80212.2
LPC_PME#: R253.2 R79837.1 U109.70
LPC_PME_N: CPU1.AU11 R9556.1 R79837.2 R79838.2
LPF: C3455.1 U120.9
LPSS_UART2_RXD: CN3.3 CPU1.AD1 R2040.1
LPSS_UART2_TXD: CN3.2 CPU1.AD2 R2041.1
LVDS_BL_ADJ: R131.1 R132.1 R133.1 R134.2 R1984.1
LVDS_DET_A*: LVDS1.17 R79689.2 U109.116
LVDS_DET_B*: Q6705.D R79691.2 U109.117
LVDS_DET_B_C*: C6718.1 LVDS1.1 Q6705.G
LVDS_PU_5: LVDS1.5 R79690.2
LVDS_PU_6: LVDS1.6 R79656.2
LVDS_PU_6_1: Q9647.D R79656.1
LVDS_PU_24: LVDS1.24 R79687.2
LX: D32.A L61.2 Q1250.5 Q1250.6 Q1250.7 Q1250.8 R79619.1
M1_SMB_CLK: NGFF1.60 R14.2
M1_SMB_DATA: NGFF1.58 R1622.2
M_A_A0: CPU1.AY50 DIMM1.98
M_A_A1: CPU1.BB50 DIMM1.97
M_A_A2: CPU1.AY51 DIMM1.96
M_A_A3: CPU1.BA50 DIMM1.95
M_A_A4: CPU1.BB52 DIMM1.92
M_A_A5: CPU1.BA51 DIMM1.91
M_A_A6: CPU1.BA52 DIMM1.90
M_A_A7: CPU1.AW52 DIMM1.86
M_A_A8: CPU1.AY52 DIMM1.89
M_A_A9: CPU1.BB54 DIMM1.85
M_A_A10: CPU1.AT50 DIMM1.107
M_A_A11: CPU1.BA54 DIMM1.84
M_A_A12: CPU1.AW54 DIMM1.83
M_A_A13: CPU1.AU46 DIMM1.119
M_A_A14: CPU1.AY54 DIMM1.80
M_A_A15: CPU1.BA55 DIMM1.78
M_A_BS0: CPU1.AU52 DIMM1.109
M_A_BS1: CPU1.AT48 DIMM1.108
M_A_BS2: CPU1.AY55 DIMM1.79
M_A_CAS#: CPU1.AU48 DIMM1.115
M_A_CKE0: CPU1.BA56 DIMM1.73
M_A_CKE1: CPU1.BB56 DIMM1.74
M_A_CLK0: CPU1.AT53 DIMM1.101
M_A_CLK1: CPU1.AT55 DIMM1.102
M_A_CLK#0: CPU1.AU53 DIMM1.103
M_A_CLK#1: CPU1.AU55 DIMM1.104
M_A_CS#0: CPU1.AU45 DIMM1.114
M_A_CS#1: CPU1.AU43 DIMM1.121
M_A_DQ0: CPU1.AL71 DIMM1.4
M_A_DQ1: CPU1.AL68 DIMM1.7
M_A_DQ2: CPU1.AN68 DIMM1.16
M_A_DQ3: CPU1.AN69 DIMM1.17
M_A_DQ4: CPU1.AL70 DIMM1.6
M_A_DQ5: CPU1.AL69 DIMM1.5
M_A_DQ6: CPU1.AN70 DIMM1.18
M_A_DQ7: CPU1.AN71 DIMM1.15
M_A_DQ8: CPU1.AR70 DIMM1.22
M_A_DQ9: CPU1.AR68 DIMM1.24
M_A_DQ10: CPU1.AU71 DIMM1.36
M_A_DQ11: CPU1.AU68 DIMM1.34
M_A_DQ12: CPU1.AR71 DIMM1.23
M_A_DQ13: CPU1.AR69 DIMM1.21
M_A_DQ14: CPU1.AU70 DIMM1.33
M_A_DQ15: CPU1.AU69 DIMM1.35
M_A_DQ16: CPU1.BB65 DIMM1.39
M_A_DQ17: CPU1.AW65 DIMM1.41
M_A_DQ18: CPU1.AW63 DIMM1.53
M_A_DQ19: CPU1.AY63 DIMM1.51
M_A_DQ20: CPU1.BA65 DIMM1.40
M_A_DQ21: CPU1.AY65 DIMM1.42
M_A_DQ22: CPU1.BA63 DIMM1.50
M_A_DQ23: CPU1.BB63 DIMM1.52
M_A_DQ24: CPU1.BA61 DIMM1.56
M_A_DQ25: CPU1.AW61 DIMM1.58
M_A_DQ26: CPU1.BB59 DIMM1.68
M_A_DQ27: CPU1.AW59 DIMM1.70
M_A_DQ28: CPU1.BB61 DIMM1.57
M_A_DQ29: CPU1.AY61 DIMM1.59
M_A_DQ30: CPU1.BA59 DIMM1.67
M_A_DQ31: CPU1.AY59 DIMM1.69
M_A_DQ32: CPU1.AY39 DIMM1.130
M_A_DQ33: CPU1.AW39 DIMM1.131
M_A_DQ34: CPU1.AY37 DIMM1.141
M_A_DQ35: CPU1.AW37 DIMM1.143
M_A_DQ36: CPU1.BB39 DIMM1.129
M_A_DQ37: CPU1.BA39 DIMM1.132
M_A_DQ38: CPU1.BA37 DIMM1.142
M_A_DQ39: CPU1.BB37 DIMM1.140
M_A_DQ40: CPU1.AY35 DIMM1.149
M_A_DQ41: CPU1.AW35 DIMM1.147
M_A_DQ42: CPU1.AY33 DIMM1.160
M_A_DQ43: CPU1.AW33 DIMM1.158
M_A_DQ44: CPU1.BB35 DIMM1.146
M_A_DQ45: CPU1.BA35 DIMM1.148
M_A_DQ46: CPU1.BA33 DIMM1.159
M_A_DQ47: CPU1.BB33 DIMM1.157
M_A_DQ48: CPU1.AY31 DIMM1.164
M_A_DQ49: CPU1.AW31 DIMM1.163
M_A_DQ50: CPU1.AY29 DIMM1.174
M_A_DQ51: CPU1.AW29 DIMM1.175
M_A_DQ52: CPU1.BB31 DIMM1.166
M_A_DQ53: CPU1.BA31 DIMM1.165
M_A_DQ54: CPU1.BA29 DIMM1.176
M_A_DQ55: CPU1.BB29 DIMM1.177
M_A_DQ56: CPU1.AY27 DIMM1.181
M_A_DQ57: CPU1.AW27 DIMM1.183
M_A_DQ58: CPU1.AY25 DIMM1.194
M_A_DQ59: CPU1.AW25 DIMM1.192
M_A_DQ60: CPU1.BB27 DIMM1.180
M_A_DQ61: CPU1.BA27 DIMM1.182
M_A_DQ62: CPU1.BA25 DIMM1.191
M_A_DQ63: CPU1.BB25 DIMM1.193
M_A_DQS_DN0: CPU1.AM70 DIMM1.10
M_A_DQS_DN1: CPU1.AT69 DIMM1.27
M_A_DQS_DN2: CPU1.BA64 DIMM1.45
M_A_DQS_DN3: CPU1.AY60 DIMM1.62
M_A_DQS_DN4: CPU1.BA38 DIMM1.135
M_A_DQS_DN5: CPU1.AY34 DIMM1.152
M_A_DQS_DN6: CPU1.BA30 DIMM1.169
M_A_DQS_DN7: CPU1.AY26 DIMM1.186
M_A_DQS_DP0: CPU1.AM69 DIMM1.12
M_A_DQS_DP1: CPU1.AT70 DIMM1.29
M_A_DQS_DP2: CPU1.AY64 DIMM1.47
M_A_DQS_DP3: CPU1.BA60 DIMM1.64
M_A_DQS_DP4: CPU1.AY38 DIMM1.137
M_A_DQS_DP5: CPU1.BA34 DIMM1.154
M_A_DQS_DP6: CPU1.AY30 DIMM1.171
M_A_DQS_DP7: CPU1.BA26 DIMM1.188
M_A_ODT0: CPU1.AT45 DIMM1.116
M_A_ODT1: CPU1.AT43 DIMM1.120
M_A_RAS#: CPU1.AU50 DIMM1.110
M_A_WE#: CPU1.AT46 DIMM1.113
M_B_A0: CPU1.BA46 DIMM2.98
M_B_A1: CPU1.AY46 DIMM2.97
M_B_A2: CPU1.AY47 DIMM2.96
M_B_A3: CPU1.BB46 DIMM2.95
M_B_A4: CPU1.BA47 DIMM2.92
M_B_A5: CPU1.AY48 DIMM2.91
M_B_A6: CPU1.BA48 DIMM2.90
M_B_A7: CPU1.AP48 DIMM2.86
M_B_A8: CPU1.BB48 DIMM2.89
M_B_A9: CPU1.AP50 DIMM2.85
M_B_A10: CPU1.AW46 DIMM2.107
M_B_A11: CPU1.AN48 DIMM2.84
M_B_A12: CPU1.AN50 DIMM2.83
M_B_A13: CPU1.BA43 DIMM2.119
M_B_A14: CPU1.AN52 DIMM2.80
M_B_A15: CPU1.AN53 DIMM2.78
M_B_BS0: CPU1.BB44 DIMM2.109
M_B_BS1: CPU1.BA44 DIMM2.108
M_B_BS2: CPU1.AP52 DIMM2.79
M_B_CAS#: CPU1.AY43 DIMM2.115
M_B_CKE0: CPU1.AN56 DIMM2.73
M_B_CKE1: CPU1.AP55 DIMM2.74
M_B_CLK0: CPU1.AP45 DIMM2.101
M_B_CLK1: CPU1.AP46 DIMM2.102
M_B_CLK#0: CPU1.AN45 DIMM2.103
M_B_CLK#1: CPU1.AN46 DIMM2.104
M_B_CS#0: CPU1.BB42 DIMM2.114
M_B_CS#1: CPU1.AY42 DIMM2.121
M_B_DQ0: CPU1.AF65 DIMM2.23
M_B_DQ1: CPU1.AF64 DIMM2.24
M_B_DQ2: CPU1.AK65 DIMM2.36
M_B_DQ3: CPU1.AK64 DIMM2.35
M_B_DQ4: CPU1.AF66 DIMM2.21
M_B_DQ5: CPU1.AF67 DIMM2.22
M_B_DQ6: CPU1.AK67 DIMM2.33
M_B_DQ7: CPU1.AK66 DIMM2.34
M_B_DQ8: CPU1.AF70 DIMM2.5
M_B_DQ9: CPU1.AF68 DIMM2.4
M_B_DQ10: CPU1.AH71 DIMM2.15
M_B_DQ11: CPU1.AH68 DIMM2.17
M_B_DQ12: CPU1.AF71 DIMM2.7
M_B_DQ13: CPU1.AF69 DIMM2.6
M_B_DQ14: CPU1.AH70 DIMM2.16
M_B_DQ15: CPU1.AH69 DIMM2.18
M_B_DQ16: CPU1.AT66 DIMM2.52
M_B_DQ17: CPU1.AU66 DIMM2.51
M_B_DQ18: CPU1.AP65 DIMM2.40
M_B_DQ19: CPU1.AN65 DIMM2.41
M_B_DQ20: CPU1.AN66 DIMM2.39
M_B_DQ21: CPU1.AP66 DIMM2.42
M_B_DQ22: CPU1.AT65 DIMM2.53
M_B_DQ23: CPU1.AU65 DIMM2.50
M_B_DQ24: CPU1.AT61 DIMM2.56
M_B_DQ25: CPU1.AU61 DIMM2.58
M_B_DQ26: CPU1.AP60 DIMM2.68
M_B_DQ27: CPU1.AN60 DIMM2.70
M_B_DQ28: CPU1.AN61 DIMM2.59
M_B_DQ29: CPU1.AP61 DIMM2.57
M_B_DQ30: CPU1.AT60 DIMM2.67
M_B_DQ31: CPU1.AU60 DIMM2.69
M_B_DQ32: CPU1.AU40 DIMM2.132
M_B_DQ33: CPU1.AT40 DIMM2.130
M_B_DQ34: CPU1.AT37 DIMM2.140
M_B_DQ35: CPU1.AU37 DIMM2.141
M_B_DQ36: CPU1.AR40 DIMM2.131
M_B_DQ37: CPU1.AP40 DIMM2.129
M_B_DQ38: CPU1.AP37 DIMM2.142
M_B_DQ39: CPU1.AR37 DIMM2.143
M_B_DQ40: CPU1.AT33 DIMM2.147
M_B_DQ41: CPU1.AU33 DIMM2.149
M_B_DQ42: CPU1.AU30 DIMM2.157
M_B_DQ43: CPU1.AT30 DIMM2.159
M_B_DQ44: CPU1.AR33 DIMM2.148
M_B_DQ45: CPU1.AP33 DIMM2.146
M_B_DQ46: CPU1.AR30 DIMM2.160
M_B_DQ47: CPU1.AP30 DIMM2.158
M_B_DQ48: CPU1.AU27 DIMM2.174
M_B_DQ49: CPU1.AT27 DIMM2.163
M_B_DQ50: CPU1.AT25 DIMM2.175
M_B_DQ51: CPU1.AU25 DIMM2.165
M_B_DQ52: CPU1.AP27 DIMM2.164
M_B_DQ53: CPU1.AN27 DIMM2.166
M_B_DQ54: CPU1.AN25 DIMM2.176
M_B_DQ55: CPU1.AP25 DIMM2.177
M_B_DQ56: CPU1.AT22 DIMM2.181
M_B_DQ57: CPU1.AU22 DIMM2.180
M_B_DQ58: CPU1.AU21 DIMM2.183
M_B_DQ59: CPU1.AT21 DIMM2.193
M_B_DQ60: CPU1.AN22 DIMM2.191
M_B_DQ61: CPU1.AP22 DIMM2.182
M_B_DQ62: CPU1.AP21 DIMM2.192
M_B_DQ63: CPU1.AN21 DIMM2.194
M_B_DQS_DN0: CPU1.AH66 DIMM2.27
M_B_DQS_DN1: CPU1.AG69 DIMM2.10
M_B_DQS_DN2: CPU1.AR66 DIMM2.45
M_B_DQS_DN3: CPU1.AR61 DIMM2.62
M_B_DQS_DN4: CPU1.AT38 DIMM2.135
M_B_DQS_DN5: CPU1.AT32 DIMM2.152
M_B_DQS_DN6: CPU1.AR25 DIMM2.169
M_B_DQS_DN7: CPU1.AR22 DIMM2.186
M_B_DQS_DP0: CPU1.AH65 DIMM2.29
M_B_DQS_DP1: CPU1.AG70 DIMM2.12
M_B_DQS_DP2: CPU1.AR65 DIMM2.47
M_B_DQS_DP3: CPU1.AR60 DIMM2.64
M_B_DQS_DP4: CPU1.AR38 DIMM2.137
M_B_DQS_DP5: CPU1.AR32 DIMM2.154
M_B_DQS_DP6: CPU1.AR27 DIMM2.171
M_B_DQS_DP7: CPU1.AR21 DIMM2.188
M_B_ODT0: CPU1.BA42 DIMM2.116
M_B_ODT1: CPU1.AW42 DIMM2.120
M_B_RAS#: CPU1.AW44 DIMM2.110
M_B_WE#: CPU1.AY44 DIMM2.113
M_VREF_CA_DIMMA: C1201.1 C1202.1 C1218.1 DIMM1.126 R1217.2 R1218.2 R1219.1 R1220.1
M_VREF_CA_DIMMB: C1306.1 C1308.1 C1309.1 DIMM2.126 R1217.1
M_VREF_DQ_DIM0: C1256.1 CPU1.AY68 R1215.1
M_VREF_DQ_DIM1: C1328.1 CPU1.BA67 R1305.1
M_VREF_DQ_DIMMA: C1204.1 C1205.1 C1206.1 DIMM1.1 R1212.2 R1213.1 R1215.2
M_VREF_DQ_DIMMB: C1302.1 C1305.1 C1310.1 DIMM2.1 R1304.2 R1305.2 R1307.1
MAA0: GPU1.K17 MEM1.N3 MEM2.N3 MEM3.N3 MEM4.N3
MAA1: GPU1.J20 MEM1.P7 MEM2.P7 MEM3.P7 MEM4.P7
MAA2: GPU1.H23 MEM1.P3 MEM2.P3 MEM3.P3 MEM4.P3
MAA3: GPU1.G23 MEM1.N2 MEM2.N2 MEM3.N2 MEM4.N2
MAA4: GPU1.G24 MEM1.P8 MEM2.P8 MEM3.P8 MEM4.P8
MAA5: GPU1.H24 MEM1.P2 MEM2.P2 MEM3.P2 MEM4.P2
MAA6: GPU1.J19 MEM1.R8 MEM2.R8 MEM3.R8 MEM4.R8
MAA7: GPU1.K19 MEM1.R2 MEM2.R2 MEM3.R2 MEM4.R2
MAA8: GPU1.J14 MEM1.T8 MEM2.T8 MEM3.T8 MEM4.T8
MAA9: GPU1.K14 MEM1.R3 MEM2.R3 MEM3.R3 MEM4.R3
MAA10: GPU1.J11 MEM1.L7 MEM2.L7 MEM3.L7 MEM4.L7
MAA11: GPU1.J13 MEM1.R7 MEM2.R7 MEM3.R7 MEM4.R7
MAA12: GPU1.H11 MEM1.N7 MEM2.N7 MEM3.N7 MEM4.N7
MAA13: GPU1.G20 MEM1.T3 MEM2.T3 MEM3.T3 MEM4.T3
MAA14: GPU1.G14 MEM1.T7 MEM2.T7 MEM3.T7 MEM4.T7
MAA_BA0: GPU1.J16 MEM1.M2 MEM2.M2 MEM3.M2 MEM4.M2
MAA_BA1: GPU1.L15 MEM1.N8 MEM2.N8 MEM3.N8 MEM4.N8
MAA_BA2: GPU1.G11 MEM1.M3 MEM2.M3 MEM3.M3 MEM4.M3
MCLK: RN3.1(A) U109.80
MCT_R: R79612.2 RV1.2 XF1.3 XF1.4 XF2.3 XF2.4
MCT_R_1: C3131.1 R79612.1
MDA0: GPU1.K27 MEM3.F8
MDA1: GPU1.J29 MEM3.F7
MDA2: GPU1.H30 MEM3.H3
MDA3: GPU1.H32 MEM3.E3
MDA4: GPU1.G29 MEM3.G2
MDA5: GPU1.F28 MEM3.F2
MDA6: GPU1.F32 MEM3.H8
MDA7: GPU1.F30 MEM3.H7
MDA8: GPU1.C30 MEM3.D7
MDA9: GPU1.F27 MEM3.C8
MDA10: GPU1.A28 MEM3.B8
MDA11: GPU1.C28 MEM3.A7
MDA12: GPU1.E27 MEM3.A3
MDA13: GPU1.G26 MEM3.A2
MDA14: GPU1.D26 MEM3.C2
MDA15: GPU1.F25 MEM3.C3
MDA16: GPU1.A25 MEM1.A2
MDA17: GPU1.C25 MEM1.C2
MDA18: GPU1.E25 MEM1.A3
MDA19: GPU1.D24 MEM1.C3
MDA20: GPU1.E23 MEM1.A7
MDA21: GPU1.F23 MEM1.D7
MDA22: GPU1.D22 MEM1.B8
MDA23: GPU1.F21 MEM1.C8
MDA24: GPU1.E21 MEM1.G2
MDA25: GPU1.D20 MEM1.E3
MDA26: GPU1.F19 MEM1.H3
MDA27: GPU1.A19 MEM1.F2
MDA28: GPU1.D18 MEM1.H8
MDA29: GPU1.F17 MEM1.H7
MDA30: GPU1.A17 MEM1.F7
MDA31: GPU1.C17 MEM1.F8
MDA32: GPU1.E17 MEM4.F8
MDA33: GPU1.D16 MEM4.H8
MDA34: GPU1.F15 MEM4.F7
MDA35: GPU1.A15 MEM4.H7
MDA36: GPU1.D14 MEM4.H3
MDA37: GPU1.F13 MEM4.G2
MDA38: GPU1.A13 MEM4.E3
MDA39: GPU1.C13 MEM4.F2
MDA40: GPU1.E11 MEM2.C3
MDA41: GPU1.A11 MEM2.A3
MDA42: GPU1.C11 MEM2.A2
MDA43: GPU1.F11 MEM2.C2
MDA44: GPU1.A9 MEM2.A7
MDA45: GPU1.C9 MEM2.B8
MDA46: GPU1.F9 MEM2.D7
MDA47: GPU1.D8 MEM2.C8
MDA48: GPU1.E7 MEM2.E3
MDA49: GPU1.A7 MEM2.H3
MDA50: GPU1.C7 MEM2.F2
MDA51: GPU1.F7 MEM2.G2
MDA52: GPU1.A5 MEM2.H8
MDA53: GPU1.E5 MEM2.F7
MDA54: GPU1.C3 MEM2.H7
MDA55: GPU1.E1 MEM2.F8
MDA56: GPU1.G7 MEM4.D7
MDA57: GPU1.G6 MEM4.C8
MDA58: GPU1.G1 MEM4.A2
MDA59: GPU1.G3 MEM4.A7
MDA60: GPU1.J6 MEM4.B8
MDA61: GPU1.J1 MEM4.C2
MDA62: GPU1.J3 MEM4.C3
MDA63: GPU1.J5 MEM4.A3
MDAT: RN3.2(A) U109.79
ME_CNTL: R1836.2 R80254.1 U109.7
ME_CNTL1: Q9644.B R1836.1
MEM_CALRP0: GPU1.K25 R80081.2
MEM_RST: MEM1.T2 MEM2.T2 MEM3.T2 MEM4.T2 R1204.2 R1891.2
MIC2-L: C139.1 U6.47
MIC2-L-1: C139.2 R225.1
MIC2-R: C138.1 U6.48
MIC2-R-1: C138.2 R627.1
MIC2-VREFO-L: R223.1 U6.1
MIC2-VREFO-R: R262.1 U6.30
MIC-CAP: C154.1 U6.36
MINI_POWER_CTRL: R15.2 RN6.4(B) U109.55
MLPS_EN#: GPU1.R5 R1882.1
MODEL_ID_DET: R79722.1 R79723.2 U4101.50
MPCIE_DISABLE_N: R1620.1 RN6.3(B) U109.56
MPV18: C786.1 C790.1 C791.1 GPU1.L8 L50.2
MS_INS#: TP205.1 U14.31
MVREFDA: C760.1 GPU1.K26 R1888.1 R1890.2
MVREFSA: C761.1 GPU1.J26 R1200.2 R1889.1
NGFF_ALERT#: CPU1.H2 R1617.1 R1717.1
NGFF_ALERT_N: NGFF1.62 R1717.2
NGFF_BT_DISABLE: CPU1.W4 R1621.1
NGFF_CLKREQ0_N: NGFF1.53 R1931.1
NGFF_CLKREQ0_NGFF#: Q1229.S R1931.2 R1932.2
NGFF_CLKREQ1_N: NGFF1.68 R1925.2
NGFF_CLKREQ1_N_TP: R1925.1 TP208.1
NGFF_DETECT_PCIE: CPU1.BB7 R1155.2 R80219.1
NGFF_DETECT_PCIE_C: NGFF1.51 R1155.1 R1709.2
NGFF_DETECT_USB: CPU1.U6 R1154.2
NGFF_DETECT_USB_C: NGFF1.1 R1154.1 R1209.2
NGFF_PCIE0_RXN: NGFF1.43 R1712.1
NGFF_PCIE0_RXP: NGFF1.41 R1711.1
NGFF_PCIE0_TXN: NGFF1.37 R1714.1
NGFF_PCIE0_TXP: NGFF1.35 R1713.1
NGFF_PCIE1_RXN: NGFF1.67 TP82.1
NGFF_PCIE1_RXP: NGFF1.65 TP81.1
NGFF_PCIE1_TXN: NGFF1.61 TP80.1
NGFF_PCIE1_TXP: NGFF1.59 TP79.1
NGFF_PEWAKE0_N: NGFF1.55 NGFF1.70 R1718.2 R1719.1
NGFF_POWER_CTRL_1: Q3.G R15.1
NGFF_POWER_CTRL_V2: C864.1 Q128.B R1716.1
NGFF_REFCLKN0: NGFF1.49 R23.1
NGFF_REFCLKN1: NGFF1.73 TP84.1
NGFF_REFCLKP0: NGFF1.47 R22.1
NGFF_REFCLKP1: NGFF1.71 TP83.1
NGFF_W_DISABLE1_N: NGFF1.56 R1620.2
NGFF_W_DISABLE2_N: NGFF1.54 R1621.2
NGFFCLK_REQ_N: Q1229.D R79760.2 R80066.2
OCS_48M_1: L9525.2 OSC2.4
OCS_48M_2: C12369.1 OSC2.1 R80151.2
ODTA0: GPU1.L18 MEM1.K1 MEM3.K1
ODTA1: GPU1.K16 MEM2.K1 MEM4.K1
OS_MODE_SEL: CPU1.AC2 R80178.2 SCA1.109
OSD_BIST_N: R535.1 R744.2
OSD_BIST_N_1: Q9632.2 R535.2
OSD_CONTROL_SEL: CPU1.M2 R80179.2 SCA1.111
OSD_DN: C238.1 R1755.1 R1758.1 R79790.1 R80187.2
OSD_DN_CPU: CPU1.AD4 R80187.1
OSD_DN_IC: R79790.2 SCA1.50
OSD_DN_R: PWRCN1.2 R1755.2
OSD_MENU: C585.1 R755.1 R758.1 R79792.1 R80188.2 R80206.1
OSD_MENU_CPU: CPU1.M3 R80188.1
OSD_MENU_IC: R79792.2 SCA1.52
OSD_MENU_R: PWRCN1.1 R758.2
OSD_MENU_SIO: R80206.2 U109.109
OSD_UP: C582.1 R742.2 R743.1 R744.1 R79791.1 R80186.2
OSD_UP_CPU: CPU1.AD3 R80186.1
OSD_UP_IC: R79791.2 SCA1.51
OSD_UP_R: PWRCN1.3 R743.2
OZ554_ENA: C3458.1 R79625.1 R79627.1 U120.3
OZ554_PWM: C8.1 R79621.1 R79623.1 U120.5
OZ554_VIN: C3457.1 R5.2 U120.4
P1P2V: C12246.1 L9504.1 PC12172.1 U9601.2
P3P3V: C11358.1 C11359.1 C12172.1 C12245.1 L9505.1 Q9601.S R9609.1 R79810.2 U9601.3 U9615.1
PANEL_OFF: CPU1.J4 Q9619.D R79866.2 R80240.1
PANEL_OFF_C: Q9619.G R79868.2 R80240.2 SCA1.113
PANEL_ON: R9542.1 R9544.2 SCA1.112
PANEL_ON1: Q9503.2 R9542.2
PANEL_ON2: Q9503.5 Q9503.6 R9543.2
PANEL_ON3: Q9503.3 R9556.2
PANEL_ON_1: R33.1 R39.1 R41.2 R42.1
PANEL_ON_2: Q10.B R42.2
PANEL_ON_3: C14.2 Q5.D R19.1 R20.2 U1.3
PANEL_ON_4: Q1.G Q5.G Q10.C R26.2 R30.1
PANEL_ON_5: Q1.D R8.1
PANEL_SEL1_CABLE: R1730.1 R79814.1 R79817.2
PANEL_SEL1_CABLE_C: CONVT1.7 R1730.2 R1734.2
PANEL_SEL1_CABLE_EC: R79814.2 U109.102
PANEL_SEL1_CABLE_S: R79799.2 R79802.1 R79817.1 SCA1.33
PANEL_SEL2_CABLE: R287.1 R79815.1 R79818.2
PANEL_SEL2_CABLE_C: CONVT1.8 R287.2 R1731.2
PANEL_SEL2_CABLE_EC: R79815.2 U109.103
PANEL_SEL2_CABLE_S: R79800.2 R79801.1 R79818.1 SCA1.32
PANEL_SEL3_CABLE: R1732.1 R79816.1 R79819.2
PANEL_SEL3_CABLE_C: CONVT1.9 R1732.2 R1733.2
PANEL_SEL3_CABLE_EC: R79816.2 U109.104
PANEL_SEL3_CABLE_S: R79797.1 R79798.2 R79819.1 SCA1.31
PB_IN_N_1: C12250.1 R332.2 R333.2 R79873.1 U109.72
PB_IN_N_1_C: R79873.2 U109.111
PB_IN_SW1: D5207.2 PWRCN1.6 R1756.1 R1760.2
PC_MONITOR_SW: R9521.1 R80175.2 SCA1.104 U9615.5 U9615.7
PC_MONITOR_SW_G: C12375.2 Q9643.G R8516.1 R80175.1
PCB_VER_ID: R79720.1 R79721.2 U4101.49
PCH_AUD_RST_N: R392.1 R79940.1 U109.19
PCH_AUD_RST_N_1: Q9622.2 R392.2
PCH_BKLT_PWM_1: Q9614.3 Q9614.6 R79174.1
PCH_CHAR_CTL3: CPU1.B9 R80108.2 R80110.2 R80134.1
PCH_DPWROK: CPU1.BB20 R79942.2 R80047.2
PCH_DVI_CLK: Q9502.1 R9534.1
PCH_DVI_DATA: Q9502.4 R9535.1
PCH_JTAG_TCK: CPU1.B56 R9914.1 R9921.2 R79996.1
PCH_JTAG_TDI: CPU1.D59 R9916.1 R79999.1
PCH_JTAG_TDO: CPU1.A56 R9920.1 R79998.1
PCH_JTAG_TMS: CPU1.C59 R9917.1 R79997.1
PCH_POPIRCOMP: CPU1.AU16 R80006.1
PCH_PWROK: DB1.1 Q9638.D R80045.1 R80148.1
PCH_PWROK_C_1: Q9638.G Q9639.6 R8513.2
PCH_PWROK_C_2: Q9639.2 R80145.2
PCH_PWROK_C_3: Q9639.5 R80146.2
PCH_RTCRST_DOWN: BTRST1.1 R80058.1
PCH_RTCRST_PULLUP: BTRST1.2 C12353.1 CPU1.AM16 R80055.1 R80057.2
PCH_SATA_LED_1: Q9631.5 Q9631.6 R1759.2
PCH_SATA_LED_R: Q9631.2 R1754.2
PCH_SIO_DPWROK: R1946.2 R79942.1 R80165.1 U109.14
PCH_SRTCRSTB_PULLUP: C12354.1 CPU1.AN18 R80055.2 R80056.1 R80059.2
PCH_WAKE_N: CPU1.BB15 R80048.1
PCIE_CALR_RX: GPU1.AA22 R1162.1
PCIE_CALR_TX: GPU1.Y22 R1161.1
PCIE_CLKREQ1_CPU_N: CPU1.AT7 R80065.1
PCIE_CLKREQ2_CPU_N: CPU1.AT8 R80066.1
PCIE_CLKREQ3_CPU_N: CPU1.AT10 R80064.1
PCIE_RST#: NGFF1.52 NGFF1.66 RN2.2(A)
PCIE_RX_CPU_N4: C1808.2 CPU1.F16
PCIE_RX_CPU_N5: CPU1.G18 R1712.2
PCIE_RX_CPU_N8: C325.2 CPU1.E22
PCIE_RX_CPU_P4: C1805.2 CPU1.E16
PCIE_RX_CPU_P5: CPU1.F18 R1711.2
PCIE_RX_CPU_P8: C324.2 CPU1.E23
PCIE_TX_CON_N4: C12338.1 U16.14
PCIE_TX_CON_N5: C12343.1 R1714.2
PCIE_TX_CON_N8: C12347.1 U14.4
PCIE_TX_CON_P4: C12339.1 U16.13
PCIE_TX_CON_P5: C12342.1 R1713.2
PCIE_TX_CON_P8: C12346.1 U14.3
PCIE_TX_CPU_N4: C12338.2 CPU1.C19
PCIE_TX_CPU_N5: C12343.2 CPU1.D20
PCIE_TX_CPU_N8: C12347.2 CPU1.B23
PCIE_TX_CPU_P4: C12339.2 CPU1.D19
PCIE_TX_CPU_P5: C12342.2 CPU1.C20
PCIE_TX_CPU_P8: C12346.2 CPU1.A23
PCIRST1#: R80168.1 RN2.5(B) RN2.6(B) U109.30
PCIRST3#: R80167.1 RN2.7(B) RN2.8(B) U109.81
PD4405_A: PD4405.A PQ4409.B
PD4405_K: PD4405.K PR4458.2
PD_N: Q1249.D U118.36
PECI_EC: CPU1.A54 R79990.1
PECI_SIO: C12126.1 R79739.1 U109.51
PEG_C_RXN0: C1840.2 GPU1.AG31
PEG_C_RXN1: C1842.2 GPU1.AF28
PEG_C_RXN2: C1844.2 GPU1.AF26
PEG_C_RXN3: C1845.2 GPU1.AD26
PEG_C_RXP0: C1838.2 GPU1.AH30
PEG_C_RXP1: C1839.2 GPU1.AG29
PEG_C_RXP2: C1841.2 GPU1.AF27
PEG_C_RXP3: C1843.2 GPU1.AD27
PEG_C_TXN0: C12341.2 CPU1.B17
PEG_C_TXN1: C12349.2 CPU1.D16
PEG_C_TXN2: C12340.2 CPU1.D17
PEG_C_TXN3: C12348.2 CPU1.B19
PEG_C_TXP0: C12345.2 CPU1.A17
PEG_C_TXP1: C12337.2 CPU1.C16
PEG_C_TXP2: C12344.2 CPU1.C17
PEG_C_TXP3: C12336.2 CPU1.A19
PEG_CLK_CPU: CPU1.E43 R9913.2
PEG_CLK_CPU#: CPU1.F43 R9923.2
PEG_CLK_XDP: R9913.1 XDP1.40
PEG_CLK_XDP#: R9923.1 XDP1.42
PEG_CLKREQ0_CPU#: CPU1.AR10 R79762.2
PEG_CLKREQ4_CPU#: CPU1.AU8 R79761.2
PEG_CLKREQ5_CPU#: CPU1.AU7 R79763.2
PEG_RCOMPN_CPU: CPU1.F5 R1604.1
PEG_RCOMPP_CPU: CPU1.E5 R1604.2
PEG_RXN0: C1840.1 CPU1.H13
PEG_RXN1: C1842.1 CPU1.G11
PEG_RXN2: C1844.1 CPU1.H16
PEG_RXN3: C1845.1 CPU1.G15
PEG_RXP0: C1838.1 CPU1.G13
PEG_RXP1: C1839.1 CPU1.F11
PEG_RXP2: C1841.1 CPU1.G16
PEG_RXP3: C1843.1 CPU1.F15
PEG_TXN0: C12341.1 GPU1.AE31
PEG_TXN1: C12349.1 GPU1.AD28
PEG_TXN2: C12340.1 GPU1.AC31
PEG_TXN3: C12348.1 GPU1.AB28
PEG_TXP0: C12345.1 GPU1.AF30
PEG_TXP1: C12337.1 GPU1.AE29
PEG_TXP2: C12344.1 GPU1.AD30
PEG_TXP3: C12336.1 GPU1.AC29
PHASE1_R: PG4.1 PR45.2
PIRQA#: CPU1.BB11 R80080.2
PLTRST#_PCH: CPU1.AN10 R80052.1
PLTRST*_EC: R79697.1 U4101.6
PLTRST*_SIO: C180.1 R251.1 R256.1 U109.46
PLTRST_CR: RN2.4(A) U14.1
PLTRST_LAN_N: RN2.1(A) U16.19
PLTRST_N: C12350.1 LPC1.3 R256.2 R9930.1 R79697.2 R80051.1 R80052.2
PLTRST_SL_N: D7.1 D7.2 D34.3 R1159.1 R1160.2 RN2.3(A)
PM_CLKRUN#_EC: R80212.1 U4101.7
PM_DPRSLPVR: PR7.1 PR15.2 U9.39
PM_PCH_PWROK: CPU1.BA20 R80045.2 RN9504.3(B)
PM_PWRBTN_N: CPU1.BA15 R333.1 R334.2 R9926.2
PM_RSMRST_PWRGD_XDP: R9903.2 R9904.2 XDP1.39
PM_SLP_S3#_R: R79789.2 SCA1.34
PORTC_SPK_L: C12332.1 U6.43
PORTC_SPK_L_1: C12332.2 R384.1
PORTC_SPK_R: C12331.1 U6.44
PORTC_SPK_R_1: C12331.2 R383.1
PQ4206_D: PQ4206.D PR4214.2
PQ4406_2: PQ5008.2 PR4462.2
PQ4406_3: PQ5008.3 PR4455.2
PQ4406_5: PC4426.1 PQ5008.5 PR8522.2
PQ4406_6: PC4426.2 PQ5008.6 PR4450.1
PQ4409_C: PQ4409.C PR4451.1 PR4462.1
PQ4409_E: PQ4409.E PR8523.2 PR8524.1
PRE: R2088.2 R2090.1 U118.16
PROC_SELECT#: CPU1.C64 R603.1
PROCHOT#_CPU: CPU1.C65 R403.2
PRW_VGA_CORE_RBIAS: PR9.1 U9.3
PS_0: C1847.1 GPU1.AC19 R80083.1 R80084.1
PS_1: C1849.2 GPU1.AD19 R943.1 R948.1
PS_2: C1850.1 GPU1.AE17 R1899.1 R1900.1
PS_3: C1848.1 GPU1.AE20 R935.2 R940.1
PSI#: PR3.1 PR4.2 U9.2
PSID_D: L15.2 Q47.D R1852.1
PSID_D_1: Q45.B R1852.2 R1853.1
PSID_G: Q45.C Q47.G R1849.2
PSYS: PR4612.2 PU4601.50
PW_CLEAR: CPU1.U7 PSWD1.2 R151.1
PWM_SW_EN: Q9614.2 Q9614.5 R79205.1 SCA1.54
PWR_0D95V_VGA_EN: PC8409.1 PR8514.2 PU8401.5
PWR_0D95V_VGA_FB: PC8401.2 PR8401.1 PR8403.2 PR8405.1 PU8401.6
PWR_0D95V_VGA_FB_R1: PC8401.1 PG8401.2 PR8403.1
PWR_0D95V_VGA_FB_R2: PC8402.1 PR8405.2
PWR_0D95V_VGA_LX: PL8401.1 PU8401.1 PU8401.2 PU8401.3
PWR_0D95V_VGA_PG: PR8404.2 PR8513.1 PU8401.4
PWR_0D95V_VGA_PVIN: PC8406.1 PC8407.1 PG8402.2 PG8404.2 PR8402.1 PU8401.9 PU8401.10
PWR_0D95V_VGA_SVIN: PC8408.1 PR8402.2 PU8401.8
PWR_1D0V_BOOT: PR5210.1 PU5201.10
PWR_1D0V_BOOT_R: PC5206.2 PR5210.2
PWR_1D0V_CS: PR5219.1 PU5201.2
PWR_1D0V_EN: PC5207.1 PR5217.2 PR5218.2 PU5201.3
PWR_1D0V_FB: PC5203.2 PR5207.1 PR5208.2 PU5201.4
PWR_1D0V_FB_R: PC5203.1 PG5202.2 PR5208.1
PWR_1D0V_LGATE: PU5201.6 PU5203.4
PWR_1D0V_PG: PR5212.2 PR8510.1 PU5201.1
PWR_1D0V_PHASE: PC5206.1 PL5201.1 PR5214.1 PU5201.8 PU5202.1 PU5202.2 PU5202.3 PU5203.5 PU5203.6 PU5203.7 PU5203.8
PWR_1D0V_RF: PR5202.1 PU5201.5
PWR_1D0V_SNB: PC5205.1 PR5214.2
PWR_1D0V_UGATE: PU5201.9 PU5202.4
PWR_1D8V: PC5303.1 PC5305.1 PC5306.1 PC5307.1 PC5310.1 PG5301.1 PG5302.1 PL5301.2 PR5309.1 PR5310.1 PR5311.1
PWR_1D8V_BOOT: PR5301.1 PU5301.10
PWR_1D8V_BOOT_A: PC5301.1 PR5301.2
PWR_1D8V_EN: C12368.1 PR8516.2 PU5301.13
PWR_1D8V_FB: PC5304.2 PR5302.1 PR5305.2 PU5301.12
PWR_1D8V_FB_1: PC5304.1 PG5302.2 PR5305.1
PWR_1D8V_LX: PC5301.2 PL5301.1 PR5303.1 PR5312.1 PU5301.8 PU5301.9 PU5301.15 PU5301.16
PWR_1D8V_PG: PR5304.2 PR8515.1 PU5301.4
PWR_1D8V_SNB: PC5302.1 PR5303.2
PWR_1D8V_VBYP: PR5306.2 PU5301.3
PWR_1D8V_VCC: PC5308.1 PU5301.11
PWR_1D8V_VOUT: PC5312.2 PG5301.2 PR5313.2 PU5301.7
PWR_1D8V_VOUT_1: PC5312.1 PR5312.2 PR5313.1
PWR_1D35V_VGA_EN: PC12187.1 PR8505.2 PU8501.8
PWR_1D35V_VGA_FB_M: PC12189.2 PR8503.1 PR8504.2 PU8501.2
PWR_1D35V_VGA_FB_M1: PC12189.1 PR8502.1 PR8504.1
PWR_1D35V_VGA_PG: PC12185.1 PR8501.2 PR8518.2 PU8501.7
PWR_3D3V_BOOT2: PR4501.1 PU4501.7
PWR_3D3V_BOOT2_1: PC4508.1 PR4501.2
PWR_3D3V_ENTRIP2: PC4512.1 PR4535.1 PU4501.4
PWR_3D3V_FB: PC4502.1 PG4501.2 PR4504.1
PWR_3D3V_FB2: PC4502.2 PR4503.1 PR4504.2 PU4501.5
PWR_3D3V_LDO3: PG4506.1 PU4501.15
PWR_3D3V_LGATE2: PU4501.10 PU4504.4
PWR_3D3V_PHASE2: PC4508.2 PL4502.2 PR5498.1 PU4501.9 PU4504.5 PU4504.6 PU4504.7 PU4504.8 PU4505.1 PU4505.2 PU4505.3
PWR_3D3V_SNB: PC12184.1 PR5498.2
PWR_3D3V_UGATE2: PU4501.8 PU4505.4
PWR_5V3D3V_ENLDO: PR4511.2 PU4501.12
PWR_5V3D3V_TON: PR4515.1 PU4501.3
PWR_5V3V_PGOOD: PR4509.2 PU4501.6
PWR_5V3V_SECFB: PR4508.2 PR4599.1 PU4501.13
PWR_5V_BOOT1: PR4513.1 PU4501.19
PWR_5V_BOOT1_1: PC4514.2 PR4513.2
PWR_5V_BYP1: PC4503.1 PC4528.1 PG4532.2 PR4518.1 PU4501.20
PWR_5V_ENTRIP1: PC4513.1 PR4506.1 PU4501.2
PWR_5V_FB1: PC4528.2 PR4518.2 PR4519.1 PU4501.1
PWR_5V_LDO: PC4505.1 PR4508.1 PU4501.14
PWR_5V_LGATE1: PU4501.16 PU4502.4
PWR_5V_PHASE1: PC4514.1 PL4501.1 PR4435.1 PU4501.17 PU4502.5 PU4502.6 PU4502.7 PU4502.8 PU4503.1 PU4503.2 PU4503.3
PWR_5V_SNB: PC4504.1 PR4435.2
PWR_5V_UGATE1: PU4501.18 PU4503.4
PWR_CHG_ACDET: PC4401.1 PR4409.1 PR4424.2 PU4404.6
PWR_CHG_ACN: PC4408.1 PC4413.2 PG4402.2 PU4404.1
PWR_CHG_ACP: PC4410.1 PC4413.1 PG4401.2 PU4404.2
PWR_CHG_AD_OFF: PQ4206.G PR4210.1 R80231.1 U4101.19
PWR_CHG_AD_OFF_R: PQ4204.B PR4210.2
PWR_CHG_BT_LR: PG4404.1 PL4401.2 PR4430.1
PWR_CHG_BTST: PR4425.1 PU4404.17
PWR_CHG_BTST_1: PC4415.1 PD4401.K PR4425.2
PWR_CHG_CMPIN: PR4405.2 PR4408.1 PR4411.2 PR4420.2 PR4428.1 PU4404.4
PWR_CHG_CMPIN_R: PQ4401.6 PR4428.2
PWR_CHG_CMPIN_RR: PQ4401.3 PR4411.1
PWR_CHG_HIDRV: PU4401.4 PU4404.18
PWR_CHG_ILIM: PQ4402.D PR4407.2 PR4416.1 PU4404.10
PWR_CHG_IOUT: PC4412.1 PR4405.1 PR4431.1 PU4404.7
PWR_CHG_LODRV: PC4409.1 PU4402.4 PU4404.15
PWR_CHG_NC: PR4422.1 PU4404.11
PWR_CHG_PHASE: PC4415.2 PL4401.1 PU4401.1 PU4401.2 PU4401.3 PU4402.5 PU4402.6 PU4402.7 PU4402.8 PU4404.19
PWR_CHG_SRN: PR4423.1 PU4404.12
PWR_CHG_SRN_1: PC4405.2 PC4411.1 PG4403.2 PR4423.2
PWR_CHG_SRP: PR4406.1 PU4404.13
PWR_CHG_SRP_1: PC4405.1 PG4404.2 PR4406.2
PWR_CHG_VCC: PC4418.1 PR4403.2 PU4404.20
PWR_DCBATOUT_1D0V: PC5204.1 PC5299.1 PR5204.2 PR5215.2 PR5221.2 PR5258.2 PT5201.1 PU5202.5 PU5202.6 PU5202.7 PU5202.8
PWR_DCBATOUT_1D8V: PC5309.1 PC5311.1 PR5307.1 PR5308.1 PU5301.1
