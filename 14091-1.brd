# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AV12: length 17.6
  BOTTOM w0.203: 176.18,142.49 175.79,142.89 U14.10
  BOTTOM w0.508: R79843.2 R79841.1 173.58,134.43 174.45,133.55 176.99,133.55 178.64,135.2 v2(178.64,135.78) 179.15,136.29 179.15,138.13 178.21,139.06 178.21,140.23 176.94,141.5 176.94,141.73 176.18,142.49
AV12_L: length 2.5
  BOTTOM w0.508: R79841.2 174.53,135.06 C12155.2 175.66,135.06 176.41,134.32 v2(176.59,134.32)
AVCC_EC: length 8.8
  TOP w0.203: U4101.52 91.32,52.09 91.47,51.94
  TOP w0.381: R79721.1 88.76,49.53 89.45,48.83 R79723.1
  TOP w0.508: R79723.1 89.66,48.92 91.47,48.92 v1(91.52,48.87) 91.67,48.87 92.43,49.62 L9526.2 92.43,50.1 91.66,50.86 C12384.1 91.47,51.24 91.47,51.94
DV12S: length 11.6
  BOTTOM w0.203: 172.8,141.07 173.87,142.14 173.9,142.14 174.19,142.43 U14.14
  BOTTOM w0.508: R79843.1 170.37,135 170.27,135.1 v2(170.16,135.1) 170.16,135.59 170.54,135.97 170.58,135.97 171.1,136.49 C12157.1 171.17,136.82 C12158.2 171.56,138.19 171.56,139.83 172.8,141.07
DV33_18: length 4.4
  BOTTOM w0.203: 171.79,144.2 171.79,144.34 171.99,144.54 U14.18
  BOTTOM w0.508: C12159.2 170.62,142.88 170.98,142.52 v2(171.14,142.52) 171.81,143.18 171.81,144.18 171.79,144.2
GND: length 2220.7
  TOP w0.089: v4(86.21,186.6) 86.21,186.28 86.6,185.89 86.6,185.21 86.57,185.07 86.57,184.91 86.62,184.72 86.62,184.55 CPU1.AK69 ; CPU1.B62 72.4,179.49 71.88,179.49 71.83,179.51 71.21,179.51 71.16,179.46 ; CPU1.B58 72.46,177.47 72.25,177.47 72.12,177.53 71.92,177.53 71.8,177.48 71.79,177.48 70.94,177.48 70.9,177.47 70.34,176.91 v4(69.88,176.91) ; v4(95.18,183.87) 95.18,183.77 94.52,183.1 94.51,183.1 CPU1.BB67
  TOP w0.102: CPU1.BB38 94.02,166.14 94.73,166.14 94.84,166.03 97.3,166.03 v4(98.04,166.78) ; 74.56,166.19 74.3,166.19 74.18,166.32 73.54,166.32 73.31,166.55 73.31,166.85 ; CPU1.F4 74.89,146.99 75.36,146.99 CPU1.G5 ; X9503.2 62.26,155.94 62.26,155.94 62.27,155.93 v3(64.3,155.93)
  TOP w0.127: v4(95.48,168.92) 95.17,168.92 95.04,168.8 94.02,168.8 CPU1.BB43 ; CPU1.AP70 89.56,184.49 89.56,186.31 v4(89.64,186.39) ; CPU1.AW30 92.04,161.69 92.01,161.72 92.01,162.48 CPU1.AW32 ; v4(95.41,159.49) 95.25,159.65 94.62,159.65 94.42,159.86 93.65,159.86 93.5,160.01 CPU1.BA28 ; v4(94.96,180.86) 94.93,180.89 CPU1.BB64 ; CPU1.E21 74.41,156.1 74.03,155.72 74.03,155.35 73.68,155 CPU1.D18 ; v4(84.22,189.04) 84.96,188.3 84.96,186.17 85.5,185.63 CPU1.AG71 ; CPU1.BB55 94.2,175.94 94.24,175.95 96.13,175.95 97.62,177.44 v4(97.89,177.44) ; CPU1.AT71 90.51,185.84 90.99,186.32 v4(90.99,186.54) ; v4(94.27,187.17) 94.83,186.61 94.83,185.4 94.31,184.88 CPU1.BB70 ; v4(96.31,158.03) 96.09,158.25 95.24,158.25 94.65,158.83 CPU1.BB26 ; v4(95.26,178.77) 95.06,178.56 94.01,178.56 CPU1.BB60 ; v4(59.52,95.79) 59.16,95.42 59.16,95.02 58.81,94.68 MEM2.M1 ; v4(87.97,186.59) 88.17,186.39 88.17,185 CPU1.AM71 ; CPU1.BB30 95.57,161.19 v4(95.74,161.02) ; CPU1.AW62 92.01,179.69 92.01,178.47 CPU1.AW60 ; CPU1.AW26 92.04,159.22 92.01,159.25 92.01,159.55 92.04,159.58 CPU1.AW28 ; CPU1.BB34 94.67,163.82 94.74,163.75 97.16,163.75 97.34,163.93
  TOP w0.152: CPU1.K22 76.63,157.41 75.71,157.41 CPU1.G22 75.38,157.73 v4(75.38,157.86) ; CPU1.BA23 92.94,157.22 92.36,157.22 CPU1.AW23 92.04,157.98 92,158.02 92,158.39 92.04,158.43 CPU1.AW26 ; CPU1.L4 77.57,147.02 78.21,147.02 CPU1.N6 ; v4(75.47,175.23) 75.54,175.16 75.79,175.16 76.03,174.92 76.03,174.64 75.85,174.46 75.85,174 CPU1.G52 ; CPU1.K67 76.14,182.73 75.76,182.35 CPU1.G66 ; CPU1.D30 74,162.07 74,160.25 CPU1.D26
  TOP w0.178: CPU1.AM27 87.83,160.03 87.83,159.35 CPU1.AM25 ; CPU1.P17 79.26,154.49 79.26,154.92 79.64,155.3 CPU1.P19 ; v3(66.73,60.45) 66.73,60.78 67.26,61.31 67.73,61.31 68.15,60.9 SCA1.11 ; CPU1.AP20 CPU1.AR20 ; CPU1.AW64 92.04,181.34 91.98,181.4 91.98,181.72 92.02,181.75 92.02,181.98 CPU1.AW66 ; CPU1.G45 75.71,170.03 75.82,169.91 75.82,169.41 CPU1.G43 ; CPU1.AM61 87.83,179.23 87.83,178.55 CPU1.AM60 ; CPU1.AP42 CPU1.AR42 CPU1.AT42 ; CPU1.N13 78.6,152.43 78.38,152.65 78.38,153.05 CPU1.L16
  TOP w0.203: U109.35 130.15,62.17 130.46,62.48 v3(130.46,62.74) ; U52.11 v3(124.87,7.37) ; CPU1.L18 CPU1.L17 77.31,154.76 CPU1.K18 ; U4101.10 96.29,58.26 v3(96.07,58.04) ; CPU1.AR58 90.47,177.52 ; U118.8 136.29,36.56 v3(136.3,36.58) ; v3(121.06,73.41) 121,73.47 PU5301.14 ; v4(71.53,107.58) 71.54,107.59 72.59,107.59 GPU1.B26 ; v4(92.74,164.87) 92.62,164.99 CPU1.AW36 ; CPU1.J8 77.2,149.17 CPU1.L8 ; CPU1.AW49 92.04,172.56 92.36,172.89 CPU1.AW50 ; CPU1.AW49 92.04,171.97 92.02,171.96 92.02,171.18 CPU1.AW47 ; CPU1.AW49 92.51,172.36 v4(92.66,172.51) ; PU5301.5 119.54,77.44 v3(119.41,77.57) 119.14,77.3 PU5301.6 ; U9.22 128.68,97.02 v3(128.3,96.65) ; CPU1.AJ15 86.34,152.78 86.07,152.51 CPU1.AH13 ; CPU1.AN63 87.95,179.61 CPU1.AM61 ; CPU1.AN63 88.1,180.76 CPU1.AL64 87.63,180.76 CPU1.AK63 ; CPU1.AN63 CPU1.AP63 ; v4(90.87,151.46) 90.9,151.43 CPU1.AW12 ; GPU1.B8 71.6,93.2 v4(71.49,93.3) ; CPU1.AW64 92.04,180.6 91.97,180.53 91.97,179.79 CPU1.AW62 v4(92.64,179.72) ; CPU1.G6 75.36,148.61 75.36,148.87 CPU1.F8 75.06,149.31 v4(75.38,149.63) ; CPU1.AW18 CPU1.BA18 CPU1.BB18 ; Q9654.4 78.25,223.76 78.05,223.96 78.05,224.62 77.61,225.06 Q9654.1 ; v4(70.9,102.93) 71.02,102.8 GPU1.B20 ; CPU1.AR50 89.53,172.59 v4(89.53,172.48) 89.53,172.4 CPU1.AR48 CPU1.AR46 ; GPU1.B14 71.59,98 71.41,97.82 v4(71.34,97.82) ; v4(75.08,97.48) 75.25,97.48 75.97,98.2 GPU1.H14 ; CPU1.AD20 83.83,156.14 83.81,156.17 83.81,156.69 CPU1.AD21 ; U4101.45 89.67,55.86 90.2,55.32 v3(90.2,54.74) ; U9.27 130.68,97.17 v3(131.12,96.73) ; v4(92.73,174.6) 92.57,174.76 CPU1.AW53 ; v3(132.75,34.8) 132.55,34.6 U118.35 ; v3(92.24,51.89) 92.24,51.94 91.72,52.45 U4101.53 ; v4(73.74,144.21) 73.79,144.26 74.02,144.26 74.3,144.54 74.3,144.78 CPU1.F1 CPU1.F2 CPU1.F4 ; CPU1.J11 77,151 76.55,150.55 76.17,150.55 CPU1.G10 ; X9503.2 60.36,157.84 60.36,158.37 ; CPU1.K70 CPU1.K71 77.31,185.04 77.31,185.61 v4(77.49,185.79) ; CPU1.A67 72.03,182.56 72.32,182.56 72.65,182.23 CPU1.B66 ; v4(79.23,157.05) 79.31,157.05 CPU1.P21 ; v3(142.78,63.12) 142.27,63.12 141.81,63.58 U109.4 ; CPU1.AT2 90.12,145.33 90.12,144.29 v4(90.11,144.29) ; CPU1.AW43 92.02,168.69 92.02,169.5 92.04,169.52 CPU1.AW45 92.09,169.9 92.66,169.9 v3(92.69,169.86) ; CPU1.AM46 87.87,171.04 87.87,170.28 CPU1.AM45 ; CPU1.K16 77.12,153.56 76.63,154.05 76.63,154.29 76.36,154.56 CPU1.H18 ; 89.74,174.62 89.74,174.02 CPU1.AR52 ; U109.71 133.01,50.18 v3(133.26,50.42) ; U118.15 132.95,39.06 v3(133,39.12) ; CPU1.AR11 89.9,150.87 v4(89.57,150.55) ; GPU1.B12 v4(71.65,96.4) ; CPU1.D45 73.8,170.51 CPU1.E46 ; PU5301.2 120.84,75.46 v3(121.19,75.82) ; CPU1.BA2 93.68,144.98 93.76,144.91 93.76,144.78 CPU1.BA1 ; CPU1.AG20 85.56,156.11 85.56,156.66 CPU1.AG21 85.51,157.1 v4(85.2,157.4) ; v4(85.25,159) 85.46,158.8 85.46,158.69 86.74,157.4 CPU1.AK22 ; CPU1.AP32 CPU1.AN32 ; v4(92.76,167.59) 92.63,167.47 CPU1.AW41 92.02,167.45 92.02,166.29 ; CPU1.AR45 89.9,170.11 v4(89.55,169.77) 89.55,169.7 89.9,169.36 CPU1.AR43 ; v4(71.17,104.4) GPU1.B22 ; U4101.21 94.52,60.33 v3(94.39,60.2)
  TOP w0.229: GPU1.H2 76.27,89.53 v4(76.27,88.69) ; GPU1.B6 72.59,91.6 72.56,91.63 71.72,91.63 71.52,91.43 v4(71.46,91.43) ; CPU1.AB18 83.41,154.35 83.41,153.88 CPU1.AD16
  TOP w0.254: CPU1.AN35 88.6,164.85 v4(88.92,165.18) ; v4(75.4,168.84) 75.4,168.99 CPU1.G43 75.72,169.29 CPU1.J42 ; CPU1.U10 81.05,150.02 v4(81.27,150.24) ; CPU1.AH6 86.3,147.19 86.34,147.19 v4(86.63,146.89) 86.89,146.64 CPU1.AJ4 CPU1.AL4 ; v4(75.47,175.23) 75.71,175.47 CPU1.G55 ; 89.57,157.99 CPU1.AR23 CPU1.AT23 90.97,158.74 91.66,158.74 91.66,158.74 CPU1.AW26 ; 89.57,157.99 v4(89.57,157.86) ; 89.57,157.99 89.57,158 CPU1.AP23 89.22,158.34 88.62,158.34 CPU1.AN23 ; v4(90.22,153.29) 90.22,153.16 CPU1.AR15 ; v4(86.68,175.25) 86.69,175.24 CPU1.AL55 87.93,175.69 CPU1.AM55 ; CPU1.AB8 82.73,148.71 82.39,149.05 v4(82.35,149.05) ; CPU1.V18 81.5,154.76 CPU1.Y19 CPU1.Y20 82.09,156.12 82.09,156.65 CPU1.Y21 82.38,156.94 82.38,157.33 ; CPU1.B10 CPU1.D10 73.64,150.05 CPU1.D11 74.09,150.69 CPU1.E11 ; GPU1.A30 71.98,110 71.94,110.04 71.55,110.04 71.53,110.02 v4(71.32,110.02) ; CPU1.BA66 CPU1.AY66 92.56,182.09 CPU1.AW66 91.71,182.28 CPU1.AV68 ; CPU1.K70 77.26,183.45 CPU1.K68 77.15,182.94 CPU1.K67 CPU1.K66 CPU1.K65 CPU1.K64 CPU1.K63 ; v4(74,176.09) 74.41,176.5 CPU1.E56 73.75,177.27 CPU1.D58 ; CPU1.A67 71.26,182.9 v4(70.9,183.26) ; 82.38,157.33 81.16,158.54 v4(81.16,158.55) 81.14,158.55 80.48,157.89 CPU1.T21 ; 82.38,157.33 CPU1.AB21 ; CPU1.AK11 86.68,150.34 v4(86.54,150.34) 86.54,149.18 CPU1.AK8 87.57,148.71 v4(87.57,148.71) 87.57,148.8 CPU1.AM8 ; v4(75.45,171.58) 75.71,171.84 CPU1.G48 ; GPU1.F2 74.6,89.77 75.01,90.18 75.01,90.57 74.77,90.81 74.68,90.81 v4(74.37,91.12) ; v4(88.92,161.52) 88.6,161.19 CPU1.AN28 ; v4(88.92,161.52) 88.6,161.84 CPU1.AN30 ; v4(88.92,161.52) 89.25,161.19 CPU1.AP28 89.31,161.12 89.84,161.12 CPU1.AR28 CPU1.AT28 ; v4(76.01,185.77) 75.9,185.66 CPU1.H71 ; CPU1.AM21 87.72,156.71 CPU1.AK21 87.01,156.89 CPU1.AK22 ; CPU1.G58 75.71,177.65 v4(75.38,177.98) 75.38,178.11 CPU1.G60 ; CPU1.E6 74.41,148.52 CPU1.F8 ; CPU1.AW34 91.79,163.97 91.56,163.97 91.35,164.18 91.09,164.18 CPU1.AT35 90.52,164.74 89.92,164.74 CPU1.AR35 89.57,165.04 89.57,165.07 ; GPU1.B10 72.46,94.94 v4(71.51,94.94) ; v4(88.92,167.01) 88.92,167.14 CPU1.AN40 ; v4(88.92,167.01) 89.25,166.68 CPU1.AP38 ; v4(88.92,167.01) 88.92,166.95 88.6,166.63 CPU1.AN38 88.14,166.09 CPU1.AL38 ; v4(92.66,172.51) 92.82,172.36 CPU1.BA49 ; CPU1.AA4 CPU1.AA2 ; MEM1.G8 58.1,112.8 58.73,112.8 MEM1.G9 58.81,113 58.96,113.14 58.96,113.54 MEM1.F9 ; v4(92.74,164.87) 92.88,164.87 93,164.99 CPU1.BA36 ; v4(72.65,144.1) 72.65,144.31 CPU1.C1 ; v4(79.2,181.09) 78.88,181.41 CPU1.N65 ; CPU1.AL52 86.72,173.41 v4(86.72,173.41) ; CPU1.AF63 85.29,180.11 v4(85.6,180.42) ; CPU1.AU10 91.88,150.09 CPU1.AW10 v4(92.67,150.25) CPU1.BA10 ; v4(78.14,149.03) 78.04,149.03 77.72,148.71 CPU1.L8 ; CPU1.D26 73.64,159.88 CPU1.D25 CPU1.C25 ; CPU1.F40 75.31,167.72 75.31,168.12 CPU1.F42 ; CPU1.AN43 88.27,168.97 v4(88.27,168.83) 87.95,169.16 CPU1.AM43 87.93,169.29 CPU1.AL45 87.49,169.75 CPU1.AM45 ; CPU1.AM60 87.95,178.3 v4(88.27,177.98) 88.27,177.85 CPU1.AN58 ; CPU1.R13 79.37,151.66 v4(79.15,151.66) 78.9,151.66 CPU1.N13 ; CPU1.AN58 88.62,177.5 89.22,177.5 CPU1.AP58 ; CPU1.AN58 88.14,177.06 CPU1.AL58 ; CPU1.W9 82.12,149.69 v4(82.37,149.69) ; v4(89.57,154.2) 89.58,154.2 89.58,154.07 CPU1.AR16 ; CPU1.AR55 89.62,175.42 v4(89.62,175.23) 89.62,175.05 CPU1.AR53 89.74,174.62 ; v4(91.55,175.26) 92.04,175.75 CPU1.AW55 91.92,176.15 91,176.15 CPU1.AT56 90.32,176.83 90.32,177.3 CPU1.AT58 90.47,177.52 ; CPU1.AD21 83.83,157.43 v4(83.75,157.51) ; CPU1.AN42 88.81,168.59 88.81,168.7 88.93,168.82 ; v4(79.2,183.69) 78.88,183.36 CPU1.N68 ; CPU1.U69 80.71,184.01 v4(81.03,184.34) 80.71,184.66 CPU1.U70 ; CPU1.AT63 90.52,180.24 89.92,180.24 CPU1.AR63 89.87,180.24 89.27,180.24 CPU1.AP63 ; 75.08,163.35 CPU1.J32 ; CPU1.AW18 92.04,154.83 91.52,154.31 v4(91.52,154.2) 91.87,153.86 CPU1.AW16 ; CPU1.B14 CPU1.D14 ; CPU1.BA53 92.89,174.76 v4(92.73,174.6) ; v4(74.18,171.58) 74.11,171.64 CPU1.D47 73.54,171.64 72.86,172.31 CPU1.B48 ; 89.57,165.07 89.25,164.74 CPU1.AP35 88.92,165.04 v4(88.92,165.18) ; 89.57,165.07 v4(89.57,165.18) ; CPU1.BA32 93.23,162.55 v4(92.67,162.55) 92.63,162.52 CPU1.AW32 91.57,162.52 CPU1.AU32 ; CPU1.AL64 87.86,180.78 87.86,180.78 87.92,180.84 87.92,181.34 CPU1.AL65 CPU1.AL66 88.06,182.27 CPU1.AM68 ; v4(94.16,144.21) 93.85,144.52 CPU1.BA1 ; CPU1.AF10 85.36,149.65 85.49,149.65 v4(85.49,149.65) ; GPU1.C1 73,88.63 v4(73.03,88.6) ; CPU1.AR8 89.58,149.5 89.58,149.63 v4(89.57,149.63) ; CPU1.AU38 91.76,166.55 CPU1.AW38 ; CPU1.L18 78.15,154.76 CPU1.N19 78.61,155.41 CPU1.L20 ; CPU1.AW6 92.67,147.87 v4(92.7,147.89) 92.7,147.87 92.74,147.83 CPU1.BA6 CPU1.BB6 ; CPU1.AN32 88.27,162.57 v4(88.27,162.43) 88.27,162.43 CPU1.AL32 ; v4(90.87,153.29) 90.88,153.29 90.88,153.15 CPU1.AU15 ; v4(71.69,101.39) 72.41,101.39 GPU1.B18 ; CPU1.AF4 CPU1.AF2 CPU1.AF1 85.14,144.6 v4(85.34,144.4) ; v4(91.75,149.5) 91.75,149.3 CPU1.AW8 ; CPU1.AD20 CPU1.AD19 ; v4(85.6,180.42) 85.91,180.11 CPU1.AH63 ; v4(85.6,180.42) 85.77,180.6 85.9,180.6 CPU1.AH64 ; CPU1.D62 CPU1.B62 ; CPU1.A70 71.15,185.38 v4(71.15,185.42) ; CPU1.BA14 v4(92.67,152.67) CPU1.AW14 ; v4(82.86,183.69) 82.54,183.36 CPU1.AA68 ; v3(77,165.18) CPU1.J35 ; v4(90.19,182.57) 89.8,182.57 CPU1.AP68 ; CPU1.U64 80.71,180.76 v4(81.03,180.44) 80.71,180.11 CPU1.U63 ; CPU1.F23 75.38,158 75.38,157.86 v4(75.38,157.86) ; CPU1.T2 CPU1.T4 79.67,146.81 CPU1.R6 80,147.41 v4(80.2,147.62) ; v4(71.64,89.69) 71.95,90 GPU1.A3 ; CPU1.AP42 88.93,168.69 88.93,168.82 ; CPU1.B53 CPU1.D53 74.04,174.43 74.04,173.33 v4(74.04,173.33) 74.41,172.96 CPU1.E50 ; HDMI2.8 118.67,13.32 v3(118.91,13.08) ; CPU1.AD16 84.48,152.81 CPU1.AF15 84.86,152.81 CPU1.AG16 CPU1.AG17 CPU1.AG18 CPU1.AG19 CPU1.AG20 ; v4(94.22,186.19) 93.85,185.82 CPU1.BA71 ; CPU1.N6 78.88,147.41 v4(79.14,147.68) ; v4(82.35,151.6) 82.25,151.6 81.88,151.97 CPU1.W13 ; CPU1.B71 71.41,186.06 v4(71.15,186.06) ; CPU1.H15 76.49,152.83 CPU1.K16 CPU1.L16 CPU1.L17 ; CPU1.AT2 CPU1.AT4 90.44,146.8 CPU1.AR5 ; CPU1.P19 CPU1.P20 79.7,156.13 79.7,156.65 CPU1.P21 ; CPU1.AT20 90.52,155.6 89.92,155.6 CPU1.AR20 ; v3(119.9,103.38) 120.05,103.53 122.88,103.53 PR29.1 ; CPU1.AU20 91.9,156.28 CPU1.AW21 ; CPU1.AJ20 86.76,155.64 86.76,155.18 CPU1.AK18 CPU1.AJ18 86.76,154.34 86.76,153.88 CPU1.AK16 86.65,152.93 86.46,152.93 CPU1.AJ15 ; CPU1.AK68 86.71,183.36 CPU1.AH67 85.93,182.71 v4(85.6,182.39) ; CPU1.AW50 92.36,173.22 CPU1.AW51 ; GPU1.K2 77.8,88.89 78.05,88.65 v4(78.05,88.39) ; CPU1.U67 80.71,182.71 v4(81.03,182.39) 80.71,182.06 CPU1.U66 ; CPU1.N10 78.92,150.33 79.1,150.33 v4(79.12,150.35) ; CPU1.E65 74.19,181.49 74.19,181.71 CPU1.D66 CPU1.B66 ; CPU1.F13 74.76,151.62 74.76,151.41 74.41,151.06 CPU1.E11 ; CPU1.AB16 82.34,154.11 CPU1.Y17 ; v4(69.65,179.88) 70.08,179.46 71.16,179.46 ; CPU1.AM13 87.95,151.9 v4(87.55,151.5) ; v4(86.68,171.57) 86.68,171.58 CPU1.AL48 87.93,171.12 CPU1.AM46 ; CPU1.D45 73.68,170.47 CPU1.D44 73.41,169.84 73.22,170.02 v4(73.16,170.02) 72.97,169.84 CPU1.B44 ; CPU1.AV69 CPU1.AV70 CPU1.AV71 92.7,186.11 v4(92.7,186.23) ; CPU1.C5 73.59,147.56 CPU1.D6 ; CPU1.E11 74.87,150.55 75.25,150.55 CPU1.G10 76.17,149.63 v4(76.69,149.63) ; CPU1.J25 75.52,159.69 CPU1.F27 75.22,160.31 75.22,160.9 CPU1.F28 75.06,161.2 v4(75.38,161.52) 75.39,161.52 CPU1.J28 ; v4(92.14,143.72) 91.83,144.02 CPU1.AV1 ; v4(86.45,160.29) 86.87,160.29 CPU1.AK27 87.47,160.6 CPU1.AL28 87.93,160.15 CPU1.AM27 ; CPU1.L2 CPU1.L4 ; v4(73.78,185.98) 74.1,185.66 CPU1.E71 ; CPU1.BA57 92.83,177.24 v4(92.68,177.39) 92.53,177.24 CPU1.AW57 ; CPU1.E18 74.06,154.66 73.76,154.97 CPU1.D18 CPU1.B18 ; CPU1.B22 CPU1.D22 ; v4(88.92,165.18) 88.6,165.5 CPU1.AN37 ; v4(85.5,151.6) 85.5,151.6 85.7,151.6 CPU1.AH13 ; v4(88.92,149.63) 88.92,149.76 CPU1.AP10 ; v4(71.51,106.11) 72.44,106.11 72.55,106 GPU1.B24 ; CPU1.K61 76.24,179.75 v4(76.18,179.75) 76.18,179.78 CPU1.G63 ; 88.93,168.82 v4(88.93,168.83) ; CPU1.AE67 CPU1.AE68 ; v4(84.46,148.93) 84.25,148.71 CPU1.AD8 ; GPU1.B16 72.58,99.58 71.69,99.58 71.69,99.59 v4(71.58,99.59) ; CPU1.BA41 92.88,167.47 v4(92.76,167.59) ; CPU1.BA62 v4(92.64,179.72) ; CPU1.F68 CPU1.D69
  TOP w0.305: SCA1.85 55.14,64.4 v3(55.28,64.26) ; DIMM2.14 154.59,186.66 v4(153.14,186.66) ; v4(77.93,111.4) 77.8,111.26 GPU1.K32 ; LVDS1.14 41.2,96.5 v3(41.18,96.52) ; v3(88.04,65.66) 88.74,64.96 C6701.2 ; v3(88.04,65.66) 87.84,65.46 U6701.15 ; v3(88.04,65.66) 87.75,65.96 U6701.16 ; v3(88.04,65.66) 88.39,66 C6702.2 ; NGFF1.7 112.3,206.25 v3(112.3,206.25) ; PU5003.6 27.97,161.93 28.23,161.67 v3(28.48,161.67) ; R80033.2 67.41,140.02 68.11,140.72 v3(68.49,140.72) ; v4(83.84,178.82) 83.78,178.88 CPU1.AD62 83.78,180.31 CPU1.AE64 84.18,180.81 84.18,181.36 CPU1.AE65 ; NGFF1.63 112.27,220.25 v3(112.3,220.22) ; v3(112.3,212.72) 112.28,212.75 NGFF1.33 ; CPU1.AE66 84.23,182.13 84.18,182.18 84.18,182.6 84.23,182.65 CPU1.AE67 ; 31.52,23.25 PWRCN1.4 ; 31.52,23.25 v3(31.53,23.24) ; 31.52,23.25 31.52,23.59 31.08,24.03 31.08,24.49 31.79,25.2 C582.2 ; v3(116.62,211.96) 116.66,212 NGFF1.30 ; CPU1.AD16 84.48,154.11 CPU1.AF17 ; v4(137.92,138.04) 137.92,138.05 DIMM1.168 ; SCA1.61 56.62,74.47 v3(56.8,74.3) ; U6701.10 85.51,63.38 v3(85.5,63.37) ; GPU1.AA11 86.36,95.6 v4(85.97,95.99) ; v4(89.57,154.2) 89.57,154.3 89.25,154.63 CPU1.AP18 89.06,154.85 89.06,155.35 89.25,155.53 CPU1.AP20 89.2,155.52 88.65,155.52 CPU1.AN20 ; v4(133.51,173.48) 133.51,173.37 132.37,172.23 ; GPU1.AG12 90.85,96.4 v4(90.84,96.39) ; HDMI4.20 v3(113.7,9.32) ; XDP1.20 v3(24.33,222.76) ; NGFF1.24 116.68,210.5 v3(116.62,210.44) ; U9625.20 159.55,45.59 v3(159.8,45.34) 160.05,45.59 U9625.21 ; v3(55.41,77.98) 56.28,78.85 Q9632.1 ; v3(92.69,169.86) 93.14,169.86 93.21,169.94 93.24,169.94 CPU1.BA45 ; v4(52.81,95.62) 52.41,96.01 MEM2.P9 ; CPU1.D14 74.07,152.49 CPU1.E15 74.41,152.89 74.08,153.22 74.08,153.45 73.96,153.56 73.96,153.93 74.08,154.05 74.08,154.33 CPU1.E18 ; v3(116.62,209.04) 116.66,209 NGFF1.18 ; NGFF1.69 112.29,221.75 v3(112.3,221.74) ; CPU1.AT68 90.51,182.89 v4(90.19,182.57) ; v3(112.3,215.77) 112.28,215.75 NGFF1.45 ; GPU1.U9 84.02,93.58 v4(84.13,93.58) ; v4(82.86,181.74) 82.54,181.41 CPU1.AA65 ; U9625.17 158.05,45.49 v3(157.89,45.34) ; U6701.5 84.21,66.68 v3(84.06,66.52) ; MEM1.G1 51.77,112.88 51.76,112.9 v4(51.42,112.9) ; DIMM1.66 138.36,171.05 v4(137.83,171.58) ; CPU1.F22 74.73,157.08 v4(74.73,156.95) 74.73,156.82 CPU1.E21 74.12,156.78 74.12,157.01 CPU1.D22 ; v4(72.75,111.36) 73,111.11 GPU1.C32 ; v4(133.47,141.74) 133.47,141.83 132.98,142.33 132.64,142.33 ; MEM2.G8 53.11,90.52 52.51,90.52 MEM2.G9 52.3,90.42 v4(51.92,90.04) 52.33,89.62 MEM2.F9 ; XDP1.26 v3(25.83,222.76) ; v4(51.82,94.53) 51.93,94.42 MEM2.M9 ; CPU1.A5 71.45,146.72 v4(71.15,146.72) ; XDP1.13 22.83,213.43 22.44,213.03 v3(22.04,213.03) 21.52,213.03 21.33,213.22 XDP1.7 ; v4(87.69,93.58) 87.69,94.31 GPU1.AB10 GPU1.Y10 ; v4(82.99,107.18) 83.22,107.18 GPU1.U25 ; v3(115.57,17.78) 115.6,17.78 115.64,17.82 HDMI4.3 ; v4(75.24,96.32) 75.16,96.4 GPU1.F12 ; R9931.2 40.29,224.85 v3(40.29,225.43) ; v4(58.41,88.41) 58.01,88.81 MEM2.E2 ; v4(58.41,88.41) 58.81,88.02 MEM2.D1 ; v4(58.41,88.41) 58.81,88.81 MEM2.E1 ; CPU1.F40 75.52,167.01 CPU1.J38 ; C12202.2 136.6,31.2 135.92,31.88 v3(135.8,31.88) ; CPU1.AL35 88.14,164.26 CPU1.AN33 88.6,163.69 v4(88.91,163.37) ; v4(152.45,140.43) 152.45,140.22 152.83,139.85 DIMM2.162 ; v3(112.3,214.25) 112.3,214.25 NGFF1.39 ; v3(27.34,222.76) 27.33,222.75 XDP1.32 ; 74.04,174.43 74.38,174.78 CPU1.E53 ; GPU1.AH28 92.2,108.8 v3(91.98,108.58) 91.8,108.4 GPU1.AG27 ; v4(57.62,91.62) 58.01,92.02 MEM2.J2 ; DIMM1.46 134.92,177.05 v4(134.91,177.04) ; v3(19.74,222.76) 19.74,222.73 19.83,222.64 XDP1.2 ; XDP1.8 21.33,222.6 v3(21.5,222.76) ; MEM1.E2 MEM1.E1 52.34,114.48 52.25,114.39 51.53,114.39 v4(51.48,114.44) ; DIMM2.66 153.27,171.05 153.14,171.18 v4(153.14,171.34) ; DIMM2.38 151.57,179.45 150.96,180.06 v4(150.96,180.69) ; NGFF1.29 112.26,211.75 v3(112.3,211.71) ; v4(79.28,96.06) 79.28,96.28 GPU1.M12 ; NGFF1.75 112.19,223.25 v3(112.3,223.14) ; v3(31.66,222.88) 31.66,222.4 31.83,222.23 XDP1.50 ; HDMI3.20 v3(115.35,32.32) ; v4(134.7,143.96) 134.7,144.07 133.81,144.95 DIMM1.145 ; MEM1.D8 58.01,115.21 57.9,115.1 57.9,114.59 MEM1.E8 ; GPU1.T25 GPU1.P25 ; DIMM2.168 153.05,138.05 v4(153.05,138.05) ; v3(45.12,225.43) 45.12,224.73 C9903.2 ; v4(79.23,157.05) 79.13,157.05 CPU1.N21 ; GPU1.P6 81,91.47 81.34,91.13 v4(81.34,91.12) ; XDP1.37 28.83,213.51 29.2,213.15 v3(31.66,213.15) 31.66,213.16 31.83,213.33 XDP1.49 ; CPU1.AW18 91.68,155.09 CPU1.AU20 91.14,155.58 91.09,155.63 90.6,155.63 CPU1.AT20 ; XDP1.59 v3(34.33,217.18) ; MEM2.B9 52.04,86.05 52.04,86.03 v4(52.01,86) 52.39,85.62 MEM2.A9 ; v3(157.26,51.56) 157.34,51.49 U9625.8 ; U9625.24 161.55,45.49 v3(161.7,45.34) ; GPU1.N27 80.43,108.17 80.43,107.23 GPU1.N25 ; v3(114.38,41.66) 115.22,40.82 HDMI3.3 ; v3(57.72,52.7) 57.12,53.3 SCA1.107 ; GPU1.AD8 89,93.2 v4(88.6,93.6) 88.2,94 GPU1.AC9 ; X9503.4 62.89,159.14 v3(63.91,158.12) 63.91,158.43 C12355.2 ; v3(28.74,222.76) 28.83,222.66 XDP1.38 ; CPU1.AA4 81.8,147.33 CPU1.W6 82.33,147.94 82.33,148.18 CPU1.AB8 ; XDP1.14 v3(22.83,222.76) ; v4(75.4,168.84) 75.06,168.49 CPU1.F42 ; CPU1.AE69 84.1,184.01 v4(83.78,183.69) 84.1,183.36 CPU1.AE68 ; v3(116.62,213.49) 116.63,213.5 NGFF1.36 ; v5(119.29,10.19) 119.15,10.32 HDMI2.2 ; NGFF1.57 112.23,218.75 v3(112.3,218.82) ; MEM2.T1 58.79,97.62 58.41,97.24 v4(58.4,97.24) ; XDP1.19 24.33,212.93 v3(24.42,212.85) 24.93,213.36 25.56,213.36 25.83,213.63 XDP1.25 ; CPU1.D47 73.64,172.27 CPU1.D48 ; HDMI1.8 v3(115.35,36.32) ; v3(41.18,103.5) 41.19,103.5 LVDS1.7 ; MEM1.J8 v4(57.61,110.88) ; HDMI1.5 HDMI3.15 115.62,34.82 115.35,34.54 v3(115.35,33.15) 115.52,33.32 HDMI1.2 ; 92,95.88 92,95 GPU1.AH10 ; v3(112.3,210.19) 112.24,210.25 NGFF1.23 ; v4(83.4,151.64) 83.72,151.97 CPU1.AD13 ; GPU1.H17 76.2,100.58 76.52,100.26 v4(76.52,99.95) ; DIMM2.138 153.12,147.05 v4(153.07,147) ; GPU1.P9 81.55,94 v4(81.82,93.73) ; MEM2.G1 v4(58.41,90.02) ; SCA1.38 v3(68.99,75.09) ; XDP1.31 27.33,213.24 v3(27.72,212.85) ; CPU1.AB15 CPU1.AB16 ; v4(56.78,86.06) 57.15,86.42 MEM2.B3 ; U9625.10 156.52,50.14 v3(156.24,50.42) 156.47,50.65 U9625.9 ; HDMI2.5 118.52,11.82 119.16,11.18 v5(119.29,11.18) ; CPU1.E46 74.41,171.34 v4(74.18,171.58) ; v3(115.35,37.82) HDMI3.9 ; MEM2.E8 53.24,88.82 v4(53.63,88.42) 53.23,88.02 MEM2.D8 ; v4(59.52,95.79) 59.29,96.02 MEM2.P1 ; v4(74.15,184.12) 74.03,184 CPU1.D69
  TOP w0.33: v4(134.4,168.4) 134.15,168.66 134.15,168.67 133.26,169.55 DIMM1.71 ; v4(152.41,180.65) 152.41,180.84 152.83,181.25 DIMM2.32 ; DIMM2.31 147.98,181.55 148.53,181 v4(148.53,180.83) ; DIMM1.38 137.13,179.45 135.8,180.78 v4(135.8,180.97) ; DIMM2.11 148.99,187.55 149.77,186.78 v4(149.77,186.35) ; DIMM2.72 152.91,169.25 152.47,169.69 v4(152.47,169.85) ; DIMM2.71 148.29,169.55 v4(148.65,169.19) ; v4(135.92,189.36) 135.96,189.39 135.96,189.53 136.74,190.31 138.61,190.31 138.67,190.25 DIMM1.2 ; v4(153.05,129.72) 153.11,129.65 DIMM2.196 155.85,129.65 156.12,129.92 ; DIMM1.144 137.66,145.25 137.32,144.91 137.32,144.7 v4(137.3,144.68) ; v4(132.75,171.58) 132.52,171.35 DIMM1.65 ; v4(152.45,174.05) 152.45,174.21 152.89,174.65 DIMM2.54 ; DIMM1.150 136.36,143.45 136.05,143.76 136.05,144.65 v4(136.03,144.67) ; v4(137.27,134.28) 137.27,134.67 137.65,135.05 DIMM1.178 ; v4(152.49,178.23) 152.49,177.98 152.82,177.65 DIMM2.44 ; v4(137.93,148.26) 137.95,148.25 139.4,148.25 DIMM1.134 ; 156.12,131.45 DIMM2.190 153.32,131.45 v4(153.07,131.7) ; v4(137.26,140.41) 137.26,140.31 137.72,139.85 DIMM1.162 ; DIMM1.195 132.27,129.95 v4(132.88,130.56) ; v4(134.72,135.78) 134.72,135.66 133.81,134.75 DIMM1.179 ; DIMM2.25 148.98,183.35 149.87,182.46 v4(149.87,182.41) ; v4(136.64,138.02) 136.64,137.93 137.12,137.45 139.4,137.45 DIMM1.170 ; v4(134.83,147.55) 134.83,147.65 133.93,148.55 DIMM1.133 ; v4(152.41,148.84) 153,148.25 DIMM2.134 156.74,148.25 v3(156.78,148.21) ; DIMM2.61 148.02,172.55 148.5,173.03 v4(148.5,173.15) ; 156.04,147.65 DIMM2.136 152.26,147.65 v4(151.68,147.07) ; DIMM2.48 152.82,176.45 152.41,176.04 v4(152.41,175.85) ; DIMM2.26 152.92,183.05 152.46,183.51 v4(152.46,183.61) ; DIMM1.28 138.36,182.45 137.88,182.93 v4(137.88,183.17) 138.29,183.17 138.41,183.05 DIMM1.26 ; v4(137.28,136.28) 137.32,136.32 137.32,136.53 137.64,136.85 DIMM1.172 ; v4(151.02,148.83) 151.02,148.91 152.16,150.05 DIMM2.128 ; DIMM1.190 136.68,131.45 135.67,132.46 v4(135.67,132.97) ; 156.33,137.45 DIMM2.170 152.04,137.45 151.67,137.82 v4(151.67,138.06) ; DIMM1.32 138.33,181.25 138.05,181.52 137.6,181.52 137.19,181.11 v4(137.19,180.97) ; DIMM1.3 131.21,189.96 132.91,189.96 133.51,189.37 v4(133.51,189.36) ; v4(152.41,189.65) 152.41,189.87 152.79,190.25 DIMM2.2 ; DIMM1.127 132.62,150.35 133.35,149.61 v4(133.35,149.47) ; 156.27,133.25 DIMM2.184 152.13,133.25 v4(150.98,134.4) ; 147.85,132.35 v4(147.86,132.33) ; 147.85,132.35 147.23,132.96 146.41,132.96 DIMM2.185 ; 147.85,132.35 DIMM2.187 ; DIMM1.9 131.2,188.15 133.84,188.15 135.03,189.35 v4(135.03,189.36) ; v4(135.77,186.32) 135.77,186.66 137.56,188.45 DIMM1.8 ; v4(133.51,175.39) 133.51,175.4 132.94,175.97 132.19,175.97 132.01,176.15 DIMM1.49 ; v4(148.54,184.55) 148.54,184.84 148.23,185.15 DIMM2.19 ; DIMM1.19 132.48,185.15 132.72,184.92 v4(132.72,184.73) ; v4(134.57,186.36) 134.57,186.5 133.52,187.55 DIMM1.11 ; DIMM1.14 137.98,186.65 137.86,186.52 v4(137.86,186.35) ; DIMM1.189 132.91,131.75 134.04,132.87 v4(134.04,133) ; v4(137.21,152.36) 137.21,150.68 137.84,150.05 DIMM1.128 ; v4(149.96,176.72) 149.96,176.71 149.4,176.15 DIMM2.49 ; v4(150.56,141.75) 149.74,142.56 147.86,142.56 ; DIMM1.37 133.74,179.75 134.91,180.92 v4(134.91,180.97) ; DIMM2.43 149.13,177.95 149.73,178.55 149.73,179.01 v4(149.86,179.14) ; v4(150,145.75) 149,146.75 DIMM2.139 ; v4(149.8,173.17) 149.8,173.06 148.69,171.95 DIMM2.63 ; DIMM2.127 148.15,150.35 148.5,150 v4(148.5,149.35) ; DIMM2.144 156.08,145.25 ; 147.86,142.56 147.26,141.96 146.41,141.96 DIMM2.155 ; 147.86,142.56 146.41,142.56 DIMM2.153 ; DIMM2.9 149.45,188.15 150.76,189.46 v4(150.76,189.62) ; v4(134.91,178.69) 134.91,178.68 134.14,177.91 131.23,177.91 DIMM1.43 ; 156.04,136.85 DIMM2.172 152.94,136.85 v4(152.36,136.27) ; DIMM1.20 138.05,184.85 v4(137.93,184.73) ; DIMM1.185 132.66,132.95 ; 132.66,132.95 v4(132.72,133) ; 132.66,132.95 132.06,132.35 DIMM1.187 ; v4(137.83,132.97) 138.11,133.25 DIMM1.184 ; DIMM2.28 152.27,182.45 151.17,183.56 151.17,183.65 v4(151.14,183.69) ; v4(150.08,147.85) 150.08,147.9 149.56,148.42 147.43,148.42 147.31,148.55 DIMM2.133 ; DIMM2.173 147.68,136.55 v4(148.16,137.03) ; DIMM1.196 136.31,129.65 135.54,130.42 v4(135.54,130.56) ; DIMM2.145 148.02,144.95 148.6,145.53 v4(148.6,145.61) ; DIMM2.8 152.56,188.45 150.96,186.85 v4(150.96,186.68) ; DIMM1.151 132.65,143.15 133.37,143.87 v4(133.37,143.96) ; DIMM1.60 137.57,172.85 137.19,173.23 v4(137.19,173.48) ; v4(133.3,186.38) 133.3,186.5 132.85,186.95 DIMM1.13 ; v4(152.47,134.43) 152.47,134.57 152.96,135.05 DIMM2.178 156.17,135.05 ; v4(132.69,140.16) 132.68,140.15 DIMM1.161 ; 156.2,141.65 DIMM2.156 152.09,141.65 151.14,142.59 v4(151.14,142.68) ; v4(137.19,169.93) 137.19,169.79 137.73,169.25 DIMM1.72 ; DIMM1.25 134.06,183.35 134.68,182.73 v4(134.68,182.32) ; DIMM1.48 138.12,176.45 137.19,175.52 v4(137.19,175.39) ; DIMM1.61 132.05,172.55 132.37,172.23 132.11,171.98 132.11,171.95 DIMM1.63 ; v4(150.42,130.4) 150.42,130.29 149.8,129.67 147.79,129.67 147.51,129.95 DIMM2.195 ; DIMM2.138 156.01,147.05 ; v4(134.91,175.39) 134.7,175.18 134.7,175.17 134.16,174.63 132.5,174.63 132.22,174.35 DIMM1.55 ; DIMM2.55 148.35,174.35 148.63,174.64 v4(148.63,174.91) ; DIMM2.167 147.37,138.35 147.53,138.51 v4(147.98,138.51) ; DIMM1.139 131.94,146.75 132.1,146.59 134.05,146.59 135.02,145.62 v4(135.02,145.53) ; DIMM2.179 148.26,134.75 148.51,135 v4(148.51,135.3) ; DIMM1.44 136.71,177.65 136.56,177.8 v4(136.56,178.69) ; v4(149.11,130.43) 148.95,130.58 148.95,130.65 147.84,131.76 146.41,131.76 DIMM2.189 ; v4(150.46,143.93) 150.46,143.88 149.74,143.16 146.41,143.16 DIMM2.151 ; v4(137.93,142.04) 138.31,141.65 DIMM1.156 ; DIMM1.54 138.2,174.65 137.94,174.39 136.7,174.39 135.92,173.62 v4(135.92,173.48) ; DIMM1.167 132.06,138.35 132.06,138.35 133.87,138.35 v4(134.67,137.55) ; v4(148.54,179.15) 148.54,179.36 148.15,179.75 DIMM2.37 ; DIMM2.3 148.39,189.95 148.62,190.19 149.08,190.19 149.49,189.78 v4(149.49,189.64) ; DIMM2.65 147.25,171.35 147.36,171.46 149.37,171.46 150.02,170.81 v4(150.02,170.69) ; v4(153.05,184.86) 153.06,184.85 DIMM2.20 ; DIMM1.173 133.26,136.55 133.39,136.42 v4(133.39,135.81) ; v4(132.66,182.32) 132.66,182.27 131.95,181.55 DIMM1.31 ; DIMM2.60 152.1,172.85 v4(150.97,173.97) ; v4(148.5,186.35) 148.5,186.65 148.19,186.95 DIMM2.13 ; DIMM1.155 132.27,141.95 132.64,142.33 132.64,142.42 132.52,142.55 DIMM1.153 ; DIMM2.168 156.24,138.05 ; DIMM1.138 138.07,147.05 v4(137.88,147.24) 138.29,147.65 DIMM1.136 ; v4(149.08,141.51) 147.72,140.15 DIMM2.161 ; DIMM2.46 152.2,177.05 151.18,178.07 v4(151.18,178.21) ; DIMM2.162 156.27,139.85 ; 156.18,143.45 DIMM2.150 152.13,143.45 151.16,144.42 v4(151.16,144.65)
  TOP w0.356: v4(86.9,97.85) 86.65,97.6 GPU1.AA13 ; 92,95.88 91.48,96.4 GPU1.AG12 ; v4(78.27,95.15) 78.27,95.17 77.8,95.64 GPU1.K11 ; v4(59.39,112.82) 59.33,112.88 MEM1.G9 ; GPU1.V18 84.99,100.81 v4(84.99,100.79) 85.01,100.79 GPU1.Y17 ; v4(77.4,107.98) 77.4,107.99 77,108.39 GPU1.J27 ; MEM1.M1 51.89,108.88 v4(51.86,108.84) ; GPU1.AD32 v4(89,111.51) ; MEM1.P9 58.42,107.68 v4(58.4,107.68) ; v4(152.48,144.65) 152.48,144.85 152.88,145.25 DIMM2.144 ; GPU1.L27 78.59,108.4 v4(78.19,108.8) 78.12,108.87 78.12,108.88 GPU1.K28 ; v4(51.92,107.65) 52.03,107.65 52.4,107.28 MEM1.P1 ; v4(85.97,95.99) 85.9,96.06 84.86,96.06 GPU1.V11 ; MEM1.F9 58.38,114.11 MEM1.E8 ; v4(83.01,107.93) 83.4,108.32 GPU1.U27 ; GPU1.AB32 v4(87.4,111.36) ; GPU1.AB15 87.4,98.75 v4(86.87,99.28) 86.55,99.6 GPU1.AA16 ; v4(74.06,94.64) 74.08,94.64 74.24,94.8 GPU1.F10 GPU1.G10 ; GPU1.K22 77.79,104.2 v4(77.37,104.62) ; GPU1.F14 74.6,97.91 75.03,97.48 v4(75.08,97.48) ; v4(87.97,101.24) 88.2,101.01 GPU1.AC17 ; GPU1.AB24 87.5,105.7 v4(87.7,105.7) 87.9,105.7 GPU1.AC24 ; GPU1.V16 84.41,99.6 v4(84.94,99.06) 85.4,98.61 GPU1.Y15 ; v4(87.74,92.05) 87.72,92.04 87.72,91.92 GPU1.AB6 ; GPU1.M6 79.4,91.37 v4(79.67,91.11) ; v4(74.05,104.65) 74.3,104.4 GPU1.F22 ; GPU1.AE27 v4(90.2,108.8) ; PC12442.2 159.86,173.35 160.16,173.66 Q9653.4 158.22,174.19 v3(158.15,174.12) ; v4(74,106.02) 74.58,106.02 GPU1.F24 ; v4(80.81,112.27) 81,112.07 GPU1.P32 ; v4(52.46,98.42) 52.41,98.37 MEM2.T9 ; GPU1.AD25 v4(89.4,107.2) ; v4(51.9,117.08) 52,116.98 52.13,116.98 52.23,116.88 MEM1.B1 ; v4(74.04,99.57) 74.11,99.57 74.13,99.6 GPU1.F16 ; Q9650.1 14.88,157.34 v3(14.64,157.1) ; GPU1.N27 79.89,108.71 v4(79.89,108.89) ; GPU1.V32 v4(84.2,111.36) ; MEM2.B1 59.65,86.42 v4(59.81,86.58) ; v4(82.33,91.11) 82.33,91.33 GPU1.T6 ; v4(75.09,102.53) 75,102.53 74.73,102.8 GPU1.F20 ; GPU1.G8 75.27,93.07 74.73,93.07 GPU1.F8 74.6,93.2 74.37,93.2 v4(74.09,92.91) ; MEM1.J2 53.21,111.28 v4(52.81,111.69) ; GPU1.W25 84.39,106.8 v4(84.15,107.04) ; GPU1.AA27 v4(86.6,109) ; v4(53.61,92.42) 53.21,92.02 MEM2.J8 ; GPU1.G31 v4(75.4,111.03) ; v4(58.43,106.09) 58.43,106.06 MEM1.T9 ; MEM1.B9 59.51,116.88 v4(59.6,116.79) ; Q9650.4 16.18,161.05 v3(16.29,161.16) ; v4(84.16,107.7) 84.25,107.6 GPU1.W26 ; GPU1.F6 74.38,91.38 74.38,91.13 v4(74.37,91.12) ; GPU1.G27 75.4,108.39 v4(75,107.99) 74.92,107.91 74.91,107.91 GPU1.F26 ; v4(90.59,111.37) 90.6,111.36 GPU1.AF32 ; v4(75.16,101.15) 75.14,101.15 75.1,101.2 GPU1.F18 ; GPU1.H20 76.2,102.93 76.54,102.59 v4(76.54,102.54) ; GPU1.AE14 90.23,97.77 v4(90.23,97.77) ; v4(88.6,92.01) 88.6,92 GPU1.AD6 GPU1.AE7 ; GPU1.V13 84.21,97.6 83.76,97.14 83.05,97.14 v4(82.99,97.21) 82.99,97.21 GPU1.T13 ; GPU1.Y32 v4(85.8,111.36) ; MEM1.B3 54.7,117.56 v4(54.7,118.75) ; v4(58.76,118.32) 58.76,117.73 MEM1.A9 ; GPU1.K6 77.4,92 v4(77.39,92) 77.36,92.03 77.36,92.04 GPU1.J7 ; GPU1.R27 81.8,107.85 v4(81.84,107.8) ; v4(74.22,109.61) 73.82,109.2 GPU1.E28 ; GPU1.J31 v4(77,110.96) ; GPU1.T32 82.6,111.36 v4(81.69,112.27) ; GPU1.T25 82.78,107.18 v4(82.99,107.18) ; v4(85.33,107.9) 85,108.23 GPU1.W27 ; GPU1.Y20 85.72,102.72 v4(85.91,102.72) ; MEM1.D1 52.14,115.56 v4(51.36,115.56) ; v4(85.46,106.43) 85.83,106.8 GPU1.Y25 ; MEM1.M9 59.46,108.88 v4(59.48,108.87) ; v4(92.2,111.38) GPU1.AH32 ; GPU1.AC26 87.82,107.98 87.82,107.98 v4(87.8,108.01) 87.81,108.02 87.82,108.02 GPU1.AC27 ; GPU1.M32 79.4,111.36 v4(79.41,111.37) ; GPU1.H6 76.51,91.29 76.51,91.21 v4(76.54,91.18) ; v4(51.94,105.94) 52.14,105.94 52.4,105.68 MEM1.T1
  TOP w0.381: D5203.8 v3(106.59,23.11) ; v3(135.42,71.5) 135.42,70.74 135.16,70.48 135.16,69.15 R339.2 C201.2 ; R79801.2 72.23,71.69 71.92,71.37 v3(71.28,71.37) ; CPU1.L11 77.35,150.67 CPU1.J11 CPU1.J13 ; v3(47.85,139.57) 48.22,139.94 U706.5 ; CPU1.D6 73.71,147.56 CPU1.E6 ; R533.2 51.47,81.03 v3(51.34,80.9) ; v3(66.58,188.65) 65.76,189.47 U9626.3 ; v3(124.37,46.61) 124.37,47.43 C190.2 ; v4(87.54,132.84) 87.28,132.84 86.9,132.46 R1825.2 ; v3(74.43,139.7) 74.26,139.53 C12377.2 ; C2103.2 87.98,141.8 87.54,142.24 v4(87.28,142.24) ; D5204.8 v3(106.71,10.29) ; v4(76.69,149.63) 77.01,149.31 CPU1.J8 ; R80165.2 144.56,71.52 143.44,72.64 v3(143.04,72.64) ; v4(51.92,90.04) 49.53,90.04 C489.2 ; Q6.4 151.18,78.12 151.04,77.98 150.15,77.98 149.88,77.71 Q6.1 148.83,77.04 v3(148.75,76.96) ; D5204.3 v3(106.71,13.34) ; R1688.2 68.88,133.03 v3(69.45,133.6) ; Q9620.1 142.83,76.53 v5(142.78,76.48) ; Q6701.4 103.72,62.81 v3(103.92,62.61) ; PR8509.1 24.73,145.99 25.18,145.54 v3(25.18,145.41) ; D5203.3 v3(106.59,20.07) ; C12335.2 150.85,119.82 150.15,119.13 v3(150.15,118.75) ; v3(21.37,144.78) 21.7,144.45 Q9635.4 ; CPU1.G10 75.71,149.96 v4(75.38,149.63) ; R79172.2 76.23,52.01 75.92,51.69 v3(74.46,51.69) ; v3(146.59,78.36) 146.54,78.41 Q9620.4
  TOP w0.406: 17.61,180.96 Q9637.4 ; Q9503.4 84.01,49.81 v3(83.35,49.15) ; v3(31.36,9.31) 31.61,9.07 Q36.4 ; 37.29,138.03 U704.5 ; Q6701.1 100.6,65.55 PC12190.2 101.51,66.93 v3(101.89,66.93) ; v3(121.95,33.78) U28.8 U28.3 ; Q9654.1 76.94,228.46 v5(77.34,228.86) ; Q9632.4 54.47,80.44 54.82,80.79 v3(55.28,80.79) ; U3.8 U3.3 v3(169.58,115.19) ; v3(71.03,69.58) 71.71,68.9 R79797.2 ; v3(81.19,51.82) 81.55,51.82 81.68,51.69 81.69,51.69 82.2,51.18 82.2,51.17 Q9503.1 ; U501.3 83.91,219.98 84.49,219.4 v3(84.49,219.33) ; Q9639.4 17.61,175.51 v3(17.23,175.13) ; v3(121.95,41.02) 122.08,40.89 U29.8 U29.3 ; v3(121.95,37.34) 121.97,37.36 U6706.3 U6706.8 ; U5.8 U5.3 v3(169.58,96.14) ; CPU1.AL2 CPU1.AL4 ; Q36.1 v3(33.48,6.49)
  TOP w0.457: R79722.2 88.62,51.76 89.12,52.27 89.14,52.27 v3(89.31,52.45) ; 98.81,163.93 97.34,163.93
  TOP w0.508: 89.82,13.3 TC23.2 ; TC23.2 88.77,14.35 ; TC23.2 89.82,15.41 ; v3(75.98,74.04) R79802.2 ; v3(83.35,83.06) R963.2 ; C12369.2 114.46,60.07 v3(114.59,60.2) ; C14.1 R19.2 ; C14.1 37.56,116.74 Q5.S ; C14.1 37.56,114.87 ; PR4515.2 157.65,22.47 v3(157.89,22.23) ; PC4516.2 149.44,14.78 149.05,14.78 v3(148.5,14.22) ; v3(166.02,45.21) 165.97,45.26 C233.2 ; R8515.2 151.58,58.46 v3(151.8,58.67) 151.61,58.86 R379.2 ; C12386.1 82.9,30.86 v3(82.33,30.86) ; C185.2 124.51,49.72 124.44,49.66 v3(124.42,49.66) ; v3(34.58,53.85) 35.15,53.85 PR8524.2 ; v3(92.24,51.89) 92.55,51.57 C12384.2 ; v3(28.99,18.54) 28.98,18.55 PWRCN1.12 ; v4(84.74,138.07) 85.47,138.07 R1834.1 R1502.2 ; 183,158.17 MEMCD1.15 183,160 ; 171.1,131.4 MEMCD1.12 171.1,129.58 ; v3(40.8,20.7) 41.69,21.59 R132.2 41.88,22.61 C87.2 C33.2 ; v3(158.91,73.15) 158.59,72.83 C131.2 157.32,72.14 C127.2 ; v3(144.43,36.96) 144.56,36.83 R80255.2 ; PC12185.2 PC12187.2 104.81,69.6 104.68,69.72 v3(104.68,70.13) ; R722.2 128.05,12.32 v3(129.19,13.46) ; Q1.S 39.94,114.17 37.63,114.17 ; R1205.2 C839.2 86.33,79.06 v3(86.52,79.25) ; R605.2 73.82,189.74 v3(73.19,190.37) 73.12,190.31 R80042.2 71.57,190.31 70.8,189.55 R80163.2 ; R605.2 75.31,189.55 PC12418.2 ; R605.2 R604.2 ; v3(79.59,66.04) 79.56,66.04 79.56,66.04 78.58,66.04 R9508.2 ; CONVT1.12 25,31.93 v3(24.8,32.13) ; R1709.1 v3(105.19,218.44) ; v4(68.49,149.61) 68.49,148.91 C2116.2 ; R80003.2 v3(66.58,179.96) ; C749.2 57.01,140.59 C12352.2 56.75,139.36 C1174.2 56.8,139.31 56.8,138.68 C1182.2 56.42,137.92 55.66,137.16 v3(54.01,137.16) ; v3(161.58,88.52) 161.58,87.76 D21.A ; v3(103.16,57.91) 103.16,59.09 C4101.1 ; v3(118.52,69.09) PR5302.2 PC5308.2 ; v3(98.59,145.29) 98.84,145.54 C2112.2 ; v3(175.17,86.49) 175.1,86.42 Q57.3 ; DCIN1.6 49.88,25.74 ; DCIN1.6 50.97,24.18 ; DCIN1.6 48.79,24.18 ; DCIN1.6 49.88,22.62 ; R300.1 159.55,65.15 v3(158.78,65.15) C516.2 ; v3(91.47,130.62) C12358.2 90.46,130.49 PC5223.1 ; C259.2 162.85,34.42 v3(162.97,34.29) ; HDMI3.25 119.85,40.97 119.67,41.15 v3(119.03,41.15) ; C1850.2 R1899.2 98.2,91.95 v3(98.08,91.82) ; v3(81.57,79.5) 81.92,79.86 82.29,79.86 82.38,79.95 C762.2 ; v3(74.96,61.85) 75.85,62.74 U9501.4 ; DCIN1.4 57.72,24.18 ; DCIN1.4 55.54,24.18 ; DCIN1.4 56.63,22.62 ; HDMI3.23 120.31,33.17 v3(119.43,34.05) ; C12264.2 158.66,41.4 v3(158.4,41.66) 158.15,41.4 C252.2 ; v3(44.59,4.76) 45.25,5.41 C593.2 44.93,5.52 44.42,6.03 Q100.E ; v5(136.94,10.29) 137.32,10.67 PC4501.2 ; DCIN1.7 53.95,31 ; DCIN1.7 52.39,29.9 ; DCIN1.7 53.95,28.81 ; v3(160.69,28.45) 160.18,27.94 158.4,27.94 158.05,28.29 SPK1.5 ; v3(122.97,69.09) 123.07,69.19 123.07,69.36 123.1,69.39 PC5309.2 ; C12200.2 v3(138.39,39.62) ; v3(96.35,98.7) 97.04,98.7 C1848.2 98.39,98.42 R940.2 ; WEBCM1.8 155.15,198.2 v3(154.59,198.75) ; C2120.2 C2121.1 101.76,149.16 C2117.2 C2118.2 C2119.2 102.08,146.88 102.78,146.18 102.78,145.8 v3(102.9,145.67) ; v3(129.38,63.6) 128.74,64.25 C191.2 C12151.2 ; R303.2 121.88,47.82 122.72,46.98 v3(122.72,46.61) ; SPK1.7 v3(150,30.61) ; C9522.2 70.23,49.7 v3(70.62,50.09) 71.47,50.09 X9502.4 ; v3(123.45,53.09) 123.58,53.21 R321.2 ; v3(91.88,211.84) 91.3,211.25 PC5199.2 ; 57.53,190.25 PT4801.2 ; PT4801.2 58.58,191.3 ; PT4801.2 58.58,189.19 ; v3(119.46,37.06) 119.52,37.06 119.53,37.07 HDMI3.24 ; Q68.S 36.08,22.96 v3(34.53,24.5) ; C12251.1 v3(149.64,47.75) ; v3(29.75,31.88) 30.26,31.37 C238.2 ; 183,129.58 MEMCD1.14 183,131.4 ; MEMCD1.6 167.79,149.72 v4(168.56,150.5) ; v3(146.59,66.17) 147.04,66.61 R1660.2 ; R9563.2 86.58,55.31 85.66,56.24 v3(85.66,56.45) R79705.2 ; HDMI3.22 120.51,29.92 v3(120.58,29.84) ; v3(92.87,71.37) 92.87,71.1 93.11,70.87 PU8501.1 ; 140.88,27.3 142.81,29.24 Q1249.S ; Q46.3 85.06,40.83 v3(85.25,40.64) ; v3(161.58,124.84) 161.32,124.59 R1729.2 ; X9505.2 101.63,111.77 v3(100.74,112.65) ; PC5004.2 v3(22.26,162.81) ; 51.69,23.03 DCIN1.2 ; DCIN1.2 53.25,24.12 ; DCIN1.2 54.82,23.03 ; v3(109.63,102.23) 109.7,102.17 PC8409.2 ; C12190.2 74.33,74.93 74.2,74.8 v3(74.2,74.17) ; C2105.2 69.44,139.36 v3(69.74,139.66) ; v3(147.35,10.41) 146.97,10.79 PC4511.2 ; C12368.2 121.7,72.01 121.19,72.52 121.19,73.28 v3(121.06,73.41) ; PQ4204.E 90.95,34.15 v3(90.58,33.78) ; D5202.1 115.92,26.99 v3(116.62,26.29) 116.94,25.97 R80238.2 ; v3(47.79,4.7) 47.79,5.3 Q101.E ; v3(35.95,140.36) 36.07,140.24 Q9634.S 37.29,138.03 ; MEMCD1.3 168.07,142.22 168.26,142.04 v4(168.26,141.99) ; R215.1 v3(159.16,87.63) ; 171.1,158.17 MEMCD1.13 171.1,160 ; v3(115.1,99.57) 115.6,100.08 PR8401.2 ; Q24.3 179.04,86.42 v3(179.1,86.49) ; C254.2 157.56,35.31 v3(157.67,35.41) 157.77,35.31 C12334.2 ; v3(131.76,84.84) 131.5,84.58 131.35,84.58 PC12175.2 ; U12.2 79.92,28.83 v3(80.42,29.34) ; C12187.2 73.19,54.36 73.95,55.12 C12185.2 74.2,55.63 v3(74.2,56.39) 74.2,56.77 73.44,57.53 R9519.1 ; C1864.1 163.8,91.63 v3(164.12,91.95) ; PC5228.2 87.98,119.44 v3(87.66,119.76) ; R9554.2 73.69,74.68 v3(74.2,74.17) ; C253.2 v3(151.52,35.31) ; v4(98.71,108.08) 99.25,108.08 X9505.4 ; v3(166.15,42.04) 165.51,41.4 C257.2 ; Q76.S 165.9,90.87 v3(165.58,91.19) ; PC5229.2 84.55,126.56 PC5224.2 83.35,125.73 v3(82.57,124.95) ; v3(39.02,133.1) PC1199.2 PC1198.2 ; PC12441.2 v3(158.15,171.32) 158.21,171.39 Q9652.S ; C271.2 v3(103.79,28.83) ; WEBCM1.10 153.76,201.1 v3(154.85,202.18) ; 98.81,163.93 99.73,163.02 v4(99.73,162.6) ; R301.1 158.02,80.26 v3(158.15,80.14) ; PR3.2 137.07,106.05 v3(137.19,105.92) ; C129.2 155.1,74.07 v3(155.2,73.96) ; v3(32.7,14.58) 33.31,13.97 C1807.2 ; R606.1 100.51,131.53 X9504.2 ; v3(51.98,139.32) 52.04,139.38 C2101.2 C716.2 ; v3(18.09,206.5) 17.56,207.04 17.34,207.04 R73.1 ; 176.12,122.17 SSUSB1.11 ; SSUSB1.11 174.25,123.24 ; SSUSB1.11 177.99,123.24 ; SSUSB1.11 176.12,124.31 ; v3(96.43,106.55) 96.76,106.21 C752.2 ; v3(63.69,132.87) 63.9,132.65 R1685.2 ; v3(70.62,52.63) 69.9,52.63 C9520.2 ; R33.2 40.17,122.17 39.69,122.65 Q10.E 36.32,122.65 35.72,122.05 v3(35.72,120.65) R30.2 ; C12250.2 118.14,46.99 118.02,46.86 v3(118.02,46.61) ; C756.2 v4(96.63,108.37) ; C1855.1 v3(46.32,111.43) ; R327.2 121.95,59.94 v3(122.21,60.2) ; PR8527.1 164.5,174.62 v3(164.12,174.24) ; v3(164.12,50.42) 164.37,50.16 C232.2 ; v3(14.38,180.47) 14.77,180.47 15.24,180.94 Q9638.S 17.61,180.96 ; R80196.2 127.99,40.58 128.05,40.51 C12203.2 C12205.2 129.76,38.93 v3(129.57,38.73) ; PC5311.2 123.32,77.09 v3(124.32,77.09) ; v3(41.89,12.24) 41.89,11.39 C572.2 R1819.2 R412.1 ; v3(137.07,43.94) 136.69,44.32 R79945.2 ; v3(22.64,190.5) 22.91,190.5 23.36,190.06 PC4622.2 ; DCIN1.5 55.52,21.16 ; DCIN1.5 53.95,20.06 ; DCIN1.5 52.39,21.16 ; C170.2 152.61,79.24 152.61,80.66 152.66,80.71 Q31.E 152.66,81.88 152.66,81.89 152.66,82.83 v3(152.76,82.93) ; PC5209.2 55.72,141.41 v3(55.66,141.35) ; v3(33.26,10.14) 33.12,10.29 C1774.2 ; CONVT1.10 27.45,32.15 27.08,32.51 v3(26.58,32.51) ; OSC2.2 119.49,59 v3(120.68,60.2) ; v3(152.94,70.61) 152.34,70.61 Q9641.S ; C9905.2 30.98,224.62 v3(31.78,225.43) ; LED2.K 142.02,38.61 141.74,38.33 v3(141.54,38.33) ; SRCON1.4 55.02,130.68 v3(56.29,129.41) ; R1881.2 R1880.2 98.14,102.93 97.57,102.36 v3(97.57,102.11) ; C248.2 152.81,46.48 v3(153.83,45.47) 154.47,46.1 C247.2 ; v5(88.68,202.82) 89.7,203.84 PC5109.2 ; R1817.2 v3(29.5,4.76) ; R210.2 v3(156.88,82.93) ; HDMI2.21 113,22.27 R80197.2 ; PT4802.2 68.4,198.37 ; PT4802.2 66.29,198.37 ; PT4802.2 67.34,199.43 ; C12363.2 v3(90.33,22.73) ; R1700.1 109.57,60.26 v3(109.76,60.07) ; v3(34.07,44.7) 34.58,44.7 35.31,43.97 PQ4402.S ; C785.2 C789.2 71.11,84.62 C787.2 70.37,83.93 v3(69.63,83.19) ; v3(30.39,10.29) 30.32,10.35 C1773.2 ; C1853.2 C489.2 ; C12170.2 v3(80.98,56.77) ; R1850.2 69.15,25.55 67.06,25.55 v3(66.71,25.91) ; PR4649.1 v3(54.01,217.3) ; C126.1 v3(154.85,77.09) ; v3(87.66,41.27) 88.49,40.45 PQ4206.S ; R79824.1 152.24,51.75 v3(151.8,52.2) ; Q8.S 125.54,46.01 v3(126.14,46.61) ; HS6.1 147.86,214 ; HS6.1 140.64,214 ; HS6.1 144.25,210.39 ; R1894.2 88.9,81.72 88.4,82.22 88.4,82.25 v3(88.17,82.47) ; C12351.2 65.57,192.15 v3(65.06,191.64) ; PWRCN1.11 27.68,26.45 28.84,25.3 v3(28.84,25.15) ; R80084.2 C1847.2 97,96.33 96.45,96.88 v3(96.45,97.13) ; HDMI4.25 122.65,17.97 v3(122.72,18.03) 122.89,18.03 123.79,18.94 C12219.2 ; HDMI3.21 118.69,43.6 v3(118.14,43.05) ; R79926.2 57.95,52.48 v3(57.72,52.7) 56.87,51.85 C12184.1 ; PC4507.2 147.28,25.4 147.78,25.91 PC4506.2 v3(146.85,26.54) ; v3(75.98,49.28) 76.04,49.21 R79756.2 ; v3(100.87,193.35) R602.1 ; R80102.2 v3(91.35,22.73) ; PC4505.2 v3(148.37,18.64) ; C209.2 47.91,18.67 v3(48.93,17.65) 49.5,18.22 C3452.2 ; v3(74.2,74.17) 73.69,73.66 R79188.1 ; R5202.1 R5201.1 104.49,15.05 v3(104.3,15.24) ; v3(166.02,88.65) 166.02,87.71 R1193.1 ; C189.2 149.51,73.41 v3(148.75,72.64) 148.5,72.9 R293.2 ; v3(77.76,190.12) 78.2,189.67 R80018.2 ; PR4503.2 v3(157.77,25.91) ; C1753.1 v3(175.67,104.37) ; v3(79.79,113.25) 79.79,113.28 79.37,113.7 C760.2 ; C182.2 v3(149.64,59.31) ; Q9629.S v3(147.58,113.54) ; v3(127.03,30.86) 127.35,30.54 C12370.2 127.92,30.78 128.62,31.47 128.64,31.47 128.77,31.6 C12204.2 ; PR4410.1 39.59,45.53 v3(39.4,45.72) ; Q2.E 144.02,114.78 v3(142.78,113.54) ; C12206.2 C12207.2 136.57,41.59 v3(136.76,41.4) ; U5202.3 v3(111.03,26.29) ; v3(43.98,14.61) C1804.2 C1803.2 ; v3(72.55,29.34) 73.31,28.57 C1802.2 74.39,29.27 C1806.2 ; PT4701.2 53.79,187.83 ; PT4701.2 51.68,187.83 ; PT4701.2 52.74,188.89 ; v4(78.01,142.29) 77.95,142.23 C2104.2 ; R80257.1 137.41,30.61 C12202.2 ; D4.2 v3(169.48,105.92) ; PR4519.2 157.77,18.82 157.74,18.8 v3(157.74,18.54) 157.56,18.54 157.44,18.41 PC4503.2 ; C750.2 49.51,136.75 v3(49.79,136.75) ; v3(82.74,61.34) 82.74,61.32 82.77,61.28 R79668.2 ; v3(36.74,47.75) 37.05,47.75 PC4409.2 ; PC8402.2 v3(111.54,102.23) ; v3(95.66,118.75) 95.16,119.25 PR5242.2 93.95,121.86 93.38,122.43 PU5302.1 ; R1882.2 v3(89.44,84.2) 89.63,84.01 R1886.2 ; C6703.2 v3(81.82,66.67) ; PR5207.2 PR5202.2 v3(23.66,151.89) ; v3(158.39,71.36) 158.39,71.36 158.15,71.12 C132.1 ; v3(43.34,10.54) 43.09,10.29 C579.2 ; R79722.2 88.62,51.56 88.56,51.51 R79720.2 ; R1207.2 75.62,83.95 v3(75.6,83.93) C788.2 74.03,84.62 C792.2 C793.2 ; v3(20.23,225.93) 19.85,225.55 C9901.2 ; Q6705.S 49.4,121.63 C6718.2 v3(49.44,122.56) ; R732.2 128.68,15.75 v3(128.81,15.62) ; C12357.2 91.41,133.41 v3(91.47,133.48) ; C12183.1 61.95,52.01 62.64,52.7 v3(62.64,52.96) ; C12217.2 127.63,19.39 v3(127.41,19.18) ; PC5207.2 23.46,150.81 v3(23.66,151) ; v3(81.82,134.11) 81.82,133.83 80.96,132.97 C2106.2 ; D24.2 v3(106.46,34.8) ; R1688.2 R80181.2 ; v3(42.07,144.55) 42.1,144.53 C747.2 ; C121.1 156.31,67.58 v3(156.73,67.16) ; v3(166.15,50.67) 165.58,51.24 C12333.1 ; v3(33.94,61.09) 34.77,61.09 R79648.1 R79647.1 ; C258.2 v5(71.66,33.02) ; R80104.2 v3(95.54,7.75) ; R216.1 v3(181.29,82.04) ; R948.2 C1849.1 96.74,94.42 v3(96.17,93.85) ; U10.2 v3(45.19,11.94) ; v3(74.46,52.58) 73.33,52.58 X9502.2 ; R79931.2 v3(149.64,64.9) 149.39,64.64 R1663.2 ; R5203.1 R5205.1 108.94,15.05 v3(109.13,15.24) ; v4(108.92,153.67) 105.62,156.97 103.79,156.97 ; HDMI4.21 120.21,22.73 v3(121.32,22.73) 120.49,23.56 C12216.2 ; v3(156.62,65.53) 157.59,65.53 C509.2 ; v3(62.52,128.14) R79981.2 ; C12262.2 152.43,41.4 v3(152.18,41.66) ; v3(37.63,128.52) 38.43,128.52 C12261.2 ; v3(18.58,189.23) 17.42,188.07 Q9636.S ; PR4644.2 v3(35.47,186.31) ; SPK1.8 162.84,32.38 v3(163.23,32.77) ; R80232.2 14.7,157.04 v3(14.64,157.1) ; R1848.2 v5(71.66,34.29) ; v3(52.61,42.29) 52.61,42.58 PQ4406.S ; TOUCH1.2 v3(27.11,9.5) ; v3(125.38,54.86) 125.76,55.24 C180.2 ; v3(104.3,23.11) 104.3,24.26 104.87,24.83 R5204.1 R5206.1 R5208.1 R5207.1 ; C2107.2 81.81,137.73 v3(81.95,137.59) 82.9,138.54 C2108.2 ; C501.2 83.28,215.46 v3(83.73,215.01) ; PR8503.2 v3(88.04,77.72) ; v3(33.99,203.84) 33.99,201.73 PC4616.2 ; PC8408.2 v3(116.37,103.38) ; v3(158.15,199.64) 158.25,199.54 WEBCM1.6 ; R79996.2 v3(63.53,175.26) ; R79825.1 v3(154.08,55.63) ; R9511.2 v3(61.76,80.64) ; R1206.2 v3(86.52,84.96)
  L2GND w0.305: 157.01,96.27 v3(156.24,96.27) 155.48,96.27
  L3 w0.254: v4(85.33,107.9) 85.55,108.13 87.08,108.13 88.23,109.28 92.45,109.28 98.1,103.63 100.62,103.63 103.41,100.84 115.48,100.84 118.02,103.38 v3(119.9,103.38)
  L3 w0.508: 180.42,79.89 UHS1.MS2 179,78.87 ; DCIN1.2 53.25,24.12 ; DCIN1.2 54.82,23.03 ; DCIN1.2 51.69,23.03 ; SSUSB1.11 176.12,124.31 ; SSUSB1.11 176.12,122.17 ; SSUSB1.11 177.99,123.24 ; 174.25,88.94 SSUSB2.10 ; SSUSB2.10 177.99,88.94 ; SSUSB2.10 176.12,90.01 ; SSUSB2.10 176.12,87.87 ; SSUSB1.10 177.99,110.44 ; SSUSB1.10 176.12,111.51 ; SSUSB1.10 176.12,109.37 ; SSUSB1.10 174.25,110.44 ; DCIN1.4 57.72,24.18 ; DCIN1.4 55.54,24.18 ; DCIN1.4 56.63,22.62 ; DCIN1.6 49.88,25.74 ; DCIN1.6 49.88,22.62 ; DCIN1.6 48.79,24.18 ; DCIN1.6 50.97,24.18 ; 52.39,21.16 DCIN1.5 55.52,21.16 ; HS6.1 146.19,214 ; HS6.1 142.31,214 ; HS6.1 144.25,215.94 ; HS6.1 144.25,212.06 ; 181.68,130.49 MEMCD1.14 ; MEMCD1.14 183,129.58 ; MEMCD1.14 183,131.4 ; SSUSB2.11 177.99,101.74 ; SSUSB2.11 176.12,102.81 ; SSUSB2.11 174.25,101.74 ; SSUSB2.11 176.12,100.67
  L4 w0.508: 162.55,221.86 H6.8 ; H6.8 163.34,221.08 ; H6.8 164.12,221.86 ; 176.12,109.37 SSUSB1.10 ; SSUSB1.10 177.99,110.44 ; SSUSB1.10 174.25,110.44 ; SSUSB1.10 176.12,111.51 ; UHS1.MS2 179,80.91 ; UHS1.MS2 179,78.87 ; UHS1.MS2 180.42,79.89 ; 162.55,228.14 H6.5 ; H6.5 164.12,228.14 ; H6.5 163.34,228.92 ; 167.88,227.71 H6.3 168.67,226.92 ; 176.12,87.87 SSUSB2.10 ; SSUSB2.10 174.25,88.94 ; SSUSB2.10 177.99,88.94 ; SSUSB2.10 176.12,90.01 ; H6.4 166.66,228.92 ; H6.4 167.45,228.14 ; H6.4 165.88,228.14 ; 165.88,221.86 H6.1 ; H6.1 167.45,221.86 ; H6.1 166.66,221.08 ; 183,129.58 MEMCD1.14 ; MEMCD1.14 183,131.4 ; MEMCD1.14 181.68,130.49 ; 162.12,222.29 H6.7 161.33,223.08 ; 167.88,222.29 H6.2 168.67,223.08 ; 176.12,122.17 SSUSB1.11 177.99,123.24 ; SSUSB2.11 177.99,101.74 ; SSUSB2.11 174.25,101.74 ; SSUSB2.11 176.12,100.67 ; SSUSB2.11 176.12,102.81 ; HS6.1 146.19,214 ; HS6.1 144.25,212.06 ; HS6.1 142.31,214 ; HS6.1 144.25,215.94 ; 161.33,226.92 H6.6 162.12,227.71
  BOTTOM w0.127: MEM2.M1 59.13,94.11 59.58,94.11 60,94.53 60,95.32 59.54,95.79 59.53,95.79 v4(59.52,95.79)
  BOTTOM w0.203: MEM4.A9 59.95,85.62 60.18,85.85 60.61,85.85 v3(61.48,86.72) ; v3(86.39,208.91) 86.05,209.26 PU5104.1 ; PU5104.3 85.25,209.17 v3(85,208.91) ; PU5104.14 85.65,212.2 v3(85.76,212.09) ; MEM2.B9 52.81,86.03 53.62,86.03 MEM4.B3 ; U54.11 v3(149.89,8.51)
  BOTTOM w0.254: C12156.1 170.28,150.5 v4(168.56,150.5) 168.69,150.62 C12378.2 ; 90.58,165.61 90.15,165.18 v4(89.57,165.18) ; R80078.2 95.09,155.45 94.95,155.45 94.19,156.21 R80076.2
  BOTTOM w0.305: C776.2 62.07,98.45 61.67,98.85 60.79,98.85 59.56,97.62 MEM2.T1 58.79,97.62 58.41,97.24 v4(58.4,97.24) ; Q9627.1 166.13,42.05 v3(166.15,42.04) ; MEM3.G8 MEM1.G1 51.73,112.88 51.72,112.9 v4(51.42,112.9) ; MEM2.E2 58.01,88.81 v4(58.41,88.41) 58.02,88.02 MEM4.D8 ; v4(57.62,91.62) 58.01,92.02 MEM2.J2 ; v4(51.92,107.65) 52.29,107.28 MEM1.P1 ; v4(51.82,94.53) 51.93,94.42 MEM2.M9 ; MEM4.D1 52.3,88.02 v4(51.86,88.47) 52.01,88.47 52.36,88.82 MEM4.E1 ; MEM2.G1 v4(58.41,90.02) ; v4(58.41,90.02) 58.01,90.41 MEM4.G8 ; v4(58.41,90.02) 58.81,89.62 MEM4.F9 ; MEM2.G9 52.36,90.42 51.97,90.04 v4(51.92,90.04) ; PQ5008.1 26.34,64.88 26.07,65.15 24.54,65.15 ; v3(158.4,41.66) 158.4,42.04 157.88,42.56 Q9622.4 ; MEM2.B9 52.01,86.02 v4(52.01,86) ; MEM2.P9 52.41,96.01 v4(52.81,95.62) ; v3(37.5,29.72) 37.5,29.08 37.23,28.81 U120.20 ; MEM2.E8 53.24,88.82 v4(53.63,88.42) ; MEM3.E1 58.71,114.38 58.12,114.38 MEM1.E8 ; Q9633.4 54.79,78.6 v3(55.41,77.98) ; Q1217.4 124.35,16.91 v3(124.37,16.89) ; MEM2.P1 59.29,96.02 v4(59.52,95.79) ; PU4404.14 39.59,45.71 39.58,45.72 v3(39.4,45.72) ; v4(51.86,108.84) 51.89,108.88 MEM1.M1 ; MEM1.G9 59.33,112.88 v4(59.39,112.82) ; v4(56.67,117.73) 56.67,117.46 57.21,116.91 MEM3.B3 ; MEM3.D8 53.21,115.23 53.1,115.11 53.1,114.59 MEM1.E2 MEM3.F9 52.3,113.79 52.3,113.85 51.98,114.17 51.74,114.17 v4(51.48,114.44) ; U9628.14 162.59,101.6 v3(162.59,101.6) ; C745.2 90.9,165.93 90.58,165.61 ; MEM1.T1 52.2,105.68 v4(51.94,105.94)
  BOTTOM w0.356: MEM1.P9 58.42,107.68 v4(58.4,107.68) ; MEM1.J2 53.21,111.28 v4(52.81,111.69) ; v4(59.81,86.58) 59.7,86.47 58.87,86.47 MEM2.B1 ; MEM2.T9 52.41,98.37 v4(52.46,98.42) ; MEM3.A9 52.04,117.68 51.94,117.78 v4(51.86,117.78) ; C777.2 60.13,103.67 60.13,104.45 58.95,105.63 58.94,105.63 58.88,105.68 MEM1.T9 58.43,106.06 v4(58.43,106.09) ; MEM1.B1 52.4,116.88 52.3,116.98 52,116.98 v4(51.9,117.08) ; v4(59.6,116.79) 59.51,116.88 MEM1.B9 ; v4(59.48,108.87) 59.46,108.88 MEM1.M9 ; MEM3.D1 59.05,115.05 59.15,115.05 v4(59.5,114.69) 59.3,114.48 MEM3.E1 ; MEM1.J8 v4(57.61,110.88) ; v4(53.61,92.42) 53.21,92.02 MEM2.J8
  BOTTOM w0.381: C2111.2 85.38,157.23 v4(85.2,157.4) ; PC5115.2 84.36,216.85 PC5103.2 ; v4(150.42,130.4) 150.42,130.08 149.64,129.31 149.64,129.29 R1301.1 ; v3(137.7,60.33) 137.89,60.33 C197.2 ; v4(152.41,180.65) 152.56,180.8 152.56,180.88 152.9,181.22 153.46,181.22 153.51,181.17 C1301.2 ; PR4648.1 33.5,210.6 v3(33.42,210.68) ; C2102.2 83.28,158.05 83.75,157.58 v4(83.75,157.51) ; Q9631.4 26.02,20.9 v3(26.2,21.08) ; Q1217.4 122.35,16.91 122.19,16.75 122.19,15.86 121.94,15.61 Q1217.1 ; C717.2 73.76,157.93 v4(74.73,156.95)
  BOTTOM w0.406: v3(57.31,43.31) 57.36,43.26 PQ4404.4 56.76,42.56 56.45,42.26 56.45,41.69 56.02,41.26 PQ4404.1 ; Q9631.1 24.15,23.61 v3(24.42,23.88) ; v3(55.28,80.79) 55.28,80.72 55.41,80.59 55.41,80.26 55.77,79.9 Q9633.1 ; v3(128.81,15.62) 128.56,15.62 128.06,15.13 Q65.4 ; v3(71.03,69.58) 71.6,69.01 PQ5007.1 ; PQ5007.4 73.67,67.13 73.95,67.41 74.45,67.41 74.85,67.01 v3(74.85,66.41) ; v3(125.76,16.38) 125.94,16.56 Q65.1
  BOTTOM w0.508: C12189.2 73.57,55.75 v3(74.2,56.39) ; 176.12,87.87 SSUSB2.10 ; SSUSB2.10 177.99,88.94 ; SSUSB2.10 174.25,88.94 ; SSUSB2.10 176.12,90.01 ; D5207.1 v3(26.83,25.15) ; PT4701.2 52.74,188.89 ; PT4701.2 53.79,187.83 ; PT4701.2 51.68,187.83 ; v3(129.19,13.46) C865.1 129.13,11.49 C1831.2 ; R1853.2 49.69,34.04 ; USB4.5 98.38,22.31 ; USB4.5 100.1,20.6 ; USB4.5 98.38,18.88 ; USB4.5 96.67,20.6 ; C12365.2 156.69,102.68 v3(156.37,103) ; R80015.2 72.83,164.47 v4(73.17,164.81) ; USB3.5 100.07,43.6 ; USB3.5 98.35,41.88 ; USB3.5 96.64,43.6 ; C767.2 73.88,99.42 v4(74.04,99.57) 74.29,99.82 C773.2 ; v4(66.07,165.35) 62.62,165.35 H2.1 ; 11.75,137.31 HDD1.1 ; HDD1.1 10.87,138.19 ; HDD1.1 12.63,138.19 ; v3(142.78,63.12) 142.84,63.18 R80218.2 142.78,64.07 C12249.2 ; v3(162.34,99.31) 162.28,99.25 R80107.2 ; 53.95,20.06 DCIN1.5 ; DCIN1.5 55.52,21.16 ; DCIN1.5 52.39,21.16 ; v3(83.73,215.01) 83.41,215.33 PC5115.2 ; DCIN1.4 57.72,24.18 ; DCIN1.4 55.54,24.18 ; DCIN1.4 56.63,22.62 ; R523.2 v3(51.34,80.9) ; SSUSB1.11 177.99,123.24 ; SSUSB1.11 176.12,122.17 ; SSUSB1.11 176.12,124.31 ; C12152.2 C12126.2 130.21,57.4 v3(130.46,57.66) ; v4(85.6,180.42) 85.69,180.33 R80128.1 85.78,179.77 R80013.2 ; U11.2 v3(50.07,11.94) ; C12251.1 v3(149.64,47.75) ; C12245.2 55.33,62.66 v3(55.28,62.61) ; C12196.2 56.1,70.29 v3(56.04,70.23) ; PC5202.2 24.73,151.89 v3(23.66,151.89) ; v4(148.75,128.14) 148.75,128.01 148.06,127.32 C1311.2 ; C9516.2 v3(60.26,69.22) ; v3(57.82,39.24) 57.85,39.21 D19.1 ; v4(92,100.18) 91.88,100.31 C784.2 ; v3(84.11,170.81) 84.23,170.69 R80129.1 ; C261.2 162.85,34.42 v3(162.97,34.29) ; v4(85.34,144.4) 85.31,144.38 85.1,144.38 84.93,144.21 R1603.2 83.79,144.4 82.77,144.4 R1901.2 ; R9505.2 60.04,56.07 v3(59.98,56.13) ; 96.64,30.46 USB3.6 ; USB3.6 100.07,30.46 ; USB3.6 98.35,32.17 ; USB3.6 98.35,28.74 ; R1501.2 v4(70.7,151.64) ; 7.08,183.37 ODD1.9 ; ODD1.9 8.4,184.69 ; ODD1.9 8.4,182.05 ; PC5205.2 32.27,149.24 32.27,150.6 32.48,150.81 ; C12195.2 C12194.2 C9518.2 54.96,76.26 C12244.2 54.19,76.33 v3(53.93,76.58) 53.8,76.45 R80170.1 ; C592.2 27.39,4.7 v3(28.42,4.7) ; 65.22,104.01 65.22,103.09 C778.2 ; 65.22,104.01 65.22,105.24 64.3,106.15 v4(63.48,106.15) ; 65.22,104.01 65.15,104.08 C559.2 R924.1 ; U9602.4 137.07,53.85 136.81,54.1 v3(136.18,54.1) ; 67.34,197.32 PT4802.2 ; PT4802.2 66.29,198.37 ; PT4802.2 67.34,199.43 ; v3(142.04,35.18) 142.15,35.08 142.15,35 143.24,33.91 R1592.2 ; C1217.2 138.59,181.23 138.21,181.61 137.56,181.61 137.19,181.24 v4(137.19,180.97) ; C768.2 80.36,103.38 C798.2 81.08,103.19 81.08,103.07 81.1,103.05 v4(81.1,102.65) ; C768.2 79.6,103.52 C812.2 ; C768.2 C766.2 ; C194.2 130.46,63.69 v3(130.46,62.74) ; C12174.2 68.44,55.04 v3(67.47,56.01) 68.49,57.02 C12186.2 ; SSUSB1.10 176.12,111.51 ; SSUSB1.10 177.99,110.44 ; SSUSB1.10 176.12,109.37 ; 144.25,210.39 HS6.1 ; HS6.1 147.86,214 ; HS6.1 140.64,214 ; HS6.1 144.25,217.61 ; v4(172.6,136.6) 172.6,136.6 172.37,136.83 C311.2 172.37,137.9 173.39,138.91 C312.1 ; 8.4,169.31 ODD1.8 ; ODD1.8 8.4,171.95 ; ODD1.8 7.08,170.63 ; USB4.6 100.1,7.46 ; USB4.6 96.67,7.46 ; USB4.6 98.38,5.74 ; USB4.6 98.38,9.17 ; C819.2 C818.2 85.4,95.99 v4(85.97,95.99) ; v4(177.43,139.12) 177.39,139.16 C12160.1 ; v5(37.63,74.55) 37.43,74.36 PR4417.2 ; R1889.2 C761.2 74.2,114.3 v3(73.44,115.06) ; Q22.E 43.66,26.73 v3(43.34,26.42) ; C806.2 79.15,98.24 C807.2 79.34,98.04 C774.2 79.34,96.13 v4(79.28,96.06) ; 111.46,11.21 HDMI2.20 ; HDMI2.20 110.34,14.03 ; HDMI2.20 112.58,14.03 ; HDMI2.20 111.46,16.85 ; C12382.2 v3(46.39,174.82) ; C744.2 93.15,167.2 v4(92.76,167.59) 92.41,167.94 92.41,168.26 C715.2 93.29,168.26 C719.2 ; C9904.2 25.43,225.17 24.93,225.68 v3(24.93,225.81) ; v3(78.9,201.17) 79.72,200.35 C12383.2 ; PQ4403.S 52.58,42.26 v3(52.61,42.29) ; R144.2 46.39,24.64 v3(46.52,24.77) ; PC4416.1 37.5,47.37 37.12,47.75 v3(36.74,47.75) PR5298.2 ; v3(91.47,81.79) 91.47,82.11 91.79,82.42 C755.1 ; PL4303.2 PC4301.2 32.99,64.83 33.69,64.14 ; v3(78.39,210.19) 79.03,210.19 C1797.2 ; 33.69,64.14 33.37,63.82 PC4304.2 PL4301.2 ; 33.69,64.14 v3(33.94,64.14) ; v4(96.31,158.03) 96.27,157.99 PC702.2 ; v4(168.31,137.16) 168.94,137.79 C12158.1 170.28,137.4 169.63,136.75 C12157.2 ; PT4801.2 58.58,191.3 ; PT4801.2 58.58,189.19 ; PT4801.2 57.53,190.25 ; v3(91.95,97.47) 92.01,97.53 C1846.2 R1210.1 ; R9604.2 65.95,65.79 v3(66.07,65.66) 65.95,65.53 C12171.2 66.45,64.14 C12188.2 ; v3(57.72,52.7) 58.61,51.82 Q9619.S ; R1823.2 81.5,138.04 v3(81.95,137.59) ; v3(101.89,66.93) 101.44,66.48 C6724.1 100.46,65.94 Q9648.S ; 101.09,9.5 USB4.4 ; USB4.4 102.12,10.53 ; USB4.4 100.06,10.53 ; USB4.4 101.09,11.56 ; 48.79,24.18 DCIN1.6 ; DCIN1.6 50.97,24.18 ; DCIN1.6 49.88,22.62 ; DCIN1.6 49.88,25.74 ; C12199.2 119.41,34.04 v3(119.43,34.05) ; v3(34.53,24.5) 33.56,23.53 R37.1 ; v4(177.45,143.51) 178.38,143.51 R79840.2 ; R1781.2 119.79,18.24 v3(119.36,18.67) ; v4(73.16,170.02) 73.16,169.45 C1040.2 C1049.2 ; 111.3,6.78 HDMI2.22 ; HDMI2.22 113.99,7.9 ; HDMI2.22 113.99,5.66 ; SSUSB2.11 176.12,102.81 ; SSUSB2.11 177.99,101.74 ; SSUSB2.11 176.12,100.67 ; R80051.2 106.78,126.85 C12350.2 107.6,127.67 v3(107.6,128.02) ; C255.2 152.43,36.22 v3(151.52,35.31) ; UHS1.MS2 180,79.89 180.63,80.52 ; v4(70.9,183.26) 70.76,183.12 70.76,181.63 72.04,180.34 R80008.2 ; R1214.2 C1206.2 C1204.2 R1213.2 v3(132.37,194.62) 132.69,194.62 133.26,194.06 C1205.2 ; v3(169.58,154.18) 169.39,154.37 C12379.2 ; PR4645.1 32.86,192.11 v3(32.82,192.07) ; R1201.1 132.49,130.18 v4(132.88,130.56) ; v3(35.72,98.93) 35.78,99 Q9651.S ; v3(33.48,6.49) 34.43,6.49 35.43,7.48 R406.2 ; C1305.2 147.29,194.06 C1310.2 C1302.2 145.96,194.37 v3(145.82,194.51) 145.7,194.63 R1306.2 R1307.2 ; C1153.2 88.13,168.97 v4(88.27,168.83) ; v3(89.49,102.46) 89.55,102.4 C759.2 C758.2 91.16,102.36 C780.2 ; C3366.2 141.51,38.38 141.54,38.35 v3(141.54,38.33) ; 10.68,148.37 HDD1.9 ; HDD1.9 12,149.69 ; HDD1.9 12,147.05 ; R9609.2 C12172.2 56.48,67.06 v3(55.79,67.06) ; PR4506.2 154.08,20.83 v3(154.47,20.45) 155.02,21.01 PC4513.2 ; C12218.2 124.62,19.53 123.12,18.03 v3(122.72,18.03) ; C705.2 92.49,172.33 v4(92.66,172.51) 92.81,172.65 C743.2 ; PL4302.2 PC4305.2 32.99,67.63 33.87,66.75 v3(33.87,66.67) ; v4(77.39,92) 77.25,91.86 C769.2 ; v3(18.89,202.76) PR4612.1 PC4637.1 PR4626.1 PR4622.2 ; v3(25.69,193.04) PR4621.2 25.74,193.92 PC4611.1 27.01,193.92 27.59,194.5 PC4625.2 PR4629.2 PC4618.2 29.62,193.78 28.96,193.12 28.96,192.04 PR4631.2 29.03,191.71 29.42,191.31 30.64,191.31 31.33,192 31.33,194.55 PC4636.2 ; v4(81.16,158.55) 81.92,159.31 R80019.2 ; v3(82.08,208.91) 81.63,208.47 PR5110.2 ; C595.2 38.76,7.79 v3(39.25,8.28) ; C12265.2 158.58,36.32 v3(157.67,35.41) 156.75,36.32 C256.2 ; v3(115.35,37.82) 116.11,38.58 C419.2 ; HDD1.7 11.75,146.69 ; HDD1.7 12.63,145.81 ; HDD1.7 10.87,145.81 ; C35.2 v5(35.09,40.77) ; C1760.2 v3(31.53,23.24) ; C770.2 74.67,102.11 v4(75.09,102.53) ; R601.2 76.36,178.9 76.36,179.15 76.18,179.32 v4(76.18,179.75) 76.87,180.43 R80009.2 ; 101.06,32.5 USB3.4 ; USB3.4 100.03,33.53 ; USB3.4 101.06,34.56 ; USB3.4 102.09,33.53 ; v3(52.51,45.82) 52.5,45.82 PQ4405.S ; v3(170.87,145.82) 170.77,145.92 C12381.2 C12380.2 ; v3(20.23,225.93) 20.8,225.36 C9902.2 ; v3(48.47,7.72) 48.25,7.94 Q102.E ; v4(78.27,95.15) 78.33,95.09 C775.2 ; C585.2 v3(28.84,25.15) ; C591.2 44.59,5.24 v3(44.59,4.76) ; v4(85.91,102.72) 85.91,102.64 86.61,101.95 C821.2 87.29,101.71 C779.2 C781.2 ; 178,69.67 UHS1.MS1 ; UHS1.MS1 179.42,70.69 ; UHS1.MS1 176.58,70.69 ; v3(64.36,74.3) 64.36,75.31 C9504.2 C12191.2 ; C710.2 93.06,162.94 v4(92.67,162.55) ; 10.68,135.63 HDD1.8 ; HDD1.8 12,134.31 ; HDD1.8 12,136.95 ; PC4512.2 155.02,24.46 v3(154.59,24.89) 154.08,24.38 PR4535.2 ; C1309.2 v3(156.78,148.21) ; C12376.2 168.32,141.92 v4(168.26,141.99) ; v4(168.18,142.88) C12159.1 ; 113.99,20.16 HDMI2.21 ; HDMI2.21 111.3,21.28 ; HDMI2.21 113.99,22.4 ; C1796.2 78.52,214 v3(78.39,213.87) ; C1617.2 146.02,205.68 C1615.2 145.58,206.12 v5(144.69,206.12) C1616.2 ; Q3.S 154.78,207.2 v5(154.72,207.14) 154.47,206.88 C864.2 ; v4(89.57,157.86) 90.39,158.69 C718.2 ; Q1212.S v3(23.15,11.87) ; C1039.2 70.65,166.81 v4(70.65,167.51) ; v3(158.15,199.64) 158.08,199.58 PC126.1 ; 181.68,130.49 MEMCD1.14 ; MEMCD1.14 183,129.58 ; MEMCD1.14 183,131.4 ; v4(69.65,179.88) 69.63,179.86 69.63,179.77 R80004.2 ; v4(137.93,148.26) 138.18,148.02 C1201.2 C1202.2 R1219.2 C1218.2 ; v3(133.23,103.53) 133.31,103.53 133.66,103.17 133.66,102.26 133.26,101.85 PR2.2 ; PC1129.2 75.55,175.31 v4(75.47,175.23) ; 51.69,23.03 DCIN1.2 ; DCIN1.2 53.25,24.12 ; DCIN1.2 54.82,23.03 ; C12353.2 C12354.2 R80056.2 108.49,153.16 108.92,153.59 v4(108.92,153.67) ; v3(162.59,101.6) 163.04,101.16 R80114.2 ; v3(26.58,29.97) 26.58,29.34 26.93,28.99 Q1214.E ; v4(79.67,91.11) 79.73,91.05 C791.2 C790.2 C786.2 79.85,88.14 R1897.2 ; v3(35.95,140.36) 37.16,140.36 PC12439.2 ; C1306.2 v3(156.78,146.43) ; Q48.E 89.76,84.52 v3(89.44,84.2) ; PR8522.1 v5(24.67,70.48) ; v3(120.94,12.41) 121.02,12.32 C1764.1 121.83,12.38 R1779.2 ; v4(75.38,157.86) 76.01,158.49 R80021.2 ; C88.2 40.8,21.91 v3(40.8,20.7) ; 52.39,29.9 DCIN1.7 53.95,28.81 ; PR5219.2 23.19,145.58 v3(23.78,146.18) ; U5203.3 116.23,16.23 v3(115.57,16.89) ; PR4599.2 v3(148.37,18.64) ; C20.2 v3(35.71,107.7) ; C1308.2 v3(156.78,147.32) ; v3(55.28,64.26) 54.96,63.94 C12197.2 ; v3(135.8,31.88) 135.86,31.81 C12201.2 ; 96.55,152.91 R80007.2 R80077.2 R80078.2 95.92,155.26 R80006.2 97.99,155.26 98.31,154.94 98.31,154.24 97.74,153.67 v4(97.06,153.67) 97.06,153.42 96.55,152.91 ; v4(75.38,161.52) 76.07,161.52 C1187.2 C1051.2 75.34,162.5 C1041.2 75.15,161.75 v4(75.38,161.52)
  vias: v2(4.45,182.45) v2(5.52,202.72) v2(7.45,137.62) v2(7.98,166.98) v2(8.44,148.77) v2(10.88,224.41) v2(23.22,182.22) v2(23.58,36.7) v2(28.46,3.48) v2(32.27,161.77) v2(37.73,206.55) v2(38.9,16.13) v2(44.08,219.99) v2(46.13,89.2) v2(46.52,113.72) v2(47.02,33.15) v2(49.66,29.67) v2(51.01,190.93) v2(51.67,2.92) v2(53.22,162.13) v2(58.71,217.04) v2(62.39,182.37) v2(85.25,193.78) v2(86.37,225.27) v2(86.82,185.7) v2(92.62,20.47) v2(93.91,42.8) v2(103.39,178.56) v2(109.15,4.57) v2(111.82,226.69) v2(114.36,211.18) v2(130.74,35.23) v2(131.88,165.66) v2(136.3,6.1) v2(137.29,24.69) v2(137.4,90.58) v2(137.78,226.67) v2(139.05,153.82) v2(142.04,124.71) v2(151.47,165.86) v2(152.18,216.71) v2(152.84,151.76) v2(158.53,46.86) v2(164.04,78.13) v2(165.74,27.18) v2(179,126.87) v2(179.89,87) v3(8.42,216.66) v3(9.18,216.66) v3(14.13,204.34) v3(14.13,203.45) v3(14.13,202.56) v3(18.32,196.22) v3(18.32,195.45) v3(21.14,1.07) v3(23.66,149.99) v3(23.66,149.1) v3(23.66,148.21) v3(24.42,201.55) v3(25.18,201.55) v3(25.94,203.07) v3(25.94,202.31) v3(25.94,201.55) v3(25.94,200.79) v3(25.94,200.03) v3(26.7,201.55) v3(26.7,163.45) v3(26.7,162.18) v3(26.7,160.91) v3(26.83,56.26) v3(26.86,1.07) v3(27.47,201.55) v3(28.35,54.74) v3(29.62,54.74) v3(31.66,6.48) v3(31.94,1.07) v3(34.32,228.85) v3(34.58,58.67) v3(34.58,56.26) v3(34.83,9.02) v3(35.09,78.23) v3(35.09,77.47) v3(35.67,114.81) v3(35.71,113.92) v3(37.02,1.07) v3(37.07,14.86) v3(37.88,15.67) v3(37.88,14.86) v3(37.88,14.05) v3(38.26,4.83) v3(38.69,14.86) v3(39.02,4.83) v3(41.18,110.62) v3(41.18,109.86) v3(41.18,109.09) v3(41.69,45.85) v3(41.69,44.58) v3(42.07,136.61) v3(42.1,1.07) v3(42.32,45.21) v3(42.58,220.85) v3(42.96,45.85) v3(42.96,44.58) v3(43.47,220.85) v3(44.23,220.85) v3(44.23,136.61) v3(44.23,17.4) v3(44.86,112.65) v3(44.86,110.36) v3(45.96,85.09) v3(46.39,160.53) v3(46.95,161.14) v3(47.02,98.68) v3(47.02,97.92) v3(47.12,116.34) v3(47.12,115.57) v3(47.18,1.07) v3(47.31,106.8) v3(47.3,105.63) v3(47.3,104.62) v3(47.3,103.52) v3(47.27,102.46) v3(47.53,161.67) v3(48.04,162.31) v3(48.8,162.31) v3(49.56,162.31) v3(52.26,1.07) v3(52.87,155.96) v3(52.87,153.67) v3(52.87,151.38) v3(57.34,1.07) v3(57.92,57.99) v3(58.07,59.05) v3(61.63,149.1) v3(61.63,146.81) v3(61.63,144.53) v3(61.63,142.24) v3(62.42,1.07) v3(63.18,154.18) v3(63.28,20.7) v3(63.28,19.94) v3(63.91,149.1) v3(66.07,23.11) v3(66.73,58.93) v3(66.84,23.11) v3(66.96,20.7) v3(66.96,19.94) v3(67.47,72.01) v3(67.47,70.36) v3(67.5,1.07) v3(71.28,58.42) v3(71.28,57.66) v3(71.28,56.24) v3(72.58,1.07) v3(74.91,65.53) v3(74.89,21.93) v3(74.96,63.63) v3(74.96,61.09) v3(75.9,21.93) v3(76.92,21.93) v3(77.66,1.07) v3(77.94,21.93) v3(78.14,199.44) v3(78.19,168.63) v3(78.19,167.89) v3(78.52,203.33) v3(78.95,21.93) v3(79.41,203.33) v3(80.55,163.19) v3(80.55,162.43) v3(80.93,201.8) v3(80.93,123.12) v3(81.44,163.19) v3(81.44,162.43) v3(81.82,161.67) v3(82.2,163.19) v3(82.2,162.43) v3(82.71,121.41) v3(82.74,1.07) v3(82.8,202.04) v3(83.85,176.28) v3(83.85,175.39) v3(83.85,174.62) v3(83.85,173.86) v3(83.85,173.1) v3(84.23,194.06) v3(84.23,193.29) v3(84.23,192.53) v3(84.23,191.64) v3(84.23,190.88) v3(84.23,190.12) v3(84.36,119.76) v3(84.74,212.09) v3(84.74,211.07) v3(85.15,161.72) v3(85.63,161.21) v3(85.76,211.07) v3(85.76,167.94) v3(86.65,93.52) v3(86.77,63.37) v3(87.03,215.26) v3(87.03,214.5) v3(87.66,43.05) v3(88.81,216.15) v3(94.14,1.14) v3(96.17,21.34) v3(97.06,15.49) v3(97.32,38.1) v3(97.32,12.32) v3(97.44,32.77) v3(97.57,36.83) v3(97.57,10.67) v3(97.82,1.14) v3(97.95,133.48) v3(97.95,14.22) v3(98.46,111.51) v3(98.46,35.43) v3(98.97,37.97) v3(98.97,12.32) v3(99.22,15.24) v3(99.47,126.97) v3(100.24,42.42) v3(101,21.46) v3(101.51,19.3) v3(101.63,31.75) v3(101.63,1.14) v3(102.14,54.23) v3(102.65,13.21) v3(102.9,53.47) v3(103.03,11.05) v3(103.54,70.99) v3(104.3,70.99) v3(104.43,13.34) v3(104.68,38.61) v3(105.06,79.76) v3(105.32,1.14) v3(105.44,99.31) v3(105.95,79.76) v3(106.21,99.31) v3(106.59,38.61) v3(107.26,71.31) v3(108.36,38.61) v3(108.36,22.35) v3(108.57,107.44) v3(108.57,106.68) v3(108.75,11.81) v3(108.87,20.95) v3(109,13.34) v3(109.51,203.71) v3(109.89,19.94) v3(109.89,11.43) v3(110.35,107.44) v3(110.35,106.68) v3(110.52,21.84) v3(110.52,19.05) v3(111.03,1.14) v3(111.41,105.28) v3(111.41,104.39) v3(111.41,103.5) v3(113.06,223.14) v3(113.44,203.71) v3(114.71,1.14) v3(120.3,1.14) v3(121.06,203.58) v3(121.19,224.28) v3(122.84,25.15) v3(122.84,24.38) v3(123.6,25.15) v3(123.99,1.14) v3(125.26,224.28) v3(125.38,203.58) v3(126.02,224.28) v3(126.14,203.58) v3(127.69,193.14) v3(128.61,193.14) v3(128.68,1.14) v3(131.1,60.83) v3(131.99,35.56) v3(132.37,1.14) v3(132.75,36.32) v3(132.75,35.56) v3(133.28,95.25) v3(133.28,94.49) v3(133.51,35.56) v3(134.78,196.85) v3(135.54,196.85) v3(136.43,1.14) v3(137.19,101.73) v3(137.19,100.71) v3(137.19,99.69) v3(137.19,98.68) v3(137.19,97.66) v3(137.19,96.65) v3(137.19,95.63) v3(137.32,160.66) v3(140.88,100.71) v3(141,1.14) v3(141.38,196.98) v3(142.15,196.47) v3(144.43,34.8) v3(145.7,197.74) v3(145.83,1.14) v3(147.1,14.1) v3(147.35,40.77) v3(147.48,104.65) v3(147.48,103.89) v3(147.99,197.74) v3(148.75,152.15) v3(150.02,150.5) v3(150.4,154.05) v3(150.4,112.14) v3(150.4,110.74) v3(151.04,1.14) v3(151.42,153.42) v3(151.43,114.95) v3(151.42,113.67) v3(151.93,151.13) v3(152.18,22.73) v3(152.18,21.72) v3(153.2,111.89) v3(153.2,110.62) v3(153.2,109.6) v3(153.2,22.73) v3(153.2,21.72) v3(153.96,113.7) v3(153.96,13.21) v3(153.96,9.53) v3(153.96,4.83) v3(153.96,1.14) v3(155.61,113.7) v3(156.12,16.08) v3(156.24,98.55) v3(156.24,93.98) v3(156.37,105.54) v3(156.93,113.75) v3(157.89,183.26) v3(158.91,48.9) v3(159.16,183.26) v3(159.55,16.13) v3(159.8,49.78) v3(159.8,48.9) v3(159.8,48.01) v3(160.69,48.9) v3(161.7,76.45) v3(162.34,104.27) v3(162.59,78.23) v3(162.59,77.34) v3(162.59,76.45) v3(162.59,75.56) v3(162.59,74.68) v3(163.48,76.45) v3(164.37,76.45) v3(164.5,210.44) v3(166.91,117.68) v3(166.91,116.92) v3(168.94,55.88) v3(168.94,52.2) v3(168.94,46.48) v3(168.94,42.8) v3(168.94,37.21) v3(168.94,33.53) v3(168.94,28.83) v3(168.94,25.15) v3(169.48,103.63) v3(169.58,151.89) v3(169.58,117.98) v3(173.77,145.54) v3(174.79,146.56) v3(174.79,145.54) v3(174.79,144.53) v3(175.8,145.54) v4(58.2,159.89) v4(59.98,148.36) v4(65.99,158.04) v4(66.07,161.42) v4(68.49,159.51) v4(68.79,151.64) v4(70.03,162.25) v4(70.52,149.61) v4(73.31,121.54) v4(73.44,120.14) v4(73.69,123.06) v4(74.96,120.27) v4(74.96,119) v4(74.96,117.86) v4(81.08,101.88) v4(81.11,100.92) v4(81.06,99.95) v4(81.13,99.09) v4(81.14,97.27) v4(81.11,95.94) v4(82.08,96) v4(82.92,102.91) v4(82.87,100.91) v4(83.04,99.09) v4(85.38,142.47) v4(87.28,144.15) v4(87.28,140.34) v4(87.75,96.12) v4(90.58,113.43) v4(92.59,113.44) v4(97.6,186.76) v4(97.98,159.51) v4(98.3,181.02) v4(99.61,175.38) v4(99.86,177.43) v4(99.99,178.73) v4(100.81,186.77) v4(101.38,184.79) v4(102.72,186.79) v4(132.75,177.04) v4(132.75,162.31) v4(132.66,157.32) v4(132.75,147.58) v4(132.72,137.39) v4(132.88,168.4) v4(133.3,160.69) v4(133.34,155.38) v4(133.38,180.97) v4(133.38,178.69) v4(133.37,154.3) v4(133.37,152.41) v4(133.38,145.57) v4(133.51,163.7) v4(133.51,125.09) v4(134,151.39) v4(134.03,140.13) v4(134.05,184.72) v4(134.15,171.58) v4(134.15,130.56) v4(134.65,160.67) v4(134.68,157.32) v4(134.72,155.44) v4(134.65,149.48) v4(134.78,163.7) v4(134.82,152.39) v4(134.78,141.74) v4(134.91,173.48) v4(135.25,138.06) v4(135.92,175.39) v4(135.92,171.58) v4(135.91,157.27) v4(135.95,155.44) v4(135.92,140.44) v4(135.88,136.24) v4(135.9,134.25) v4(135.95,142.16) v4(136.43,169.93) v4(136.43,163.7) v4(136.46,159.29) v4(136.58,184.71) v4(136.56,183.17) v4(136.56,162.31) v4(136.61,147.24) v4(136.71,165.8) v4(136.66,148.26) v4(136.81,130.56) v4(137.19,189.36) v4(137.19,159.29) v4(137.29,155.4) v4(137.83,178.69) v4(137.83,163.7) v4(137.83,162.31) v4(137.91,157.27) v4(140.62,125.09) v4(143.42,125.09) v4(147.86,182.37) v4(147.9,176.72) v4(147.91,157.83) v4(147.91,125.09) v4(148.05,147.83) v4(148.62,170.69) v4(148.61,164.1) v4(148.61,155.39) v4(148.7,160.99) v4(148.72,144.02) v4(148.77,156.51) v4(149.39,132.33) v4(149.46,138.57) v4(149.83,180.83) v4(149.81,164.08) v4(149.77,149.35) v4(149.9,184.62) v4(149.93,174.9) v4(149.88,157.83) v4(150.04,135.31) v4(150.06,160.97) v4(150.22,159.1) v4(150.16,136.99) v4(150.33,166.12) v4(150.53,167) v4(150.93,136.29) v4(150.91,131.7) v4(150.95,175.86) v4(150.98,169.92) v4(151.07,171.39) v4(151.1,157.52) v4(151.11,140.48) v4(151.58,129.71) v4(151.67,184.84) v4(151.8,159.13) v4(152.05,167) v4(152.07,161.01) v4(152.17,161.99) v4(152.29,164.36) v4(152.42,156.76) v4(152.94,154.81) v4(153.11,142.74) v4(173.39,151.89) v4(174.91,136.91) v4(175.29,140.84) v5(1.14,228.86) v5(1.14,223.78) v5(1.14,218.7) v5(1.14,213.62) v5(1.14,208.54) v5(1.14,203.46) v5(1.14,198.38) v5(1.14,193.3) v5(1.14,188.22) v5(1.14,183.14) v5(1.14,178.06) v5(1.14,172.98) v5(1.14,167.9) v5(1.33,153.97) v5(3.08,221.36) v5(3.21,223.52) v5(3.46,216.28) v5(3.59,199.64) v5(3.59,194.56) v5(3.59,189.48) v5(3.59,184.4) v5(3.84,181.1) v5(3.84,176.02) v5(3.84,170.94) v5(3.84,165.86) v5(4.58,152.32) v5(4.73,204.85) v5(5.14,148.38) v5(5.14,143.3) v5(5.14,138.22) v5(5.14,133.14) v5(5.37,218.57) v5(6.13,201.17) v5(6.13,196.72) v5(6.13,191.39) v5(6.13,187.07) v5(6.13,183.01) v5(6.13,177.93) v5(6.13,172.85) v5(6.13,167.77) v5(6.22,228.86) v5(6.64,226.95) v5(7.02,151.64) v5(7.02,146.56) v5(7.02,141.48) v5(7.02,136.4) v5(7.27,221.36) v5(8.92,226.44) v5(8.92,150.37) v5(8.92,145.29) v5(8.92,140.21) v5(8.92,135.13) v5(9.56,222.5) v5(10.22,133.14) v5(11.3,228.86) v5(12.35,225.17) v5(14.38,227.46) v5(15.3,133.14) v5(16.38,228.86) v5(20.38,133.14) v5(20.94,184.02) v5(20.94,183.11) v5(20.94,182.19) v5(21.14,73.86) v5(21.14,67.18) v5(21.14,62.1) v5(21.14,57.02) v5(21.14,41.78) v5(21.14,36.7) v5(21.14,31.62) v5(21.14,26.54) v5(21.14,21.46) v5(21.14,16.38) v5(21.14,11.3) v5(21.14,6.22) v5(21.46,228.86) v5(21.85,184.02) v5(21.85,183.11) v5(21.85,182.19) v5(21.85,181.28) v5(21.85,180.37) v5(22.87,184.15) v5(23.4,72.52) v5(23.4,65.84) v5(23.4,60.76) v5(23.4,55.68) v5(23.66,38.86) v5(23.66,37.72) v5(23.78,184.15) v5(24.75,184.15) v5(24.75,183.24) v5(24.75,182.32) v5(24.75,181.41) v5(24.75,180.49) v5(25.46,133.14) v5(25.66,184.15) v5(25.66,183.24) v5(25.66,182.32) v5(25.66,181.41) v5(25.66,180.49) v5(26.22,73.86) v5(26.54,228.86) v5(26.58,184.15) v5(26.58,183.24) v5(26.58,182.32) v5(26.58,181.41) v5(26.58,180.49) v5(28.66,154.94) v5(28.66,153.97) v5(28.66,153.06) v5(28.91,131.98) v5(29.14,126.97) v5(29.14,121.89) v5(29.14,116.81) v5(29.14,111.73) v5(29.14,106.65) v5(29.14,101.57) v5(29.14,96.49) v5(29.14,91.41) v5(29.14,86.33) v5(29.14,81.25) v5(29.14,76.17) v5(29.57,154.94) v5(29.57,153.97) v5(29.57,153.06) v5(29.85,163.32) v5(29.85,162.41) v5(29.85,161.49) v5(30.49,154.94) v5(30.49,153.97) v5(30.49,153.06) v5(30.77,163.32) v5(30.77,162.41) v5(30.77,161.49) v5(31.4,154.94) v5(31.4,153.97) v5(31.4,153.06) v5(31.62,228.86) v5(31.68,163.32) v5(34.96,75.72) v5(34.96,74.8) v5(35.09,65.53) v5(35.09,64.52) v5(35.09,39.75) v5(35.09,38.73) v5(35.21,203.84) v5(35.57,201.32) v5(35.57,200.41) v5(36.23,205.77) v5(36.23,203.84) v5(36.48,201.32) v5(36.48,200.41) v5(36.48,75.69) v5(36.48,74.68) v5(36.7,228.86) v5(37.37,203.45) v5(37.63,75.56) v5(37.88,208.41) v5(38.39,203.45) v5(38.64,52.96) v5(38.64,52.04) v5(38.64,51.13) v5(38.64,50.22) v5(38.9,208.41) v5(39.56,52.96) v5(39.56,52.04) v5(39.78,209.55) v5(39.78,208.64) v5(39.78,206.81) v5(39.78,205.89) v5(39.78,204.98) v5(39.78,203.96) v5(39.78,203.05) v5(39.78,201.22) v5(39.78,200.3) v5(40.7,209.55) v5(40.7,208.64) v5(40.7,206.81) v5(40.7,205.89) v5(40.7,204.98) v5(40.7,203.96) v5(40.7,203.05) v5(40.7,201.22) v5(40.7,200.3) v5(41.61,209.55) v5(41.61,208.64) v5(41.61,206.81) v5(41.61,205.89) v5(41.61,204.98) v5(41.61,203.96) v5(41.61,203.05) v5(41.61,201.22) v5(41.61,200.3) v5(41.78,228.86) v5(42.07,173.74) v5(43.09,173.74) v5(44.1,173.74) v5(45.12,173.74) v5(46.13,173.74) v5(46.86,228.86) v5(47.15,173.74) v5(47.61,190.78) v5(47.61,189.87) v5(48.17,34.42) v5(48.17,33.4) v5(48.17,32.26) v5(48.52,190.78) v5(48.52,189.87) v5(48.8,170.56) v5(48.8,21.21) v5(49.18,33.4) v5(49.18,32.26) v5(49.31,26.54) v5(49.44,190.78) v5(49.44,189.87) v5(49.82,170.56) v5(50.71,28.19) v5(50.71,21.21) v5(50.83,170.56) v5(51.94,228.86) v5(52.23,170.56) v5(53.83,190.78) v5(53.83,189.87) v5(53.75,170.56) v5(54.74,190.78) v5(54.74,189.87) v5(54.77,170.56) v5(55.66,190.78) v5(55.66,189.87) v5(55.79,170.56) v5(56.04,21.97) v5(57.02,228.86) v5(57.28,21.97) v5(57.44,177.04) v5(58.07,182.37) v5(58.45,177.04) v5(59.09,182.37) v5(59.22,218.19) v5(59.47,177.04) v5(60.1,182.37) v5(60.23,218.19) v5(60.61,177.04) v5(61.25,218.19) v5(61.25,182.37) v5(62.1,228.86) v5(62.26,218.19) v5(63.28,218.19) v5(66.33,216.28) v5(66.96,215.52) v5(66.96,214.5) v5(67.18,228.86) v5(67.22,200.41) v5(67.6,209.93) v5(67.6,208.03) v5(67.6,205.99) v5(72.26,228.86) v5(78.92,196.22) v5(79.63,196.8) v5(80.42,197.36) v5(82.42,228.86) v5(84.23,226.31) v5(85.2,226.31) v5(86.11,226.31) v5(86.39,73.91) v5(87.03,226.31) v5(87.41,73.91) v5(87.5,228.86) v5(87.66,202.82) v5(87.82,1.14) v5(87.99,226.31) v5(88.43,73.91) v5(88.68,16.26) v5(88.68,12.57) v5(88.68,10.79) v5(88.93,226.31) v5(89.44,73.91) v5(89.7,16.26) v5(89.7,12.57) v5(89.7,10.79) v5(92.58,228.86) v5(94.39,203.58) v5(95.31,203.58) v5(96.22,203.58) v5(97.66,228.86) v5(97.98,226.53) v5(97.98,225.62) v5(98.94,226.53) v5(98.94,225.62) v5(99.6,203.58) v5(99.86,226.53) v5(99.86,225.62) v5(100.52,203.58) v5(100.77,226.53) v5(100.77,225.62) v5(101.43,203.58) v5(101.73,226.53) v5(101.73,225.62) v5(102.74,228.86) v5(102.67,226.53) v5(102.67,225.62) v5(107.82,228.86) v5(112.9,228.86) v5(117.98,228.86) v5(119.29,9.27) v5(123.06,228.86) v5(126.4,3.66) v5(127.29,10.92) v5(127.41,3.66) v5(128.05,214.38) v5(128.05,210.44) v5(128.14,228.86) v5(128.3,224.33) v5(129.83,212.47) v5(130.97,224.28) v5(132.11,217.3) v5(132.49,84.25) v5(132.75,91.57) v5(132.75,90.65) v5(132.75,89.74) v5(132.75,88.82) v5(132.75,87.91) v5(132.75,87) v5(132.75,86.08) v5(132.75,85.17) v5(133.13,214.38) v5(133.13,210.44) v5(133.22,228.86) v5(133.41,84.25) v5(133.66,91.57) v5(133.66,90.65) v5(133.66,89.74) v5(133.66,88.82) v5(133.66,87.91) v5(133.66,87) v5(133.66,86.08) v5(133.66,85.17) v5(134.15,224.28) v5(134.4,22.99) v5(134.58,91.57) v5(134.58,90.65) v5(134.58,89.74) v5(134.58,88.82) v5(134.58,87.91) v5(134.58,87) v5(134.58,86.08) v5(134.58,85.17) v5(134.91,212.47) v5(135.42,22.99) v5(135.49,91.57) v5(135.49,90.65) v5(135.49,89.74) v5(135.49,88.82) v5(135.49,87.91) v5(135.49,87) v5(135.49,86.08) v5(135.49,85.17) v5(136.05,26.04) v5(136.05,9.78) v5(136.3,217.17) v5(136.43,22.99) v5(136.94,224.28) v5(136.94,9.37) v5(137.07,26.04) v5(137.57,26.92) v5(137.96,10.29) v5(137.96,9.37) v5(138.08,26.04) v5(138.21,214.38) v5(138.21,210.44) v5(138.3,228.86) v5(138.59,26.92) v5(139.1,26.04) v5(139.48,22.99) v5(139.73,26.92) v5(139.99,224.41) v5(139.99,212.47) v5(140.11,26.04) v5(140.5,22.99) v5(140.62,217.3) v5(141.13,26.04) v5(141.51,22.99) v5(142.78,77.39) v5(142.78,75.56) v5(143.38,228.86) v5(145.83,210.19) v5(146.85,210.21) v5(147.1,3.68) v5(147.33,6.45) v5(147.86,210.19) v5(148.12,3.68) v5(148.46,228.86) v5(149,221.62) v5(149.13,225.04) v5(149.39,213.36) v5(149.64,3.68) v5(150.6,3.68) v5(150.91,219.84) v5(151.29,223.01) v5(151.54,3.68) v5(152.81,217.93) v5(153.2,221.11) v5(153.54,228.86) v5(153.58,226.57) v5(154.72,215.9) v5(155.48,227.71) v5(155.48,218.82) v5(157.01,226.44) v5(157.89,216.41) v5(158.02,220.85) v5(158.02,194.82) v5(158.02,193.8) v5(158.02,192.66) v5(158.62,228.86) v5(159.29,226.19) v5(159.55,223.14) v5(159.93,218.95) v5(160.31,228.73) v5(160.56,221.11) v5(160.69,213.61) v5(161.83,217.3) v5(162.34,219.46) v5(163.86,215.9) v5(165.77,218.95) v5(166.4,212.72) v5(168.69,220.22) v5(168.86,218.7) v5(168.86,213.62) v5(168.86,208.54) v5(168.86,203.46) v5(168.86,198.38) v5(168.86,193.3) v5(168.86,188.22) v5(168.86,183.14) v5(168.86,178.06) v5(168.86,162.82) v5(173.7,161.26) v5(175.04,159.77) v5(177.07,117.73) v5(177.2,120.27) v5(177.2,115.44) v5(177.45,157.35) v5(177.58,105.92) v5(178.21,125.22) v5(178.21,99.82) v5(178.21,96.52) v5(178.21,93.09) v5(178.47,111.76) v5(178.72,159.38) v5(178.72,108.84) v5(178.72,103.25) v5(178.78,161.26) v5(178.78,68.04) v5(179.36,119.76) v5(179.36,114.81) v5(179.48,88.39) v5(180.63,156.34) v5(180.63,117.35) v5(180.88,98.81) v5(181.14,129.41) v5(181.14,122.3) v5(181.14,110.24) v5(181.14,87) v5(181.26,125.35) v5(181.26,113.67) v5(181.26,95.25) v5(181.26,91.95) v5(181.64,101.98) v5(181.64,83.82) v5(181.9,120.14) v5(182.02,127.89) v5(182.28,115.57) v5(182.41,88.52) v5(182.66,153.54) v5(183.6,120.62) v5(183.6,115.54) v5(183.6,100.3) v5(183.6,95.22) v5(183.6,90.14) v5(183.8,110.24) v5(183.86,161.26) v5(183.86,156.18) v5(183.86,151.1) v5(183.86,146.02) v5(183.86,140.94) v5(183.86,135.86) v5(183.86,125.7) v5(183.86,85.06) v5(183.88,69.09)
