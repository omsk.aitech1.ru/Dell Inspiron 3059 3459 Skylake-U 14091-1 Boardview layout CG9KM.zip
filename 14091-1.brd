# Allegro board 14091-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_SMI#: length 175.4
  TOP w0.089: 75.2,144.27 75.41,144.49 75.46,144.58 75.46,144.78 75.42,144.87 75.42,145.16 75.46,145.23 75.46,146.38 CPU1.G4
  TOP w0.102: v3(98.71,59.31) 98.56,59.46 U4101.13 ; R1611.1 72.3,141.54 72.3,142.24 v3(73.06,143) 73.24,143 74.51,144.27 75.2,144.27
  L3 w0.127: v3(112.17,61.98) 112.75,61.4 112.75,60.22 112.41,59.88 110.84,59.88 110.18,60.54 99.94,60.54 v3(98.71,59.31)
  L4 w0.127: v3(73.06,143) 74.9,141.16 74.9,138.46 75.56,137.8 75.56,135.69 76.83,134.42 76.83,132.56 85.81,123.57 86.27,123.57 87.64,122.2 112.36,122.2 120.86,113.71 120.86,109.95 121.67,109.14 135.26,109.14 v3(135.66,108.74)
  BOTTOM w0.102: v3(135.66,108.74) 135.89,108.74 138.74,105.88 138.74,75.78 137.7,74.73 137.7,74.41 137.31,74.02 124.1,74.02 v2(123.87,73.79) 112.17,62.09 v3(112.17,61.98)
EC_VCORF: length 10.3
  TOP w0.102: C4101.2 103.02,60.17 v1(102.14,60.17) 100.33,60.17 99.49,61.01 98.89,61.01 97.06,62.84 95,62.84 94.92,62.76 U4101.20
EDID_RDY: length 109.2
  TOP w0.102: CPU1.J1 76.46,144.62 76.46,143.74 75.47,142.75 v1(75.47,142.37) 75.09,141.99 R80132.1 75.88,140.63 75.88,139.08 73.78,136.98 65.52,136.98 65.21,137.29 60.91,137.29 57.5,133.87 v3(57.5,133.86) ; v3(66.63,77.44) 66.62,77.44 SCA1.41
  L3 w0.127: v3(57.5,133.86) 57.03,134.33 56.54,134.33 55.86,133.65 55.86,131.75 44.48,120.37 44.48,114.89 42.91,113.32 42.91,91.72 45.08,89.54 45.08,87.58 50.94,81.72 52.29,81.72 54.21,79.8 57.69,79.8 60.05,77.44 v3(66.63,77.44)
EDP_AUX_CPU_N: length 180
  TOP w0.102: 80.32,50.99 80.54,50.99 80.98,50.55 81.44,50.55 81.57,50.67 81.57,50.92 81.43,51.05 v3(81.19,51.05) ; 80.32,50.99 78.78,50.99 78.39,50.6 78.07,50.6 77.95,50.72 77.95,50.93 R79755.2 R79172.1 76.72,50.72 76.38,50.72 C12175.1 ; 80.32,50.99 v1(80.32,51.36) ; v4(74.74,170.67) 74.83,170.58 74.83,170.39 74.59,170.16 74.46,170.16 CPU1.E45
  L3 w0.127: v3(81.19,51.05) 80.87,50.74 78.19,50.74 76.94,51.99 76.94,56.46 76.63,56.78 76.63,67.3 75.08,68.85 69.36,68.85 68.85,69.35 64.87,69.35 62.19,72.03 52.84,72.03 50.87,74 50.87,79.34 43.94,86.27 43.94,89.04 40.65,92.33 40.65,119.15 57.95,136.45 57.95,150.11 58.57,150.74 58.57,156.88 56.95,158.49 56.95,161.65 57.75,162.45 64.23,162.45 67.99,166.2 71.11,166.2 72.04,167.13 72.04,168.02 73.05,169.02 73.17,169.02 73.96,169.82 73.96,170.31 74.34,170.69 74.72,170.69 v4(74.74,170.67)
EDP_AUX_CPU_P: length 180
  TOP w0.102: 79.46,50.77 80.45,50.77 81.13,50.09 v3(81.21,50.09) ; 79.46,50.77 v1(79.46,50.37) ; 79.46,50.77 78.87,50.77 78.2,50.1 R79171.2 R79756.1 76.72,50.5 76.38,50.5 C12176.1 ; CPU1.F45 75.06,170.32 v4(75.37,170.63)
  L3 w0.127: v3(81.21,50.09) 80.82,50.48 78.08,50.48 76.68,51.88 76.68,56.35 76.36,56.67 76.36,67.19 74.97,68.58 69.25,68.58 68.74,69.09 64.76,69.09 62.08,71.77 52.73,71.77 50.6,73.89 50.6,79.23 43.67,86.16 43.67,88.93 40.38,92.22 40.38,119.26 57.68,136.56 57.68,150.22 58.3,150.85 58.3,156.77 56.69,158.38 56.69,161.76 57.64,162.71 64.12,162.71 67.88,166.47 71,166.47 71.78,167.24 71.78,168.13 72.93,169.29 73.06,169.29 73.69,169.93 73.69,170.42 74.37,171.09 74.91,171.09 75.06,170.94 75.06,170.94 v4(75.37,170.63)
EDP_HPD_CPU: length 163.9
  TOP w0.102: v3(79.28,128.14) 78.77,127.64 78.77,127 78.44,126.67 74.53,126.67 73.32,127.88 65.97,127.88 63.45,125.36 36.7,125.36 v1(36.69,125.35) 36.61,125.35 v3(35.72,124.46) ; v3(54.52,52.45) 54.52,52.1 55.41,51.21 56.33,51.21 R530.1 56.93,50.74 R79926.1 R79925.2 59.99,50.74 v1(60.18,50.55) ; v4(78.13,150.34) 77.98,150.34 CPU1.L10
  L3 w0.127: v3(54.52,52.45) 54.52,56.48 54.39,56.61 54.39,59.11 44.53,68.96 44.53,76.57 34.1,87 34.1,123.2 35.37,124.46 v3(35.72,124.46)
  L4 w0.127: v3(79.28,128.14) 79.28,129.08 76.24,132.12 76.24,134.18 74.97,135.45 74.97,137.55 73.63,138.9 73.63,140.91 72.3,142.24 72.3,143.13 72.23,143.2 72.23,144.27 74.25,146.3 76.35,146.3 77.11,147.07 77.11,149.32 v4(78.13,150.34)
EDP_RCOMP_CPU: length 13.4
  TOP w0.203: CPU1.E52 74.41,173.66 v4(74.71,173.36)
  L3 w0.203: v3(84.11,169.93) 80.68,173.36 v4(74.71,173.36)
  BOTTOM w0.203: v3(84.11,169.93) 84.74,169.29 R801.2
  BOTTOM w0.508: v4(74.71,173.36) 74.71,172.84 v2(74.99,172.57)
EDP_TX_CPU_N0: length 160.6
  TOP w0.102: v3(67.85,171.83) 67.51,171.49 67.51,171.38 67.59,171.3 72.4,171.3 72.47,171.37 72.49,171.37 72.76,171.64 CPU1.C47 ; C12180.1 73.59,61.13 73.86,61.13 v3(74.2,61.47)
  L3 w0.127: v3(67.85,171.83) 67.36,171.34 67.36,171.08 66.84,170.56 59.46,170.56 53.49,164.58 53.49,157.24 53.83,156.9 53.83,150.32 52.62,149.11 52.62,142.89 51.48,141.75 51.48,134.72 37.41,120.65 37.41,90.76 39.4,88.77 39.4,86.27 47.77,77.9 47.77,72.34 52.28,67.83 56.66,67.83 60.37,64.12 70.53,64.12 73.5,61.15 73.88,61.15 v3(74.2,61.47)
  BOTTOM w0.102: v3(67.85,171.83) 67.85,172.59 v2(67.72,172.72)
EDP_TX_CPU_N1: length 160.7
  TOP w0.089: CPU1.D46 72.78,170.77 72.59,170.34 72.57,170.33 72.51,170.28 72.49,170.27 72.44,170.25 72.36,170.24 72.23,170.25 72.14,170.28 71.89,170.28 71.73,170.21 71.63,170.21 71.47,170.29 70.96,170.29 70.95,170.3 69.83,170.3 69.55,170.02 69.55,169.72 v4(69.38,169.54)
  TOP w0.102: v3(74.2,63.25) 73.86,62.91 73.59,62.91 C12182.1
  L3 w0.127: v4(69.38,169.54) 69.38,168.91 69.19,168.72 68.8,168.72 67.36,167.27 65.21,167.27 64.21,168.28 60.49,168.28 55.87,163.66 55.87,157.9 57.53,156.25 57.53,151.33 56.9,150.71 56.9,137.14 39.59,119.83 39.59,91.84 42.8,88.64 42.8,85.92 49.83,78.89 49.83,73.4 52.36,70.87 57.44,70.87 58.31,69.99 62.5,69.99 65.18,67.31 74.66,67.31 75.59,66.38 75.59,63.58 75.15,63.14 74.79,63.14 74.68,63.25 v3(74.2,63.25)
  BOTTOM w0.102: v2(75.78,63.6) 75.34,63.17 74.28,63.17 v3(74.2,63.25)
EDP_TX_CPU_N2: length 157.4
  TOP w0.102: C12373.1 73.59,64.69 73.86,64.69 v3(74.2,65.02) ; CPU1.A45 71.64,170.56 67.65,170.56 67.18,170.09 67.18,169.84 v3(67.47,169.54)
  L3 w0.127: v3(67.47,169.54) 67.11,169.19 67.11,168.94 66.84,168.67 65.65,168.67 64.76,169.56 59.71,169.56 54.27,164.12 54.27,157.59 54.66,157.21 54.66,149.88 53.51,148.73 53.51,135.63 38.19,120.3 38.19,91.19 40.23,89.15 40.23,86.55 48.55,78.23 48.55,72.66 52.6,68.61 57.18,68.61 60.89,64.9 71.84,64.9 72.75,63.98 73.54,63.98 73.69,64.13 73.69,65.28 73.82,65.41 74.07,65.41 74.2,65.28 v3(74.2,65.02)
  BOTTOM w0.102: v3(67.47,169.54) 67.47,169.93 v2(67.09,170.31)
EDP_TX_CPU_N3: length 156.8
  TOP w0.102: C12374.1 73.67,67.56 73.84,67.39 73.84,66.97 74.01,66.8 v3(74.2,66.8) ; v4(69.9,171.83) 69.83,171.83 69.6,172.06 69.6,172.25 69.73,172.38 70.68,172.38 71.06,172 71.57,172 71.69,171.88 CPU1.A47
  L3 w0.127: v4(69.9,171.83) 69.9,171.42 69.77,171.3 69.11,171.3 68.32,170.51 68.32,169 67.22,167.89 65.33,167.89 64.44,168.78 60.23,168.78 55.35,163.91 55.35,157.65 57.02,155.99 57.02,151.54 56.4,150.92 56.4,137.39 39,119.99 39,91.52 42.17,88.34 42.17,85.75 49.32,78.6 49.32,72.98 52.82,69.48 58.31,69.48 59.12,68.67 63.1,68.67 65.28,66.49 71.82,66.49 72.13,66.18 73.69,66.18 73.82,66.31 73.82,66.67 73.95,66.8 v3(74.2,66.8)
  BOTTOM w0.102: v4(69.9,171.83) 69.9,171.41 v2(70.24,171.07)
EDP_TX_CPU_P0: length 160.7
  TOP w0.102: CPU1.C46 72.49,171.07 72.49,171.08 67.5,171.08 67.3,171.29 67.3,171.62 v3(67.09,171.83) ; C12179.1 73.59,60.92 73.86,60.92 v3(74.2,60.58)
  L3 w0.127: v3(67.09,171.83) 67.09,171.19 66.72,170.83 59.35,170.83 53.22,164.69 53.22,157.13 53.56,156.79 53.56,150.43 52.36,149.22 52.36,143 51.21,141.86 51.21,134.83 37.15,120.77 37.15,90.65 39.14,88.66 39.14,86.16 47.51,77.79 47.51,72.23 52.17,67.56 56.55,67.56 60.26,63.86 70.42,63.86 73.39,60.88 73.9,60.88 v3(74.2,60.58)
  BOTTOM w0.102: v3(74.2,60.58) 74.2,60.12 v2(74.56,59.77)
EDP_TX_CPU_P1: length 160.6
  TOP w0.089: CPU1.C45 72.72,170.19 72.65,170.15 72.6,170.12 72.44,170.06 72.39,170.05 72.24,170.05 72.15,170.08 72.1,170.1 71.92,170.1 71.76,170.04 71.59,170.04 71.43,170.11 70.96,170.11 70.95,170.11 69.91,170.11 69.74,169.94 69.74,169.81 v4(70.01,169.54)
  TOP w0.102: C12181.1 73.59,62.69 73.86,62.69 v3(74.2,62.36)
  L3 w0.127: v4(70.01,169.54) 69.97,169.54 69.64,169.22 69.64,168.8 69.3,168.45 68.91,168.45 67.47,167 65.1,167 64.1,168.01 60.6,168.01 56.14,163.55 56.14,158.01 57.79,156.36 57.79,151.22 57.17,150.6 57.17,137.03 39.86,119.72 39.86,91.95 43.06,88.75 43.06,86.03 50.1,79 50.1,73.51 52.47,71.13 57.55,71.13 58.42,70.26 62.61,70.26 65.29,67.58 74.77,67.58 75.85,66.49 75.85,63.47 75.26,62.88 74.72,62.88 v3(74.2,62.36)
  BOTTOM w0.102: v2(75.7,62.2) 75.34,62.56 74.4,62.56 v3(74.2,62.36)
EDP_TX_CPU_P2: length 156.9
  TOP w0.102: v1(66.84,170.64) 67.13,170.35 ; 67.13,170.35 67.56,170.78 71.84,170.78 71.93,170.69 72.16,170.69 CPU1.B45 ; 67.13,170.35 66.96,170.18 66.96,169.8 v3(66.71,169.54) ; C12371.1 73.59,64.47 73.99,64.47 v3(74.2,64.26)
  L3 w0.127: v3(66.71,169.54) 66.85,169.41 66.85,169.05 66.73,168.94 65.76,168.94 64.87,169.82 59.6,169.82 54.01,164.23 54.01,157.48 54.33,157.16 54.39,157.1 54.39,149.99 53.25,148.84 53.25,135.74 37.92,120.41 37.92,91.08 39.96,89.04 39.96,86.44 48.28,78.12 48.28,72.55 52.49,68.34 57.07,68.34 60.78,64.63 71.73,64.63 72.64,63.72 73.65,63.72 v3(74.2,64.26)
EDP_TX_CPU_P3: length 156.9
  TOP w0.102: v4(69.27,171.83) 69.39,171.95 69.39,172.34 69.64,172.59 70.77,172.59 71.15,172.21 71.69,172.21 72.26,171.64 CPU1.B47 ; C12372.1 73.44,66.67 v3(74.2,65.91)
  L3 w0.127: v4(69.27,171.83) 68.05,170.62 68.05,169.11 67.11,168.16 65.44,168.16 64.55,169.05 60.12,169.05 55.09,164.02 55.09,157.54 56.75,155.88 56.75,151.65 56.13,151.03 56.13,137.5 38.73,120.1 38.73,91.41 41.9,88.23 41.9,85.64 49.06,78.49 49.06,72.87 52.71,69.22 58.2,69.22 59.01,68.41 62.99,68.41 65.17,66.22 71.71,66.22 72.02,65.91 v3(74.2,65.91)
  BOTTOM w0.102: v2(68.84,171.07) 69.27,171.49 v4(69.27,171.83)
EDRAM_OPIO_RCOMP: length 2.6
  TOP w0.203: v4(75.98,181.85) 76.3,182.17 CPU1.H66
  BOTTOM w0.203: v4(75.98,181.85) 76.82,181.85 R80009.1 v2(76.87,182.88)
EESCL: length 10.8
  TOP w0.102: SCA1.56 59.12,74.83 58.96,74.67 58.96,73.15 v3(61.12,70.99)
  BOTTOM w0.102: RN9503.2 59.98,71.5 60.08,71.4 60.71,71.4 v3(61.12,70.99) 61.12,70.92 61.86,70.18 v2(61.98,70.18) 62.42,70.18 62.72,70.48 63.79,70.48
EESDA: length 11.6
  TOP w0.102: SCA1.57 58.62,74.83 58.45,74.66 58.45,72.9 60.36,70.99 v3(60.36,70.94)
  BOTTOM w0.102: RN9503.3 60.35,71 60.36,70.99 v3(60.36,70.94) 60.36,69.99 v2(61.48,68.86) 62.42,68.86 62.77,69.22 63.79,69.22
EMMC_RCOMP: length 11.2
  TOP w0.203: R1502.1 87.62,136.79 v1(87.87,136.55) 88.31,136.55 89.16,137.4 89.16,140.21 90.77,141.82 90.77,142.99 90.8,143.02 90.8,143.65 90.57,143.88 90.57,144.48 90.44,144.6 CPU1.AT1
EOPIO_RCOMP: length 3.8
  TOP w0.203: v4(75.99,180.85) 76.3,181.15 CPU1.H65
  BOTTOM w0.203: R80008.1 v2(73.95,180.34) 73.96,180.33 75.48,180.33 75.81,180.66 75.81,180.67 v4(75.99,180.85)
EQ: length 8.4
  TOP w0.102: U118.17 132.15,38.76 132.32,38.93 132.32,39.42 v3(131.86,39.88)
  BOTTOM w0.102: R1593.2 130.18,41.31 130.18,40.94 v2(130.23,40.89) 130.23,40.87 130.94,40.16 131.58,40.16 v3(131.86,39.88) 130.84,39.88 130.36,39.4 130.36,38.44 R2085.1
ESPI_RST#: length 11.3
  TOP w0.089: 95.95,149.85 94.73,151.07 93.93,151.07 93.67,150.81 CPU1.BA11
  TOP w0.102: 95.95,149.85 95.96,149.84 98.49,149.84 99.86,148.48 TP9918.1
EXT_PWR_GATE#: length 27.2
  TOP w0.102: CPU1.AM10 87.95,150.06 v4(87.55,149.66)
  BOTTOM w0.102: v4(87.55,149.66) 87.98,149.24 87.98,146.25 89,145.22 90.37,145.22 91.22,144.37 v2(91.22,144.17) 91.22,140.08 88.83,137.69 88.83,135.03 89.72,134.14 89.72,131.73 92.29,129.16 93.06,129.16 R80035.2
EXT_RST#: length 5.4
  TOP w0.102: U4101.41 86.64,57.46 R79706.2 85.77,57.34 v3(85.66,57.23) 85.54,57.34 R79705.1
  BOTTOM w0.102: v2(84.84,57.23) v3(85.66,57.23)
FALL_INT2: length 19.4
  TOP w0.102: 100.57,64.25 100.49,64.32 100.49,64.64 100.74,64.9 Q6701.2 ; 100.57,64.25 Q6701.3 ; 100.57,64.25 99.68,64.25 v1(99.36,64.56) 98.17,65.76 90.88,65.76 90.08,64.96 90.08,64.43 88.39,62.74 87.35,62.74 R6703.2
FFS_INT1: length 212.6
  TOP w0.089: 76.26,143.97 76.26,144.79 76.3,144.87 76.3,145.15 76.26,145.24 76.26,145.44 76.33,145.57 76.33,145.79 CPU1.J3
  TOP w0.102: R79872.1 149,57.15 v3(149.64,57.78) ; 76.26,143.97 74.46,142.16 74.46,140.39 74.89,139.95 74.89,138.42 73.68,137.21 65.61,137.21 65.31,137.52 60.33,137.52 v1(59.82,137.01) 59.82,136.89 56.79,133.86 v3(56.74,133.86) ; R6702.2 85.71,62.17 R79658.2 84.37,60.83 81.72,60.83 v3(81.21,61.34)
  L3 w0.127: v3(56.74,133.86) 56.12,133.24 56.12,131.64 44.74,120.27 44.74,114.79 43.16,113.21 43.16,91.82 45.32,89.66 45.32,89.63 45.33,89.62 45.33,87.69 51.05,81.98 52.44,81.98 54.28,80.14 57.82,80.14 58.96,81.28 64.96,81.28 73.38,72.86 73.38,71.56 74.45,70.48 75.49,70.48 78.39,67.58 78.39,66.16 81.19,63.36 81.19,61.37 v3(81.21,61.34)
  L4 w0.127: v3(81.21,61.34) 81.85,61.98 87.13,61.98 87.28,61.98 87.62,62.32 90.99,62.32 91.47,62.8 95.79,62.8 96.15,62.45 97.92,62.45 99.47,60.9 100.3,60.9 102.15,59.05 107.78,59.05 110.92,55.92 113.09,55.92 113.51,55.5 121.76,55.5 122.14,55.89 122.18,55.92 124.15,55.92 125,56.77 134.65,56.77 135.22,57.34 140.43,57.34 140.88,56.9 144.43,56.9 145.03,56.3 147.43,56.3 148.91,57.78 v3(149.64,57.78)
FFS_INT1_C: length 3.6
  TOP w0.102: U6701.11 86.01,63.23 85.69,62.92 85.25,62.92 85.05,63.12 84.69,63.12 v1(84.62,63.04) 84.62,62.22 R79658.1
FFS_INT1_SIO: length 3.8
  TOP w0.102: R79872.2 147.24,56.59 146.2,56.59 145.38,55.77 U109.110
FFS_INT2_APU: length 131.4
  TOP w0.089: 76.46,143.23 76.66,143.42 76.66,144.31 76.78,144.58 76.78,144.79 CPU1.J2
  TOP w0.102: 76.46,143.23 76.11,142.88 76.11,138.99 73.87,136.75 65.42,136.75 65.12,137.06 61.02,137.06 59.47,135.51 59.47,135.06 59.16,134.76 v1(59.16,134.75) 59.15,134.75 v3(58.26,133.86) ; v3(81.97,61.34) 81.76,61.56 R79657.2
  L3 w0.127: v3(81.97,61.34) 81.95,61.37 81.95,62.96 78.65,66.26 78.65,67.69 75.59,70.74 74.55,70.74 73.69,71.6 73.69,72.91 65.07,81.53 53.25,81.53 52.55,82.23 51.15,82.23 45.59,87.8 45.59,89.78 43.42,91.95 43.42,113.11 44.99,114.68 44.99,120 56.37,131.38 56.37,132.51 57.02,133.17 57.57,133.17 v3(58.26,133.86)
FFS_INT2_C: length 31.4
  TOP w0.102: U6701.9 84.61,64.23 84.06,63.68 84.06,62.5 R79668.1 82.71,62.17 R79657.1 R6704.2 v3(83.6,63.25) ; v3(90.04,63.74) 90.33,64.03 90.33,64.89 90.98,65.53 95.79,65.53 96.43,64.9 v1(96.98,64.9) 98.07,64.9 99.21,63.75 102,63.75 102.65,63.11 102.65,62.67 R6706.1 103.03,62.55 103.03,64.52 103.4,64.9 Q6701.5
  L4 w0.127: v3(83.6,63.25) 83.6,63.37 84.11,63.88 89.9,63.88 v3(90.04,63.74)
FFS_INT2_Q: length 200
  TOP w0.102: Q6701.6 104.03,65.55 104.68,64.9 v3(104.68,62.61) 103.98,61.91 R6705.2 102.97,61.59 R6706.2
  L4 w0.127: SATAP1.5 13.43,188.57 13.43,160.77 14,160.2 17.56,156.64 17.56,143.69 24.02,137.22 29.2,137.22 33.12,133.31 33.12,124.44 35,122.56 40.17,122.56 43.11,119.61 43.11,86.18 47.63,81.66 51.6,81.66 54.68,78.59 55.46,78.59 57.24,76.81 60.23,76.81 65.92,71.12 68.58,71.12 69.56,70.14 72.56,70.14 73.29,69.41 88.65,69.41 91.15,66.9 97.16,66.9 100.65,63.41 101.35,63.41 101.59,63.17 104.12,63.17 v3(104.68,62.61)
FIVR_EN_R: length 18.2
  TOP w0.102: R9907.2 R9906.2 42.96,223.71 41.69,222.44 v1(41.38,222.44) 40.35,222.44 36.61,218.69 33.67,218.69 33.31,218.33 33.31,217.62 32.47,216.79 31.52,216.79 30.83,216.11 XDP1.45
FLASH_WP: length 29.3
  TOP w0.102: SCA1.108 57.62,57.05 62.14,61.56 v3(62.14,65.91) ; R9509.1 v2(75.6,65.02) v3(74.96,64.39)
  L4 w0.127: v3(74.96,64.39) 74.96,64.36 74.4,63.79 73.27,63.79 70.94,66.13 62.35,66.13 v3(62.14,65.91)
  BOTTOM w0.102: v3(74.96,64.39) v2(75.6,65.02)
FWH_ID0: length 6
  TOP w0.102: LPC1.6 109.03,58.01 108.87,58.17 R1700.2 107.79,59.37 v1(107.73,59.44)
GPD2/LAN_WAKE#: length 41.4
  TOP w0.102: R80049.2 105.04,123.23 v1(105.04,124.69) 105.04,124.94 106.21,126.11 106.21,134.37 v3(107.86,136.02) ; CPU1.AM15 87.95,152.7 v4(88.27,152.37)
  L3 w0.127: v4(88.27,152.37) 88.77,151.88 91.33,151.88 91.9,151.31 93.45,151.31 106.06,138.69 106.06,137.81 v3(107.86,136.02)
GPIO: length 5
  BOTTOM w0.102: U14.28 174.59,148.87 175.8,150.09 v2(175.8,150.32) 175.8,151.12 175.61,151.31 R79850.1
GPIO17_THERMAL_INT: length 17.5
  TOP w0.102: R1884.2 v1(94.52,85.98) 93.57,85.98 R1887.2 R1896.2 92.49,86.74 90.91,88.32 87.02,88.32 86.24,89.09 86.24,89.62 85.82,90.04 85.69,90.04 85.38,90.36 85.38,90.89 85.05,91.22 84.12,91.22 83.87,91.46 83.87,91.6 83.54,91.93 82.15,91.93 81.82,91.6 GPU1.R6
GPIO19_CTF: length 16.5
  TOP w0.102: GPU1.M2 79.41,89.59 79.41,87.27 v1(79.71,86.97) 80.32,86.36 80.32,85.88 81.69,84.51 82.85,84.51 82.9,84.45 85.98,84.45 86.94,83.49 90.09,83.49 R1886.1 90.52,83.06 R329.2
GPIO19_CTF_R: length 9.3
  TOP w0.102: R329.1 91.79,82.42 89.25,82.42 R1894.1 88.74,82.93 D7.3 ; R329.1 R80085.1 ; R329.1 92.49,83.12 v1(92.49,84.05) R1896.1
GPIO_8_ROMSO: length 6.4
  TOP w0.102: v4(80.68,94.36) 81.12,94.8 GPU1.P10
  BOTTOM w0.102: v4(80.68,94.36) 81.76,94.36 82.3,93.82 82.3,92.81 v2(83.4,91.72) 83.15,91.48 R1169.1
GPIO_9_ROMSI: length 11.5
  TOP w0.102: v3(86.65,85.98) 86.6,85.93 82.55,85.93 80.96,87.53 80.96,88.9 80.81,89.28 80.74,89.35 80.67,89.53 80.67,89.66 80.72,89.78 80.77,89.84 81,90.35 GPU1.P4
  BOTTOM w0.102: v2(87.56,84.71) 87.6,84.75 R1171.2 87.35,85.98 v3(86.65,85.98)
GPIO_10_ROMSCK: length 9.1
  TOP w0.102: GPU1.P2 81.16,89.44 81.16,88.11 v1(82.3,86.97) 83.14,86.13 86.04,86.13 v3(86.65,86.74)
  BOTTOM w0.102: R1170.2 v3(86.65,86.74)
GPIO_22_ROMCS#: length 5.8
  TOP w0.102: v4(80.68,93.47) 80.41,93.2 GPU1.N8
  BOTTOM w0.102: R1168.1 82.74,89.9 82.74,91.28 82.32,91.69 82.26,91.69 v2(81.83,92.12) 81.19,92.77 81.19,92.96 v4(80.68,93.47)
GPIO_SVC: length 10.9
  TOP w0.102: TP165.1 99.19,90.02 96.97,90.02 94.78,92.21 94.78,94.33 93.95,95.16 93.04,95.16 GPU1.AJ11
GPIO_SVD: length 9.1
  TOP w0.102: TP163.1 97.82,91.19 96.55,91.19 95.28,92.46 95.28,94.47 93.76,95.99 93.41,95.99 GPU1.AK12
GPIO_SVT: length 7.1
  TOP w0.102: GPU1.AL11 93.83,95.6 95.03,94.4 95.03,92.24 96.72,90.55 TP164.1
GPIO_VGA_03_DATA: length 8.9
  TOP w0.102: R1165.1 99.22,89.26 RN16.1 99.78,89.1 99.98,88.9 99.98,88.27 100.87,87.38 v3(101,87.38) 101,85.6 100.09,84.69 Q123.4
  BOTTOM w0.102: v2(101,88.19) v3(101,87.38)
GPIO_VGA_03_DATA_R: length 17.3
  TOP w0.102: GPU1.U8 83.93,93.2 84.26,92.87 85,92.87 86.14,91.73 86.14,91.59 86.46,91.27 87,91.27 87.79,90.48 87.79,89.94 88.2,89.53 88.43,89.53 89.23,88.73 93.1,88.73 93.38,88.44 95.59,88.44 96.17,89.03 v3(96.17,89.41) 96.32,89.26 R1165.2
  BOTTOM w0.102: v3(96.17,89.41) 96.68,89.92 v2(96.81,89.92)
GPIO_VGA_04_CLK: length 5.2
  TOP w0.102: Q123.1 97.39,86.92 97.85,87.38 v1(98.71,87.38) 97.91,88.18 R1166.1 98.11,88.45 RN16.2
GPIO_VGA_04_CLK_R: length 16.6
  TOP w0.102: R1166.2 97.02,88.05 v1(96.09,87.12) 95.07,88.14 92.66,88.14 92.28,88.52 88.01,88.52 87.03,89.51 87.03,90.04 86.6,90.47 86.46,90.47 85.38,91.56 85.38,91.69 85,92.07 84.32,92.07 83.99,92.4 GPU1.U7
GPP_B2/VRALERT#: length 4.1
  TOP w0.102: v4(87.57,150.52) 87.57,150.66 87.92,151 CPU1.AM11
  BOTTOM w0.089: v4(87.57,150.52) 87.57,150.63 86.95,151.26 86.95,152.48 86.88,152.55
  BOTTOM w0.102: TP1708.1 86.14,153.29 86.88,152.55
GPP_B18/GSPI0_MOSI: length 23.7
  TOP w0.127: v4(89.57,148.72) 89.9,148.4 CPU1.AR7
  BOTTOM w0.127: R2007.2 v2(98.44,141.69) 95.41,144.72 95.41,145.72 93.63,147.5 93.63,147.55 92.87,148.31 91.07,148.31 91.05,148.3 89.99,148.3 v4(89.57,148.72)
GPP_B22/GSPI1_MOSI: length 11.6
  TOP w0.089: CPU1.AN5 89.5,146.44 89.5,144.29
  TOP w0.127: v1(88.53,137.69) 88.34,137.88 R2012.2 88.81,139.18 88.81,140.3 90.46,141.95 90.46,143.01 90.52,143.07 90.52,143.1 90.55,143.12 90.55,143.51 90.29,143.77 90.02,143.77 89.5,144.29
GPP_B23/SML1ALERT#: length 24.5
  TOP w0.102: v4(87.54,147.79) 87.95,148.19 CPU1.AM7
  BOTTOM w0.102: R1833.1 91.28,128.71 89.49,130.51 89.49,134.04 88.6,134.93 88.6,137.79 89.9,139.08 89.9,141.58 v2(90.29,141.97) 90.53,142.21 90.53,144.44 89.94,145.03 88.93,145.03 87.66,146.3 87.66,147.67 v4(87.54,147.79)
GPP_C2/SMBALERT#: length 11
  TOP w0.102: CPU1.R10 79.97,150.32 v4(80.21,150.32)
  BOTTOM w0.102: v4(80.21,150.32) 80.62,149.92 80.62,147.46 80.03,146.87 80.03,144.39 79.54,143.89 v2(79.54,142.34) R1832.1
GPP_C5/SML0ALERT#: length 6.5
  TOP w0.102: CPU1.W1 81.83,143.9 v4(81.69,143.76)
  BOTTOM w0.102: R1823.1 82.52,138.81 R1822.2 82.63,140.7 v2(82.63,141.76) 82.63,142.82 v4(81.69,143.76)
GPU_CLKA0_T: length 4.4
  TOP w0.102: R80089.2 R1906.2 47.57,110.59 v1(47,110.59) 46.87,110.72 46.87,111.93 C1855.2
GPU_CLKA1_T: length 3.5
  TOP w0.102: R1909.2 R80090.2 48.01,93.09 v1(47.51,93.6) 48.23,94.32 C207.2
GPU_DMINUS: length 127.4
  TOP w0.127: GPU1.T2 82.71,89.49 82.71,89.05 83.24,88.52 85.78,88.52 86.45,87.85 89.8,87.85 90.84,86.8 90.84,86.3 RT2.2 90.65,85.98 91.28,85.34 v3(91.28,85.22)
  L4 w0.127: v3(91.28,85.22) 91.28,85.13 91.05,84.9 88.43,84.9 87.45,83.92 87.45,81.39 89.46,79.38 95.17,79.38 99.6,74.94 99.6,71.57 103.84,67.32 126.65,67.32 129.08,69.75 129.47,70.14 137.98,70.14 138.18,70.35 150.67,70.35 v3(150.91,70.1)
  BOTTOM w0.127: R651.2 140.05,44.83 C524.2 140.43,45.21 140.88,45.21 141.26,44.83 148.12,44.83 150.5,47.22 150.5,66.01 ; 150.5,66.01 150.5,69.7 v3(150.91,70.1) ; 150.5,66.01 v2(150.83,66.01)
GPU_DPLUS: length 134.6
  TOP w0.127: v3(137.83,46.74) 138.61,47.52 U109.85 ; v3(91.35,84.45) 91.85,84.96 91.85,85.72 91.6,85.98 RT2.1 91.09,86.3 91.09,86.91 89.9,88.1 86.56,88.1 85.89,88.77 83.34,88.77 82.96,89.15 82.96,90.04 GPU1.T4
  L4 w0.127: v3(150.91,70.87) 150.64,70.6 138.08,70.6 137.88,70.4 129.37,70.4 128.83,69.85 126.55,67.58 103.95,67.58 99.85,71.67 99.85,75.05 95.27,79.63 89.57,79.63 87.7,81.5 87.7,83.81 88.54,84.65 91.05,84.65 91.24,84.45 v3(91.35,84.45)
  BOTTOM w0.127: v3(150.91,70.87) 150.25,70.21 150.25,68.5 ; 150.25,68.5 150.25,47.32 148.01,45.09 141.36,45.09 140.98,45.47 140.43,45.47 C524.1 140.05,45.85 R658.1 139.16,45.66 138.84,45.34 137.83,45.34 137.57,45.59 137.57,46.48 v3(137.83,46.74) ; 150.25,68.5 v2(149.92,68.5)
GPU_GPIO16: length 5.5
  TOP w0.102: GPU1.M4 79.4,90.1 79.73,89.77 79.73,87.79 81.29,86.23 TP155.1
GPU_SCL: length 3.3
  TOP w0.102: TP149.1 83.83,86.89 81.8,88.92 GPU1.R1
GPU_SDA: length 5.2
  TOP w0.102: TP150.1 84.46,87.66 83.45,87.66 82.2,88.9 82.2,89.6 GPU1.R3
GPU_THERM_SHUTDOWN*: length 94.1
  TOP w0.102: PC12.1 135.29,102.87 v3(134.65,102.23) 134.47,102.23 133.56,101.33 U9.38
  L4 w0.127: v3(134.65,102.23) 136.69,100.2 137.35,100.2 139.52,98.04 139.52,77.9 134.16,72.54 128.53,72.54 125.66,69.67 108.31,69.67 108.18,69.54 103.82,69.54 101.25,72.11 101.25,75.48 95.8,80.94 94.86,80.94 v3(94.01,81.79)
  BOTTOM w0.102: v3(94.01,81.79) 94.01,83.54 v2(94.37,83.9) 94.58,84.11 R354.1 ; PR8517.2 134.15,104.71 134.15,102.74 v3(134.65,102.23) 135.16,102.74 PR19.2
GPU_THERMAL_INT: length 69.4
  TOP w0.102: v3(90.71,81.79) 91.17,81.33 94.96,81.33 96.1,82.46 96.1,84.47 R1885.2 94.65,84.14 R1884.1 ; U109.28 132.21,65.81 v3(132.32,65.91)
  L4 w0.127: v3(133.64,71.5) 128.68,71.5 125.78,68.59 104.37,68.59 100.87,72.09 100.87,75.47 95.68,80.66 91.84,80.66 v3(90.71,81.79)
  BOTTOM w0.102: v3(132.32,65.91) 132.32,70.18 v2(132.88,70.75) v3(133.64,71.5)
GPU_VCC3_CTL: length 10.2
  TOP w0.102: v3(167.42,90.93) 167.8,91.31 R80092.1 165.07,91.76 164.53,91.22 Q76.G 164.53,90.7 165.06,90.17 165.06,89.56 v1(165.03,89.53) 164.02,89.53 163.23,90.32 C1864.2
  BOTTOM w0.102: v3(167.42,90.93) 167.67,90.68 D5206.A
GPU_VCC3_CTL_2: length 6.6
  TOP w0.102: v1(157.59,91.06) 158.88,91.06 Q77.G 159.9,92.08 161.7,92.08 162.15,91.63 C836.1 162.34,92.77 R1195.2
GPU_VCC3_CTL_3: length 6.6
  TOP w0.102: v1(162.57,93.9) 163.16,93.31 R1195.1 165.45,92.84 Q76.D 166.47,93.73 R80091.1
GPU_VREFG: length 7.3
  TOP w0.254: v4(88.77,98.76) 88.77,98.83 GPU1.AC16
  BOTTOM w0.508: v4(88.77,98.76) 88.88,98.86 89.02,98.86 89.32,99.16 89.82,99.16 89.87,99.11 89.89,99.11 90.42,98.58 91.25,98.58 v2(91.42,98.42) C1846.1 R1210.2 R1211.1
GPU_WAKEB: length 6
  TOP w0.102: R1883.2 96.68,105.16 v1(96.17,105.66) 94.6,107.24 94.6,107.27 93.82,108.04 92.96,108.04 92.82,108.18 GPU1.AJ27
GPU_XO_IN: length 10.2
  TOP w0.102: R1880.1 96.5,103.12 v1(96.19,102.81) 95.98,102.81 94.06,104.73 91.26,104.73 91.06,104.53 88.86,104.53 88.53,104.2 GPU1.AC22
GPU_XO_IN2: length 11
  TOP w0.102: R1881.1 97.24,104.13 v1(96.15,104.13) 95.67,104.13 94.27,105.53 91.26,105.53 91.07,105.34 91.07,105.2 90.74,104.87 88.01,104.87 87.54,104.4 GPU1.AB22
H_CPUPWRGD: length 6.9
  TOP w0.102: R80042.1 v1(71.79,188.47) 70.52,187.2 70.52,185.15 71.19,184.48 71.19,184 71.64,183.55 CPU1.A68
H_PROCHOT_N: length 489.3
  TOP w0.102: v3(35.97,137.92) 37.5,136.4 37.5,135.25 38.13,134.62 v3(38.13,133.1) ; R80166.1 148.81,71.06 149.83,72.07 Q9641.D 152.24,72.07 v3(152.94,71.37) ; v3(66.58,187.83) 66.77,188.02 R401.2 R403.1 ; PR4664.2 v3(24.67,193.8)
  L3 w0.127: v3(24.67,58.8) 29.5,58.8 29.79,59.09 29.79,128.69 34.7,133.6 37.63,133.6 v3(38.13,133.1) ; v3(38.01,172.72) 36.86,172.72 35.97,171.83 32.16,171.83 26.07,165.74 26.07,161.04 23.02,157.99 23.02,144.78 25.81,141.99 37.51,141.99 37.88,141.61 37.88,139.83 v3(35.97,137.92)
  L4 w0.127: v3(164.24,205.23) 163.94,204.93 108.11,204.93 107.63,204.44 88.52,204.44 84.73,200.66 83.83,200.66 81.2,198.03 79.59,198.03 70.91,189.36 70.24,189.36 68.71,187.83 v3(66.58,187.83) 65.34,187.83 62.14,184.63 62.14,184.21 62.14,182.49 58.97,179.32 56.42,179.32 54.81,177.71 52.02,177.71 46.77,172.47 38.26,172.47 v3(38.01,172.72) 37.75,172.47 26.62,172.47 20.7,178.39 20.7,179.73 20.7,180.63 19.97,181.36 19.97,185.23 20.8,186.06 23.44,186.06 26.2,188.81 26.2,189.99 24.67,191.52 v3(24.67,193.8)
  BOTTOM w0.102: PR4455.1 v3(24.67,58.8) ; v3(164.24,205.23) 164.24,204.37 v2(164.27,204.34) 164.24,204.32 164.24,201.03 165.18,200.09 165.18,150.76 162.52,148.09 162.52,121.17 160.63,119.28 158.48,119.28 157.18,117.98 151.19,117.98 148.2,115 148.2,103.8 152.28,99.72 152.28,91.39 150.96,90.07 150.96,73.36 v3(152.94,71.37) ; PR4663.1 v3(24.67,193.8)
H_RCIN#: length 150.6
  TOP w0.102: CPU1.AW13 91.81,152 v4(91.76,152.06)
  L3 w0.127: v3(147.48,100.46) 147.23,100.2 147.21,100.2 145.07,98.06 145.07,89.44 143.54,87.91 143.54,80.15 142.02,78.63 142.02,70.2 139.25,67.44 139.07,67.44 137.7,66.07 137.7,64.64 131.99,58.93 v3(131.99,57.66)
  L4 w0.127: v3(107.79,140.97) 107.39,140.56 107.39,140.01 107.7,139.7 108.36,139.7 130.18,117.88 135.69,117.88 139.1,121.28 146.85,121.28 v3(149.39,118.75)
  BOTTOM w0.102: v3(149.39,118.75) v2(148.12,117.48) 146.57,115.93 146.57,102.9 147.48,101.98 v3(147.48,100.46) ; v3(107.79,140.97) 107.41,140.97 R2021.2 101.68,141.54 97.7,145.53 97.7,146.36 92,152.06 v4(91.76,152.06) ; v3(131.99,57.66) 131.99,58.05 130.49,59.54 130.11,59.54 129.7,59.94 129.01,59.94 128.62,60.34 R80130.1
H_VID0: length 92.7
  TOP w0.102: PR40.1 134.91,95.63 v3(134.65,95.89) 134.25,95.89 v1(133.76,96.37) 133.71,96.37 132.63,97.45 U9.31 ; GPU1.T8 82.81,93.2 v4(83.18,92.83)
  L3 w0.127: v3(95.54,84.2) 95.07,83.73 91.41,83.73 83.18,91.95 v4(83.18,92.83)
  L4 w0.127: v3(134.65,95.89) 134.65,95.43 137.79,92.29 137.79,78.61 133.47,74.3 127.67,74.3 124.77,71.4 107.96,71.4 95.54,83.82 v3(95.54,84.2)
  BOTTOM w0.102: v3(134.65,95.89) 134.91,95.63 PR40.1
H_VID1: length 95.9
  TOP w0.102: GPU1.N1 80.2,87.71 82.39,85.52 83.02,85.52 83.88,84.66 86.06,84.66 86.52,84.2 v3(88.76,84.2) ; PR5479.1 v3(134.65,96.65) 133.59,97.71 133.59,98.48 133.13,98.93 U9.32
  L4 w0.127: v3(88.76,84.2) 89.77,83.19 95.38,83.19 105.44,73.12 105.44,72.46 107.07,70.84 107.48,70.84 107.6,70.97 124.95,70.97 127.82,73.84 133.63,73.84 138.22,78.43 138.22,92.54 135.16,95.6 135.16,96.14 v3(134.65,96.65)
  BOTTOM w0.102: v2(133.84,96.06) 134.42,96.65 v3(134.65,96.65) PR5479.1
H_VID2: length 97.7
  TOP w0.102: GPU1.P8 81.33,93.2 v4(81.69,92.84) ; U9.33 133.37,99.33 134.02,98.68 134.02,98.3 v3(134.65,97.66) PR5490.1
  L3 w0.127: v4(81.69,92.84) 82.2,92.33 82.2,92.2 90.08,84.33 90.08,84.13 91.91,82.3 92.74,82.3 v3(93.25,81.79)
  L4 w0.127: v3(93.25,81.79) 93.72,82.26 95.7,82.26 104.94,73.02 104.94,72.36 106.89,70.41 107.73,70.41 107.86,70.54 125.15,70.54 128.02,73.41 133.8,73.41 138.65,78.25 138.65,92.72 135.69,95.68 135.69,96.62 v3(134.65,97.66)
  BOTTOM w0.102: PR5490.1 v3(134.65,97.66) 134.25,97.66 v2(133.86,98.05)
H_VID3: length 88.1
  TOP w0.102: v4(94.39,89.92) 94.38,89.92 94.16,90.14 94.16,93.31 93.92,93.55 93.38,93.55 93,93.93 GPU1.AK10 ; PR33.1 v3(134.65,98.68) 133.6,99.73 U9.34
  L4 w0.127: v4(94.39,89.92) 94.39,86.41 106.33,74.47 106.33,73.79 108.29,71.83 124.55,71.83 127.52,74.8 133.37,74.8 137.36,78.79 137.36,92.09 134.18,95.26 134.18,98.21 v3(134.65,98.68)
  BOTTOM w0.102: v2(94.61,90.85) 94.61,90.13 v4(94.39,89.92) ; PR33.1 v3(134.65,98.68)
H_VID4: length 87.3
  TOP w0.102: U9.35 133.71,100.13 133.89,99.95 134.4,99.95 v3(134.65,99.69) PR31.1 ; GPU1.AM10 94.55,94.05 94.55,91.95 95.46,91.04 95.46,88.95 v3(95.41,88.9)
  L4 w0.127: v3(134.65,99.69) 133.59,98.63 133.59,97.08 133.75,96.91 133.75,95.08 136.93,91.91 136.93,78.97 133.27,75.31 127.41,75.31 124.37,72.26 108.47,72.26 106.84,73.89 106.84,74.57 97.28,84.13 97.28,84.4 95.41,86.26 v3(95.41,88.9)
  BOTTOM w0.102: v3(95.41,88.9) 95.28,88.77 v2(95.28,88.01) ; PR31.1 v3(134.65,99.69)
H_VID5: length 100.8
  TOP w0.102: PR26.1 134.78,100.71 v3(134.65,100.58) 134.6,100.53 U9.36 ; v4(83.11,93.58) 82.69,94 GPU1.T9
  L3 w0.127: v4(83.11,93.58) 82.74,93.2 82.74,92.07 91.88,82.93 93.63,82.93 v3(94.78,81.79)
  L4 w0.127: v3(134.65,100.58) 136.18,99.06 136.18,95.83 139.09,92.93 139.09,78.08 133.98,72.97 128.23,72.97 125.36,70.1 108.11,70.1 107.98,69.98 107.91,69.98 107.91,69.97 106.71,69.97 104.43,72.26 104.43,72.92 95.56,81.79 v3(94.78,81.79)
  BOTTOM w0.102: PR26.1 134.78,100.71 v3(134.65,100.58) ; v3(94.78,81.79) 94.91,81.79 v2(95.44,82.32)
H_VID6: length 5.3
  TOP w0.102: PR5478.1 134.93,101.73 v3(134.65,101.45) 134.17,100.97 133.76,100.97 133.73,100.93 U9.37
  BOTTOM w0.102: PR5478.1 134.93,101.73 v3(134.65,101.45) 134.3,101.45 v2(133.76,100.91)
HDA_BITCLK_CPU: length 13.8
  TOP w0.089: CPU1.AY22 93.28,157.11 93.81,157.11 93.99,156.94 93.99,156.76 94.3,156.45 94.69,156.45 95.1,156.04 95.3,156.04
  TOP w0.102: R1907.2 99.78,159.63 v1(99.78,158.67) 99.78,156.87 98.94,156.04 95.3,156.04
HDA_RST#_CPU: length 12.8
  TOP w0.089: 95.13,155.64 94.99,155.64 94.54,156.09 94.11,156.09 93.62,156.58 93.51,156.58 93.48,156.61 93.19,156.61 93.17,156.59 92.86,156.59 92.6,156.85 CPU1.AW22
  TOP w0.102: R1911.2 100.82,158.64 v1(100.82,157.84) 100.82,157.27 99.2,155.64 95.13,155.64
HDA_SDOUT_CPU: length 68.3
  TOP w0.102: CPU1.BB22 94.52,156.64 94.77,156.64 95.16,156.25 98.87,156.25 99.15,156.53 99.15,159.44 101.63,161.93 101.63,162.5 R1912.2 R1910.2 102.08,164.15 102.31,164.38 104.31,164.38 104.41,164.27 104.41,162.24 115.27,151.38 115.27,130.68 114.43,129.84 114.43,125 v3(114.41,124.98)
  BOTTOM w0.102: v3(114.41,124.98) 113.71,124.98 v2(112.81,124.08) Q9644.C 109.13,122.75 R153.2
HDA_SPKR: length 109.8
  TOP w0.152: R208.1 154.85,89.41 151.32,92.94 151.32,101.37 152.53,102.59 152.53,107.85 149.26,111.13 149.26,115.7 v3(146.21,118.75) ; CPU1.AW5 91.98,147.22 v4(92.35,146.85)
  L4 w0.152: v3(107.86,132.46) 109,131.32 111.22,131.32 127.85,114.69 133.89,114.69 137.19,114.69 140.26,117.77 141.22,117.77 143.45,117.77 144.91,119.23 145.73,119.23 v3(146.21,118.75)
  BOTTOM w0.152: v4(92.35,146.85) 92.44,146.85 v2(93.55,145.74) 106.01,133.28 R2006.2 106.5,133.32 107.2,133.32 107.86,132.66 v3(107.86,132.46)
HDA_SYNC_CPU: length 12.2
  TOP w0.089: 95.35,155.83 95.05,155.83 94.61,156.27 94.18,156.27 93.66,156.78 CPU1.BA22
  TOP w0.102: 95.35,155.83 99.12,155.83 100.24,156.95 100.24,158.27 100.57,158.6 100.57,159.4 100.91,159.74 v1(100.92,159.74) 100.92,159.75 R1908.2
HDMI1_CK+: length 87.5
  TOP w0.089: TR5204.4 107.56,19.46 107.56,19.78 107.14,20.2 107.14,21.04 D5203.4 D5203.7 107.09,22.85 v3(107.35,23.11) 107.48,23.24 107.48,23.56 R5208.2 ; SCA1.9 68.99,59.9 67.62,59.9 v3(67.47,60.06)
  L3 w0.102: v3(67.47,60.06) 67.47,59.89 67.6,59.77 67.8,59.77 67.93,59.89 67.93,60.36 68.05,60.49 69.48,60.49 69.77,60.78 69.77,62.84 69.9,62.97 70.14,62.97 70.28,62.82 70.28,60.78 70.58,60.49 71.37,60.49 72.62,59.24 73.04,59.24 73.62,59.81 73.8,59.81 73.98,59.64 73.98,59.46 72.19,57.67 72.19,57.26 72.61,56.84 73.02,56.84 75.2,59.02 75.38,59.02 75.53,58.86 75.53,58.64 74.59,57.69 74.59,56.97 75.85,55.7 75.85,51.35 78.94,48.26 87.96,48.26 93.94,42.28 93.94,30.47 98.83,25.58 106.41,25.58 107.53,24.46 107.53,23.29 v3(107.35,23.11)
  BOTTOM w0.089: v2(107.58,23.93) 107.35,23.7 v3(107.35,23.11)
HDMI1_CK+_C: length 16.5
  TOP w0.089: TR5204.3 106.89,17.55 106.89,16.93 107.21,16.61 109.13,16.61 110.33,17.82 112.35,17.82 115.52,14.65 115.84,14.65 116.17,14.32 HDMI2.10 118.43,14.32 v3(118.91,13.84)
  BOTTOM w0.089: v3(118.91,13.84) 118.52,13.84 v2(118.17,13.49)
HDMI1_CK-: length 87.4
  TOP w0.089: SCA1.10 67.89,60.4 v3(67.47,60.82) ; R5207.2 107.86,23.69 107.86,23.37 v3(108.11,23.11) 107.59,22.59 D5203.6 D5203.5 107.48,20.99 107.48,20.34 107.9,19.92 107.9,19.46 TR5204.1
  L3 w0.102: v3(67.47,60.82) 69.34,60.82 69.44,60.92 69.44,62.98 69.76,63.3 70.27,63.3 70.61,62.96 70.61,60.92 70.71,60.82 71.51,60.82 72.76,59.57 72.9,59.57 73.48,60.15 73.93,60.15 74.31,59.77 74.31,59.32 72.52,57.53 72.52,57.4 72.75,57.17 72.88,57.17 75.06,59.35 75.51,59.35 75.86,59 75.86,58.5 74.92,57.55 74.92,57.11 76.18,55.84 76.18,51.49 79.08,48.59 88.09,48.59 94.27,42.42 94.27,30.61 98.97,25.91 106.55,25.91 107.86,24.6 107.86,23.37 v3(108.11,23.11)
  BOTTOM w0.089: v2(108.92,23.11) v3(108.11,23.11)
HDMI1_CK-_C: length 14.8
  TOP w0.089: TR5204.2 108.07,17.54 108.01,17.48 107.35,17.48 107.23,17.36 107.23,17.07 107.35,16.95 108.98,16.95 110.19,18.16 112.49,18.16 114.65,16 v3(114.84,16) 114.84,15.81 115.66,14.99 115.84,14.99 116.17,15.32 HDMI2.12
  BOTTOM w0.089: v2(114.59,16.79) 114.59,16.26 v3(114.84,16)
HDMI1_CTRL_CLK_CPU: length 202.2
  TOP w0.102: v3(145.7,35.81) 145.52,35.64 145.52,34.62 143.67,32.77 143.66,32.77 143.31,32.41 142.45,32.41 139.5,29.46 R80194.2 135.35,29.97 134.4,29.97 134.07,30.3 134.07,31.53 133.75,31.85 U118.38 ; v4(78.12,151.63) 77.79,151.97 CPU1.L13
  L4 w0.089: 78.73,148.8 78.72,148.82 78.72,151.03 v4(78.12,151.63)
  L4 w0.127: v3(152.05,105.92) 147.73,110.24 147.23,110.24 145.7,111.76 122.72,111.76 121.95,112.52 121.95,114.16 112.39,123.72 87.77,123.72 86.82,124.67 86.27,124.67 77.92,133.01 77.92,134.87 76.68,136.12 76.68,145.5 78.63,147.46 78.63,148.46 78.73,148.56 78.73,148.8
  BOTTOM w0.102: v3(152.05,105.92) v2(153.39,104.58) 153.63,104.34 153.63,101.06 154.11,100.57 154.11,87.5 153.27,86.66 153.27,72.95 155.03,71.19 155.03,49.19 154.22,48.39 154.22,48.02 150.91,44.7 150.91,39.19 147.81,36.09 145.98,36.09 v3(145.7,35.81)
HDMI1_CTRL_DATA_CPU: length 202.4
  TOP w0.102: CPU1.L12 77.8,151.32 v4(78.13,150.98) ; v3(144.94,35.81) 145.17,35.59 145.17,34.77 143.16,32.77 142.3,32.77 140.14,30.61 R80257.2 138.02,29.97 136.88,29.97 R80195.2 135.3,30.43 134.58,30.43 134.44,30.57 134.44,31.66 134.15,31.95 U118.39
  L4 w0.089: 78.28,148.48 78.54,148.73 78.54,150.58 v4(78.13,150.98)
  L4 w0.127: 78.28,148.48 77.63,147.83 77.63,146.76 76.3,145.43 76.3,136.28 76.3,135.96 77.54,134.72 77.54,132.85 86.11,124.28 86.65,124.28 87.93,123.01 112.57,123.01 121.57,114 121.57,111.12 122.84,109.86 147.35,109.86 v3(152.05,105.16)
  BOTTOM w0.102: v3(144.94,35.81) 145.58,36.45 147.66,36.45 150.53,39.31 150.53,44.83 153.83,48.13 153.83,48.64 154.67,49.48 154.67,71.04 151.87,73.84 151.87,86.51 v2(152.37,87.01) 153.75,88.39 153.75,100.42 153.27,100.91 153.27,103.94 v3(152.05,105.16)
HDMI1_D0+: length 84.6
  TOP w0.089: TR5202.4 105.4,19.46 105.4,20.22 105.68,20.51 105.68,20.99 D5203.1 D5203.10 105.59,22.59 v3(105.06,23.11) 105.37,23.43 105.37,23.63 R5204.2 ; v3(70.52,57.25) 70.16,57.25 70.01,57.4 SCA1.4
  L3 w0.102: v3(105.06,23.11) 105.06,22.83 105.24,22.66 105.72,22.66 105.85,22.53 105.85,22.02 105.6,21.77 104.49,21.77 102.77,23.48 102.77,23.63 103.48,24.33 103.48,24.78 103.17,25.1 102.59,25.1 101.95,24.45 101.8,24.45 101.36,24.89 98.67,24.89 98.14,25.42 97.61,25.95 93.45,30.11 93.45,37.99 93.16,38.29 92.4,38.29 92.26,38.42 92.26,38.67 92.39,38.8 93.16,38.8 93.45,39.09 93.45,39.67 93.16,39.97 91.04,39.97 90.91,40.09 90.91,40.35 91.04,40.47 93.16,40.47 93.45,40.77 93.45,42.08 87.76,47.78 78.74,47.78 77.84,48.68 77.42,48.68 76.51,47.78 76.28,47.78 76.13,47.93 76.13,48.11 77.06,49.04 77.06,49.46 75.37,51.15 75.37,51.16 75.29,51.23 75.29,53.89 74.51,54.67 74.51,55.22 74.06,55.67 72.68,55.67 71.28,54.26 71.1,54.26 70.92,54.44 70.92,54.62 72.32,56.03 72.32,56.45 71.74,57.03 70.73,57.03 v3(70.52,57.25)
  BOTTOM w0.089: v2(104.86,23.9) 104.86,23.32 v3(105.06,23.11)
HDMI1_D0+_C: length 17.6
  TOP w0.089: TR5202.3 105.23,17.84 104.78,17.39 104.78,16.51 105.49,15.8 109.53,15.8 110.62,16.89 111.89,16.89 113.13,15.66 113.13,14.62 114.92,12.82 v3(115.12,12.82) HDMI4.13
  BOTTOM w0.089: v3(115.12,12.82) 115.12,12.19 v2(115.3,12.01)
HDMI1_D0-: length 84.6
  TOP w0.089: TR5202.1 105.74,19.46 105.74,20.08 106.03,20.37 106.03,21.04 D5203.2 D5203.9 106.09,22.85 v3(105.82,23.11) 105.72,23.22 105.72,23.58 R5206.2 ; SCA1.3 70.1,56.9 v3(70.52,56.48)
  L3 w0.102: v3(70.52,56.48) 70.73,56.7 71.6,56.7 71.99,56.31 71.99,56.17 70.59,54.76 70.59,54.3 70.96,53.93 71.41,53.93 71.5,54.02 72.82,55.34 73.92,55.34 74.18,55.08 74.18,54.54 74.96,53.75 74.96,51.09 75.04,51.02 75.04,51.01 76.73,49.32 76.73,49.18 75.8,48.25 75.8,47.8 76.15,47.45 76.65,47.45 77.55,48.35 77.7,48.35 77.92,48.13 78.33,47.72 78.6,47.45 87.62,47.45 93.12,41.94 93.12,40.91 93.02,40.8 90.9,40.8 90.58,40.48 90.58,39.96 90.9,39.64 93.02,39.64 93.12,39.53 93.12,39.23 93.02,39.13 92.25,39.13 91.93,38.81 91.93,38.29 92.26,37.96 93.02,37.96 93.12,37.86 93.12,29.97 97.38,25.72 98.53,24.56 101.23,24.56 101.67,24.12 102.08,24.12 102.73,24.77 103.03,24.77 103.15,24.65 103.15,24.47 102.44,23.76 102.44,23.35 104.35,21.44 105.73,21.44 106.18,21.88 106.18,22.76 v3(105.82,23.11)
  BOTTOM w0.089: v3(105.82,23.11) 105.82,23.5 v2(106.21,23.88)
HDMI1_D0-_C: length 17.5
  TOP w0.089: HDMI4.11 115.91,13.82 v3(115.55,13.46) 114.76,13.46 113.47,14.76 113.47,15.8 112.03,17.23 110.48,17.23 109.39,16.14 105.64,16.14 105.13,16.65 105.13,17.25 105.25,17.37 105.78,17.37 105.91,17.5 TR5202.2
  BOTTOM w0.089: v2(116.37,13.46) v3(115.55,13.46)
HDMI1_D1+: length 86.4
  TOP w0.089: R5203.2 107.22,13.59 v3(107.48,13.34) 107.21,13.07 D5204.2 D5204.9 107.29,11.23 107.29,10.55 107.56,10.29 107.56,9.91 107.39,9.74 TR5203.4 ; SCA1.6 70.15,58.4 v3(70.52,58.77)
  L3 w0.102: v3(107.48,13.34) 107.48,14.38 106.51,15.34 106.51,18.12 104.19,20.44 100.95,23.67 98.09,23.67 92.16,29.6 92.16,36.91 89.77,39.3 89.77,41.67 90.07,41.96 91.3,41.96 91.42,42.09 91.42,42.34 91.3,42.47 90.07,42.47 89.77,42.77 89.77,43.66 86.8,46.63 74.04,46.63 73.74,46.93 73.74,48.13 73.62,48.26 73.36,48.26 73.24,48.13 73.24,46.93 72.94,46.63 72.18,46.63 69.17,49.65 69.17,58.84 69.49,59.16 70.13,59.16 v3(70.52,58.77)
  BOTTOM w0.089: v3(107.48,13.34) 107.35,13.46 v2(107.35,14.15)
HDMI1_D1+_C: length 16.1
  TOP w0.089: TR5203.3 106.76,7.64 106.76,7.11 107.42,6.45 v3(107.65,6.45) 107.9,6.45 109.25,7.8 109.25,9.1 110.36,10.2 111.65,10.2 113.1,11.65 115.86,11.65 116.19,11.32 HDMI2.4
  BOTTOM w0.089: v3(107.65,6.45) v2(107.65,7.26)
HDMI1_D1-: length 86.5
  TOP w0.089: SCA1.5 70,57.9 70.11,58.01 v3(70.52,58.01) ; R5205.2 v3(108.24,13.34) 107.71,12.81 D5204.1 D5204.10 107.63,11.23 107.63,10.69 107.9,10.43 107.9,9.91 108.07,9.74 TR5203.1
  L3 w0.102: v3(70.52,58.01) 70.29,58.01 70.06,58.24 70.06,58.7 69.93,58.83 69.63,58.83 69.5,58.7 69.5,49.78 72.32,46.96 72.8,46.96 72.91,47.07 72.91,48.27 73.23,48.59 73.75,48.59 74.07,48.27 74.07,47.07 74.18,46.96 86.93,46.96 90.1,43.8 90.1,42.9 90.2,42.8 91.43,42.8 91.75,42.48 91.75,41.95 91.43,41.63 90.2,41.63 90.1,41.53 90.1,39.43 92.49,37.05 92.49,29.74 98.22,24 101.09,24 106.84,18.25 106.84,15.48 107.81,14.52 107.81,13.77 v3(108.24,13.34)
  BOTTOM w0.089: v3(108.24,13.34) 108.24,12.85 107.91,12.52 v2(107.88,12.52)
HDMI1_D1-_C: length 17.7
  TOP w0.089: TR5203.2 108.07,7.8 107.94,7.67 107.31,7.67 107.11,7.47 107.11,7.25 107.44,6.92 107.89,6.92 108.91,7.95 108.91,9.24 110.21,10.54 111.51,10.54 112.95,11.99 115.73,11.99 116.06,12.32 HDMI2.6 118.9,12.32 v3(118.93,12.29)
  BOTTOM w0.089: v2(118.17,11.91) 118.55,11.91 v3(118.93,12.29)
HDMI1_D2+: length 84.3
  TOP w0.089: TR5201.4 105.4,9.68 105.4,10.19 105.82,10.61 105.82,11.21 D5204.6 D5204.5 105.71,12.81 v3(105.19,13.34) 105.42,13.56 105.42,13.93 R5201.2 ; v3(67.47,59.29) 67.58,59.4 SCA1.8
  L3 w0.102: v3(105.19,13.34) 105.62,12.9 105.62,12.65 105.52,12.55 104.27,12.55 104.08,12.75 103.87,12.95 103.87,13.58 105.24,14.95 105.24,18.7 105.08,18.87 100.75,23.19 97.71,23.19 91.54,29.36 91.54,36.85 89.29,39.1 89.29,43.46 86.6,46.15 71.98,46.15 68.69,49.45 68.69,50.38 68.18,50.89 68.18,55.08 68.69,55.59 68.69,58.54 68.37,58.86 67.79,58.86 67.47,59.18 v3(67.47,59.29)
  BOTTOM w0.089: v3(105.19,13.34) 105.06,13.46 v2(105.06,14.15)
HDMI1_D2+_C: length 18.7
  TOP w0.089: HDMI4.19 116.2,9.82 115.86,10.16 112.76,10.16 111.99,9.39 110.69,9.39 110.07,8.76 110.07,6.93 108.46,5.32 105.76,5.32 v3(104.63,6.45) 104.63,7.67 TR5201.3
  BOTTOM w0.089: v3(104.63,6.45) v2(103.82,6.45)
HDMI1_D2-: length 84.4
  TOP w0.089: TR5201.1 105.74,9.69 105.74,10.05 106.16,10.47 106.16,11.26 D5204.7 D5204.4 106.21,13.07 v3(105.95,13.34) 106.21,13.59 R5202.2 ; v3(67.47,58.53) 67.84,58.9 SCA1.7
  L3 w0.102: v3(67.47,58.53) 68.23,58.53 68.36,58.4 68.36,55.73 67.85,55.22 67.85,50.75 68.36,50.24 68.36,49.31 71.85,45.82 86.46,45.82 88.96,43.32 88.96,38.96 91.21,36.71 91.21,29.22 97.57,22.86 100.62,22.86 104.91,18.57 104.91,15.09 103.54,13.72 103.54,12.82 103.84,12.51 104.14,12.22 105.66,12.22 105.95,12.51 v3(105.95,13.34)
  BOTTOM w0.089: v3(105.95,13.34) 105.95,12.8 105.67,12.52 v2(105.65,12.52)
HDMI1_D2-_C: length 18.5
  TOP w0.089: TR5201.2 105.91,7.74 105.74,7.57 105.09,7.57 104.97,7.45 104.97,6.77 105.29,6.45 v3(105.39,6.45) 106.18,5.66 108.31,5.66 109.72,7.07 109.72,8.9 110.55,9.73 111.84,9.73 112.62,10.5 115.88,10.5 116.2,10.82 HDMI4.17
  BOTTOM w0.089: v3(105.39,6.45) v2(106.21,6.45)
HDMI1_DATA_CPU_N0: length 289.9
  TOP w0.102: v4(74.13,175.23) 74.13,175.53 74.3,175.69 CPU1.E55 ; C12213.1 140.13,32.94 141.25,32.94 141.56,33.25 ; 141.56,33.25 v1(141.28,33.53) ; 141.56,33.25 143.19,34.87 143.36,34.87 v3(143.67,35.18)
  L3 w0.127: v3(143.67,35.18) 143.16,35.18 143.04,35.3 143.04,35.94 142.27,36.7 142.27,38.35 149.14,45.22 149.14,63.36 152.46,66.67 152.46,71.81 152.08,72.19 152.08,83.04 153.5,84.46 153.5,85.64 161.72,93.86 161.72,116.6 163.33,118.21 163.33,125.35 162.42,126.26 162.42,192.33 152.61,202.14 86.25,202.14 73.98,189.87 73.24,189.87 69.95,186.57 69.95,182.11 71.32,180.74 71.32,177.26 73.18,175.4 73.97,175.4 v4(74.13,175.23)
HDMI1_DATA_CPU_N1: length 278.6
  TOP w0.102: C12211.1 140.14,34.96 140.32,34.96 140.71,35.36 141.18,35.36 v3(141.38,35.56) ; CPU1.E58 74.41,177.39 v4(74.73,177.06)
  L3 w0.127: v4(74.73,177.06) 74.52,177.28 74.41,177.28 73.31,178.37 73.31,184.35 75.18,186.22 75.18,188.53 75.92,189.27 77.67,189.27 88.98,200.58 150.22,200.58 156.38,194.42 156.38,191.88 160.75,187.51 160.75,123.94 161.3,123.39 161.3,118.47 160.07,117.23 160.07,94.4 150.41,84.75 150.41,67.98 148.25,65.82 148.25,65.42 147.37,64.53 147.37,46.11 141.94,40.69 140.29,40.69 139.23,39.63 139.23,35.6 139.63,35.2 141.02,35.2 v3(141.38,35.56)
  BOTTOM w0.102: v2(142.04,36.2) 141.41,35.56 v3(141.38,35.56)
HDMI1_DATA_CPU_N2: length 293.9
  TOP w0.102: C12209.1 140.13,36.75 141.05,36.75 ; CPU1.F53 75.06,174.55 74.87,174.36 v4(74.76,174.36) ; 141.05,36.75 141.56,36.75 141.81,37 143.46,37 v3(143.67,37.21) ; 141.05,36.75 v1(141.05,37.16)
  L3 w0.127: v3(143.67,37.21) 143.42,36.96 143.16,36.96 143.05,37.07 143.05,38.01 150.41,45.38 150.41,63.51 153.73,66.83 153.73,71.87 152.85,72.74 152.85,80.83 154.27,82.25 154.27,85.32 163.37,94.42 163.37,117.11 164.12,117.86 164.12,125.65 163.22,126.56 163.22,192.67 152.97,202.91 90.38,202.91 89.55,203.75 86.41,203.75 81.11,198.45 80,198.45 72.04,190.5 72.04,189.76 68.96,186.68 68.96,179.54 69.42,179.08 70.08,179.08 70.44,178.72 70.44,176.99 72.9,174.54 74.58,174.54 v4(74.76,174.36)
HDMI1_DATA_CPU_N3: length 278.6
  TOP w0.102: v3(140.75,38.73) 140.62,38.86 C12215.1 ; v4(74.74,176.14) 75.06,176.46 CPU1.F56
  L3 w0.127: v4(74.74,176.14) 74.73,176.15 74.58,176.15 74.2,176.53 73.69,176.53 72.36,177.86 72.36,182.87 71.78,183.45 71.78,187.29 73.46,188.98 74.2,188.98 86.59,201.36 150.7,201.36 157.27,194.79 157.27,192.13 161.64,187.77 161.64,125.94 162.36,125.21 162.36,118.39 160.84,116.87 160.84,94.08 151.3,84.54 151.3,71.87 151.68,71.48 151.68,68.14 149.03,65.48 149.03,65.1 148.25,64.33 148.25,45.86 141.75,39.36 140.48,39.36 140.13,39.01 140.13,38.62 140.24,38.51 140.52,38.51 v3(140.75,38.73)
  BOTTOM w0.102: v2(140.56,39.53) 140.56,38.93 v3(140.75,38.73)
HDMI1_DATA_CPU_P0: length 289.9
  TOP w0.102: v3(143.67,34.42) 143.43,34.66 143.28,34.66 142.69,34.07 ; 142.69,34.07 141.34,32.72 140.13,32.72 C12212.1 ; 142.69,34.07 v1(142.98,33.78) ; CPU1.F55 75.06,175.51 v4(74.79,175.24)
  L3 w0.127: v4(74.79,175.24) 74.73,175.24 74.3,175.67 73.29,175.67 71.58,177.37 71.58,180.85 70.21,182.22 70.21,186.46 73.35,189.6 74.09,189.6 86.36,201.87 152.5,201.87 162.15,192.22 162.15,126.15 163.06,125.23 163.06,118.32 161.45,116.71 161.45,93.97 153.23,85.75 153.23,84.57 151.81,83.15 151.81,72.08 152.19,71.7 152.19,66.78 148.88,63.47 148.88,45.33 142.01,38.46 142.01,36.59 142.77,35.83 142.77,35.19 143.43,34.53 143.56,34.53 v3(143.67,34.42)
HDMI1_DATA_CPU_P1: length 278.5
  TOP w0.102: v4(75.38,177.06) 75.06,177.39 CPU1.F58 ; v3(141.38,34.8) 141.38,34.92 141.17,35.14 140.8,35.14 140.41,34.75 140.13,34.75 C12210.1
  L3 w0.127: v4(75.38,177.06) 74.9,177.55 74.52,177.55 73.58,178.48 73.58,184.24 75.45,186.11 75.45,188.42 76.03,189 77.78,189 89.09,200.31 150.11,200.31 156.12,194.31 156.12,191.77 160.48,187.4 160.48,123.83 161.03,123.28 161.03,118.58 159.8,117.34 159.8,94.51 150.15,84.86 150.15,68.09 147.99,65.93 147.99,65.53 147.1,64.64 147.1,46.22 141.83,40.96 140.18,40.96 138.96,39.74 138.96,35.49 139.51,34.93 141.25,34.93 v3(141.38,34.8)
  BOTTOM w0.102: v2(141.99,34.11) 141.99,34.14 141.38,34.75 v3(141.38,34.8)
HDMI1_DATA_CPU_P2: length 293.8
  TOP w0.102: CPU1.G53 75.4,174.46 v4(75.4,174.31) ; v3(143.67,36.45) 143.33,36.79 142.65,36.79 ; 142.65,36.79 141.9,36.79 141.65,36.54 140.14,36.54 C12208.1 ; 142.65,36.79 v1(142.65,36.4)
  L3 w0.127: v4(75.4,174.31) 75.4,174.32 74.91,174.8 73.01,174.8 70.71,177.1 70.71,178.83 70.19,179.35 69.53,179.35 69.22,179.65 69.22,186.57 72.31,189.65 72.31,190.39 80.11,198.18 81.22,198.18 86.52,203.48 89.44,203.48 90.27,202.65 152.86,202.65 162.95,192.56 162.95,126.45 163.85,125.54 163.85,117.97 163.1,117.22 163.1,94.53 154.01,85.43 154.01,82.36 152.59,80.94 152.59,72.63 153.46,71.75 153.46,66.94 150.15,63.62 150.15,45.49 142.78,38.12 142.78,36.96 143.05,36.69 143.43,36.69 v3(143.67,36.45)
HDMI1_DATA_CPU_P3: length 278.9
  TOP w0.102: C12214.1 v3(140.75,37.97) ; v4(75.39,176.14) 75.71,176.46 CPU1.G56
  L3 w0.127: v4(75.39,176.14) 75.35,176.14 74.9,176.59 74.51,176.59 74.31,176.8 73.8,176.8 72.63,177.97 72.63,182.98 72.04,183.56 72.04,187.18 73.57,188.71 74.32,188.71 86.7,201.09 150.59,201.09 157.01,194.68 157.01,192.02 161.37,187.66 161.37,125.83 162.1,125.1 162.1,118.5 160.57,116.98 160.57,94.19 151.04,84.65 151.04,71.75 151.42,71.37 151.42,68.25 148.76,65.59 148.76,65.21 147.99,64.44 147.99,45.97 141.64,39.62 140.37,39.62 139.86,39.12 139.86,38.51 140.13,38.24 140.48,38.24 v3(140.75,37.97)
  BOTTOM w0.102: v3(140.75,37.97) 141.08,37.64 v2(141.97,37.64)
HDMI1_DATA_IC_N0: length 4.2
  TOP w0.102: C12213.2 138.72,33.09 138.51,33.09 138.44,33.16 137.18,33.16 136.36,33.98 136.1,33.98 135.91,34.16 U118.2
HDMI1_DATA_IC_N1: length 3.9
  TOP w0.102: U118.5 135.91,35.36 136.01,35.27 136.84,35.27 137.08,35.03 138.63,35.03 C12211.2
HDMI1_DATA_IC_N2: length 4.1
  TOP w0.102: U118.7 135.91,36.16 136.01,36.07 136.74,36.07 137.48,36.81 138.63,36.81 C12209.2
HDMI1_DATA_IC_N3: length 4.3
  TOP w0.102: C12215.2 138.63,38.59 137.88,38.59 136.56,37.27 136.01,37.27 135.91,37.36 U118.10
HDMI1_DATA_IC_P0: length 4.5
  TOP w0.102: C12212.2 138.35,32.94 137.75,32.94 ; 137.75,32.94 137.09,32.94 136.27,33.76 U118.1 ; 137.75,32.94 v1(137.75,32.59)
HDMI1_DATA_IC_P1: length 4.3
  TOP w0.102: 137.57,34.82 136.99,34.82 136.75,35.05 136.01,35.05 135.91,34.96 U118.4 ; 137.57,34.82 v1(137.57,34.42) ; 137.57,34.82 138.51,34.82 C12210.2
HDMI1_DATA_IC_P2: length 4.6
  TOP w0.102: 137.21,36.23 137.57,36.6 138.51,36.6 C12208.2 ; 137.21,36.23 v1(137.5,35.94) ; 137.21,36.23 136.83,35.85 136.01,35.85 135.91,35.76 U118.6
HDMI1_DATA_IC_P3: length 4.7
  TOP w0.102: 137.5,37.9 136.65,37.05 136.01,37.05 135.91,36.96 U118.9 ; 137.5,37.9 137.97,38.37 138.51,38.37 C12214.2 ; 137.5,37.9 v1(137.75,37.64)
HDMI1_OUT_HPD: length 196.4
  TOP w0.102: v4(78.13,149.67) 77.82,149.37 CPU1.L9 ; U118.3 136.56,34.56 137.36,33.76 140.16,33.76 140.72,34.32 141.92,34.32 143.42,35.81 v3(144.18,35.81) 144.68,36.32 145.64,36.32 R80255.1
  L4 w0.127: v3(152.05,104.39) 146.97,109.47 121.81,109.47 121.19,110.09 121.19,113.84 112.43,122.61 87.79,122.61 86.49,123.9 85.95,123.9 77.16,132.69 77.16,134.56 75.92,135.8 75.92,145.38 77.4,146.86 77.4,148.95 v4(78.13,149.67)
  BOTTOM w0.102: v3(144.18,35.81) 145.32,36.96 147.67,36.96 150.15,39.44 150.15,44.96 152.74,47.55 152.74,56.62 153.71,57.58 153.71,71.37 151.52,73.56 151.52,88.16 v2(152.7,89.35) 153.4,90.04 153.4,100.28 152.92,100.76 152.92,103.53 v3(152.05,104.39)
HDMI1_SCL: length 87.8
  TOP w0.102: v3(78.39,54.36) 78.77,54.74 R9534.2 ; R9546.1 66.96,50.04 v3(67.09,49.91) ; R80172.2 123.22,20.07 v3(122.72,19.56)
  L3 w0.127: v3(122.72,19.56) 122.21,20.07 122.21,23.21 120.48,24.94 108.75,24.94 106.91,26.78 99.83,26.78 95.14,31.48 95.14,43.92 89.54,49.53 84.73,49.53 81.43,52.83 79.92,52.83 v3(78.39,54.36)
  L4 w0.127: v3(78.39,54.36) 78.05,54.01 74.42,54.01 74.11,54.32 68.83,54.32 67.72,53.21 67.72,50.55 v3(67.09,49.91)
  BOTTOM w0.102: v3(67.09,49.91) 67.04,49.96 v2(66.25,49.96) ; R9534.2 78.77,54.74 v3(78.39,54.36)
HDMI1_SDA: length 89.2
  TOP w0.102: R9536.1 65.95,50.39 66.89,49.45 v3(67.7,49.45) ; R9535.2 78.52,53.72 v3(78.39,53.59)
  L3 w0.127: v3(78.39,53.59) 79.54,52.45 81.27,52.45 84.57,49.15 89.38,49.15 94.76,43.77 94.76,31.32 99.68,26.4 106.75,26.4 108.64,24.51 120.3,24.51 121.83,22.99 121.83,19.68 v3(122.72,18.8)
  L4 w0.127: v3(78.39,53.59) 74.2,53.59 73.86,53.94 68.99,53.94 68.11,53.06 68.11,50.39 67.7,49.98 v3(67.7,49.45)
  BOTTOM w0.102: R80171.2 123.6,19.68 v3(122.72,18.8) ; v3(78.39,53.59) 78.52,53.72 R9535.2 79.22,52.64 v2(79.18,52.6)
