# Allegro board 14091-1.brd (continued)
## Nets (continued)
PWR_DCBATOUT_3D3V: PC4509.1 PC4515.1 PR4530.1 PR4531.1 PR4532.1 PT4504.1 PU4505.5 PU4505.6 PU4505.7 PU4505.8
PWR_DCBATOUT_5V: PC4510.1 PC4517.1 PC4518.1 PR4502.1 PR4528.1 PR4529.1 PT4503.1 PU4503.5 PU4503.6 PU4503.7 PU4503.8
PWR_DCBATOUT_VDDQ: PC5101.1 PC5105.1 PC5106.1 PC5107.1 PR5101.1 PR5112.2 PR5121.2 PR5127.2 PT5103.1 PU5103.5 PU5103.6 PU5103.7 PU5103.8
PWR_LED_YELLOW_C: PWRCN1.9 Q1212.D R1751.2 R1761.1
PWR_LED_YELLOW_C2: R724.2 R1751.1
PWR_V1P8A_EN: PC5228.1 PR5245.1 PR5257.2 PU5302.8
PWR_V1P8A_FB: PC5226.2 PR1689.2 PR5242.1 PU5302.2
PWR_V1P8A_PG: PC5229.1 PR5246.2 PU5302.7 R1689.2
PWR_VCC_CSN_SA: PC4607.1 PC4626.2 PG5002.1 PR4610.2 PU4601.45
PWR_VCCGT_BSTA: PR4601.2 PU4601.14
PWR_VCCGT_BSTA_R: PC4601.1 PR4601.1
PWR_VCCGT_BSTB: PR4667.1 PU4601.22
PWR_VCCGT_BSTB_R: PC4634.1 PR4667.2
PWR_VCCGT_COMP: PC4615.1 PC4631.2 PU4601.4
PWR_VCCGT_COMP_R: PC4631.1 PR4602.1
PWR_VCCGT_CSCOMP: PC4630.1 PC4639.1 PR4630.2 PR4633.1 PR4651.2 PU4601.6
PWR_VCCGT_CSNA: PG4805.1 PR4656.1
PWR_VCCGT_CSNB: PG4822.1 PR4657.1
PWR_VCCGT_CSPA: PC4632.1 PR4653.1 PU4601.10
PWR_VCCGT_CSPB: PC4612.2 PR4652.2 PR4658.1 PU4601.9
PWR_VCCGT_CSREF: PC4604.1 PC4612.1 PC4632.2 PR4656.2 PR4657.2 PU4601.8
PWR_VCCGT_CSSUM: PC4630.2 PC4639.2 PR4636.1 PR4637.2 PR4642.1 PU4601.7
PWR_VCCGT_DIFFOUT: PR4622.1 PR4624.1 PR4628.1 PU4601.2
PWR_VCCGT_DIFFOUT_R: PC4614.2 PR4628.2
PWR_VCCGT_FB: PC4614.1 PC4615.2 PR4602.2 PR4624.2 PU4601.3
PWR_VCCGT_ILIM: PR4630.1 PU4601.5
PWR_VCCGT_ILIM_NTC: PR4633.2 PR4637.1 PR4651.1
PWR_VCCGT_IOUT: PC4637.2 PR4626.2 PU4601.1
PWR_VCCGT_LGA: PR4654.1 PU4601.17 PU4802.4 PU4803.4
PWR_VCCGT_LGB: PR4650.1 PU4601.19 PU4805.4 PU4807.4
PWR_VCCGT_SNB1: PC4809.1 PR4813.2
PWR_VCCGT_SNB2: PC4810.1 PR4814.2
PWR_VCCGT_SWA: PC4601.2 PG4804.2 PL4801.1 PR4813.1 PU4601.16 PU4801.1 PU4801.2 PU4801.3 PU4802.5 PU4802.6 PU4802.7 PU4802.8 PU4803.5 PU4803.6 PU4803.7 PU4803.8
PWR_VCCGT_SWB: PC4634.2 PG4819.2 PL4802.1 PR4814.1 PU4601.20 PU4804.1 PU4804.2 PU4804.3 PU4805.5 PU4805.6 PU4805.7 PU4805.8 PU4807.5 PU4807.6 PU4807.7 PU4807.8
PWR_VCCGT_SWNA: PG4804.1 PR4636.2 PR4653.2
PWR_VCCGT_SWNB: PG4819.1 PR4642.2 PR4658.2
PWR_VCCGT_TSENSE: PC4635.1 PR4647.1 PU4601.11
PWR_VCCGT_TSENSE_NTC: PR4647.2 PR4648.2 PR4649.2
PWR_VCCGT_UGA: PU4601.15 PU4801.4
PWR_VCCGT_UGB: PU4601.21 PU4804.4
PWR_VCCGT_VSN: PC4603.2 PR4617.2 PU4601.52
PWR_VCCGT_VSN_G: PC4603.1 PC4609.1 PG4604.1 PR4617.1
PWR_VCCGT_VSP: PC4609.2 PG4601.1 PU4601.51
PWR_VCCSA_BST: PR5005.2 PU5003.1
PWR_VCCSA_BST_RC: PC5020.1 PR5005.1
PWR_VCCSA_COMP: PC4605.2 PC4606.2 PU4601.47
PWR_VCCSA_COMP_1: PC4605.1 PR4605.2
PWR_VCCSA_CSP: PC4607.2 PC4626.1 PR4608.2 PR4627.1 PU4601.44
PWR_VCCSA_CSP_R: PR4608.1 PR4610.1
PWR_VCCSA_DRVH: PU5001.4 PU5003.8
PWR_VCCSA_DRVL: PU5002.4 PU5003.5
PWR_VCCSA_ILIM: PC4628.1 PR4613.2 PU4601.46
PWR_VCCSA_IOUT: PC4602.2 PR4614.1 PU4601.43
PWR_VCCSA_PH: PC5020.2 PG5001.2 PL5001.1 PU5001.1 PU5001.2 PU5001.3 PU5002.5 PU5002.6 PU5002.7 PU5002.8 PU5003.7
PWR_VCCSA_PWM: PR4620.2 PU4601.40 PU5003.2
PWR_VCCSA_SWN: PG5001.1 PR4627.2
PWR_VCCSA_VSN: PC4638.2 PR4603.2 PU4601.48
PWR_VCCSA_VSN_G: PC4620.1 PC4638.1 PG4602.1 PR4603.1
PWR_VCCSA_VSP_: PR4606.1 PR4669.2 PU4601.49
PWR_VCCSA_VSP_G: PC4620.2 PC4633.1 PG4603.1 PR4606.2
PWR_VCCSA_VSP_RC: PC4633.2 PR4669.1
PWR_VCORE_ALERT#: PR4660.2 PU4601.37
PWR_VCORE_BST: PR4646.1 PU4601.26
PWR_VCORE_BST_R: PC4617.2 PR4646.2
PWR_VCORE_COMP: PC4618.1 PC4619.1 PU4601.30
PWR_VCORE_COMP_RC: PC4619.2 PR4631.1
PWR_VCORE_CSN: PC4608.2 PC4613.2 PG4702.1 PR4632.1 PU4601.32
PWR_VCORE_CSP: PC4608.1 PC4613.1 PR4623.1 PR4625.1 PU4601.33
PWR_VCORE_CSP_NTC: PR4625.2 PR4632.2
PWR_VCORE_DRON: PU4601.39 PU5003.3
PWR_VCORE_EN: PR4666.1 PU4601.41
PWR_VCORE_ILIM: PC4625.1 PR4629.1 PU4601.31
PWR_VCORE_IOUT: PC4611.2 PR4621.1 PU4601.34
PWR_VCORE_LG: PR4655.1 PU4601.23 PU4702.4 PU4703.4
PWR_VCORE_SCLK: PR4662.2 PU4601.38
PWR_VCORE_SDIO: PR4668.2 PU4601.36
PWR_VCORE_SNB: PC4702.1 PR4707.2
PWR_VCORE_SW: PC4617.1 PG4701.2 PL4701.1 PR4707.1 PU4601.24 PU4701.1 PU4701.2 PU4701.3 PU4702.5 PU4702.6 PU4702.7 PU4702.8 PU4703.5 PU4703.6 PU4703.7 PU4703.8 PU4704.1 PU4704.2 PU4704.3
PWR_VCORE_SWN: PG4701.1 PR4623.2
PWR_VCORE_TSENSE: PC4636.1 PR4640.1 PU4601.27
PWR_VCORE_TSENSE_NTC: PR4640.2 PR4644.1 PR4645.2
PWR_VCORE_UG: PU4601.25 PU4701.4 PU4704.4
PWR_VCORE_VCC: PC4627.1 PR4639.2 PU4601.13
PWR_VCORE_VR_RDY: PR4665.1 PU4601.42
PWR_VCORE_VRHOT#: PR4663.2 PU4601.35
PWR_VCORE_VRMP: PC4629.1 PR4638.1 PU4601.12
PWR_VCORE_VSN: PC4624.1 PR4635.1 PU4601.29
PWR_VCORE_VSN_G: PC4623.1 PC4624.2 PG4606.1 PR4635.2
PWR_VCORE_VSP: PR4641.2 PR4661.1 PU4601.28
PWR_VCORE_VSP_G: PC4621.2 PC4623.2 PG4607.1 PR4641.1
PWR_VCORE_VSP_RC: PC4621.1 PR4661.2
PWR_VDDQ_BOOT: PR5103.1 PU5104.18
PWR_VDDQ_BOOT_1: PC5114.1 PR5103.2
PWR_VDDQ_CS: PC5111.2 PR5111.2 PU5104.13
PWR_VDDQ_EN: C1796.1 PU5104.8 R1810.2 R80117.2
PWR_VDDQ_FB: PC5112.2 PR5102.2 PR5110.1 PU5104.6
PWR_VDDQ_LGATE: PU5102.4 PU5104.15
PWR_VDDQ_PG: D5212.3 PR5106.2 PU5104.10 R80141.1
PWR_VDDQ_PG_N: Q9637.5 R80141.2 R80200.2
PWR_VDDQ_PHASE: PC5114.2 PL5101.1 PR5114.1 PU5102.5 PU5102.6 PU5102.7 PU5102.8 PU5103.1 PU5103.2 PU5103.3 PU5104.16
PWR_VDDQ_SENSE: PC5112.1 PR5102.1 PR5122.2 PU5104.5
PWR_VDDQ_SNB: PC5110.1 PR5114.2
PWR_VDDQ_TON: PR5101.2 PU5104.9
PWR_VDDQ_UGATE: PU5103.4 PU5104.17
PWR_VDDQ_VDD: PC5111.1 PC5115.1 PR5105.1 PR5111.1 PU5104.11
PWR_VDDQ_VDDP: PC5103.1 PR5118.1 PU5104.12
PWR_VDDQ_VLDOIN: PC5199.1 PR5108.2 PR5116.2 PU5104.19
PWR_VDDQ_VTTREF: PC5102.1 PR5125.2 PU5104.4
PWR_VGA_CORE_BOOT1: PR43.1 U9.19
PWR_VGA_CORE_COMP: PC4.2 PC6.1 PC7.2 PC8.1 PR1.2 PR13.2 U9.7
PWR_VGA_CORE_FB: PC8.2 PR8.2 PR20.1 PR21.1 U9.8
PWR_VGA_CORE_FB2: PC4.1 PC5.2 U9.9
PWR_VGA_CORE_IMON: PC59.2 PR5487.1 PR5488.2 U9.18
PWR_VGA_CORE_ISEN1: PR12.2 U9.11
PWR_VGA_CORE_ISEN2: PR11.2 PR12.1 U9.10
PWR_VGA_CORE_ISUM+: PC15.1 PC16.1 PR34.1 PR42.1 PR45.1 PR5491.1 U9.15
PWR_VGA_CORE_ISUM-: PC14.1 PR16.2 U9.14
PWR_VGA_CORE_LGATE1A: PU3.4 PU5409.4 U9.23
PWR_VGA_CORE_LGATE1B: TP203.1 U9.24
PWR_VGA_CORE_NTC: PC9.1 PR60.2 U9.5
PWR_VGA_CORE_PHASE1: PC19.1 PG4.2 PL1.1 PR5492.1 PU1.1 PU1.2 PU1.3 PU2.1 PU2.2 PU2.3 PU3.5 PU3.6 PU3.7 PU3.8 PU5409.5 PU5409.6 PU5409.7 PU5409.8 U9.21
PWR_VGA_CORE_RTN: PC13.2 PC59.1 PC12180.2 PR29.2 PR5488.1 U9.13
PWR_VGA_CORE_SNB1: PC12175.1 PR5492.2
PWR_VGA_CORE_UGATE1: PU1.4 PU2.4 U9.20
PWR_VGA_CORE_VCCP: PC17.1 PC18.1 PR44.1 U9.25
PWR_VGA_CORE_VDD: PC58.1 PR5481.2 PR5487.2 U9.16
PWR_VGA_CORE_VIN: PC60.1 PR101.2 U9.17
PWR_VGA_CORE_VSEN: PC11.2 PC13.1 PC12176.1 PR21.2 PR28.2 U9.12
PWR_VGA_CORE_VSUM-: PC15.2 PC16.2 PC20.2 PR16.1 PR51.2 PR5489.1 PR5491.2
PWR_VGA_CORE_VW: PC7.1 PR13.1 U9.6
PWRBTN_N: C1760.1 R332.1 R1756.2 U4101.47
PWRCN_DET_N: C12377.1 CPU1.H3 PWRCN1.5 R1610.1
PWRGD_3V: C201.1 Q9629.G R336.2 R338.1 R339.1 R80192.2
PWRGD_3V_B: Q2.B Q9629.D R117.2
PWRGD_3V_B_1: Q9620.5 Q9620.6 R337.2
PWRGD_3V_C: C12335.1 Q2.C Q4.G Q9628.G R118.2
PWRGD_3V_LL: Q9620.3 R338.2
PWRGD_PS_L: C189.1 Q6.2 R288.2 R293.1
PWRGD_PS_L1: Q6.5 Q6.6 R79934.2
PWRGD_PS_L2: Q6.3 R80149.2
PWRGOOD_GPU: GPU1.N10 R1158.2
PWROK3_1: R298.2 U109.29
PWROK3_1_R: R298.1 R335.2 R336.1
PWROK3_2: R295.1 U109.75
PWROK3_2_R: R265.1 R295.2 R340.1
PX_EN: GPU1.AB16 TP159.1
QSAN_0: GPU1.H27 MEM3.G3
QSAN_1: GPU1.A27 MEM3.B7
QSAN_2: GPU1.C23 MEM1.B7
QSAN_3: GPU1.C19 MEM1.G3
QSAN_4: GPU1.C15 MEM4.G3
QSAN_5: GPU1.E9 MEM2.B7
QSAN_6: GPU1.C5 MEM2.G3
QSAN_7: GPU1.H4 MEM4.B7
QSAP_0: GPU1.H28 MEM3.F3
QSAP_1: GPU1.C27 MEM3.C7
QSAP_2: GPU1.A23 MEM1.C7
QSAP_3: GPU1.E19 MEM1.F3
QSAP_4: GPU1.E15 MEM4.F3
QSAP_5: GPU1.D10 MEM2.C7
QSAP_6: GPU1.D6 MEM2.F3
QSAP_7: GPU1.G5 MEM4.C7
RASA0#: GPU1.G22 MEM1.J3 MEM3.J3
RASA1#: GPU1.G17 MEM2.J3 MEM4.J3
RDY#: TP4126.1 U4101.23
REMOTE1+: C211.2 R404.1 RT3.1 U109.87
REMOTE1-: C211.1 R400.2 RT3.2
REXT: R2082.1 U118.18
RING2: C157.1 Q24.2 R261.2 U6.31 UHS1.3
ROM_CS#: R1167.2 R1168.2 U49.1
ROM_SI_D3: R1171.1 U49.5
ROM_SLK_D4: R1170.1 U49.6
ROM_SO_C4: R1169.2 U49.2
RREF: R79840.1 U14.9
RSMRST*_R: Q9620.2 R340.2
RSMRST_N: CPU1.AY17 Q9650.3 R291.1 R1993.1 R9904.1 R80047.1 R80205.1 RN9504.4(B)
RSMRST_N_2: R80205.2 U109.52
RSMRST_N_B: Q9650.5 R80236.1
RSMRST_PWRGD#: PR8510.2 PR8511.2 PR8512.1 U109.127
RSVD_TP_AK12: CPU1.AK12 TP606.1
RSVD_TP_AK13: CPU1.AK13 TP605.1
RSVD_TP_BA68: CPU1.BA68 TP602.1
RSVD_TP_BA70: CPU1.BA70 TP601.1
RSVD_TP_BB68: CPU1.BB68 TP603.1
RSVD_TP_BB69: CPU1.BB69 TP604.1
RSVD_TP_F65: CPU1.F65 TP612.1
RSVD_TP_G65: CPU1.G65 TP613.1
RT: R79628.1 U120.10
RTD2482_VREF: C12190.1 SCA1.44
RTD_PIN2: R9519.2 R9531.2 SCA1.2
RTD_PIN105: R79236.1 R79237.2 R79832.1 SCA1.102
RTD_PIN119: R9525.1 SCA1.119
RTD_PIN121: R9527.2 SCA1.121
RTD_PIN122: R9530.2 SCA1.122
RTD_PIN123: R9536.2 SCA1.123
RTD_PIN124: R9546.2 SCA1.124
RTD_RESETB: C12174.1 R9548.1 SCA1.125
RTL_ISOLATE_N: Q36.6 R377.2 R1817.1 U16.20
RTL_ISOLATE_N_1: C1798.1 Q36.5 R406.1 R1816.2
RTL_ISOLATE_N_2: Q36.2 Q36.3 R378.2
RTN1: CONVT1.1 R51.1
RTN2: CONVT1.2 R53.1
RTN3: CONVT1.5 R56.1
RTN4: CONVT1.6 R59.1
RUN_EN1: Q65.2 Q65.3 R732.1 R733.2
RUN_EN2: Q65.6 R722.1 R1178.1 R1778.2
RUN_EN_1P8V: C862.1 R1178.2 R1179.2 U105.3
RUNPWR_R6: C865.2 Q65.5 R718.2
S_LVDS_BL_EN: R135.1 R139.1 R143.2 R144.1 R1985.1
S_TXE0+: LVDS1.18 SCA1.82
S_TXE0-: LVDS1.19 SCA1.83
S_TXE1+: LVDS1.15 SCA1.80
S_TXE1-: LVDS1.16 SCA1.81
S_TXE2+: LVDS1.12 SCA1.78
S_TXE2-: LVDS1.13 SCA1.79
S_TXE3+: LVDS1.8 SCA1.74
S_TXE3-: LVDS1.9 SCA1.75
S_TXEC+: LVDS1.10 SCA1.76
S_TXEC-: LVDS1.11 SCA1.77
S_TXO0+: LVDS1.29 SCA1.94
S_TXO0-: LVDS1.30 SCA1.95
S_TXO1+: LVDS1.27 SCA1.92
S_TXO1-: LVDS1.28 SCA1.93
S_TXO2+: LVDS1.25 SCA1.90
S_TXO2-: LVDS1.26 SCA1.91
S_TXO3+: LVDS1.20 SCA1.86
S_TXO3-: LVDS1.21 SCA1.87
S_TXOC+: LVDS1.22 SCA1.88
S_TXOC-: LVDS1.23 SCA1.89
SA0_DIMA: DIMM1.197 R1201.2
SA0_DIMB: DIMM2.197 R1301.2
SA1_DIMA: DIMM1.201 R1202.2
SA1_DIMB: DIMM2.201 R1302.2
SATA__RXN0_C: C149.2 HDD1.5
SATA__RXN1_C: C118.2 ODD1.5
SATA__RXP0_C: C151.2 HDD1.6
SATA__RXP1_C: C119.2 ODD1.6
SATA__TXN0_C: C142.2 HDD1.3
SATA__TXN1_C: C115.2 ODD1.3
SATA__TXP0_C: C141.2 HDD1.2
SATA__TXP1_C: C114.2 ODD1.2
SATA_LED_N: CPU1.H1 Q9646.4 R1615.2 R1754.1
SATA_LED_N_C_1: Q9646.3 Q9646.6 R80201.2
SATA_RXN0_C_N: C149.1 L604.1
SATA_RXN1_C_N: C118.1 L602.1
SATA_RXP0_C_N: C151.1 L604.4
SATA_RXP1_C_N: C119.1 L602.4
SATA_TXN0_C_N: C142.1 L603.1
SATA_TXN1_C_N: C115.1 L601.4
SATA_TXP0_C_N: C141.1 L603.4
SATA_TXP1_C_N: C114.1 L601.1
SATAHDR_RX_DN0: CPU1.F20 L604.2
SATAHDR_RX_DN1: CPU1.G21 L602.2
SATAHDR_RX_DP0: CPU1.E20 L604.3
SATAHDR_RX_DP1: CPU1.F21 L602.3
SATAHDR_TX_DN0: CPU1.B21 L603.2
SATAHDR_TX_DN1: CPU1.D21 L601.3
SATAHDR_TX_DP0: CPU1.A21 L603.3
SATAHDR_TX_DP1: CPU1.C21 L601.2
SB3V: C579.1 C595.1 C1615.1 C1617.1 C1701.1 C1925.1 C12351.1 F3.1 MEJ1.1 PC1.1 PC140.1 PC5223.2 PG8402.1 PG8404.1 PR4509.1 PR5106.1 PR5212.1 PR5218.1 PR5246.1 PR5257.1 PU5302.5 PU5302.9 Q44.S Q1211.S Q9601.D Q9644.E R10.1 R151.2 R253.1 R279.1 R280.2 R282.2 R283.2 R304.2 R337.1 R341.2 R378.1 R531.1 R731.1 R741.1 R742.1 R755.2 R764.2 R775.1 R1108.1 R1109.1 R1115.1 R1116.1 R1123.1 R1124.1 R1126.1 R1127.1 R1135.1 R1137.1 R1708.1 R1731.1 R1733.1 R1734.1 R1752.1 R1758.2 R1784.1 R1785.1 R1822.1 R1824.1 R1832.2 R1833.2 R1837.1 R1838.1 R1993.2 R2091.1 R5216.1 R6702.1 R8511.1 R8513.1 R8514.1 R9909.1 R9929.1 R79689.1 R79691.1 R79806.1 R79836.2 R79927.1 R79930.2 R79932.2 R79933.1 R79934.1 R79938.2 R80035.1 R80039.1 R80040.1 R80109.2 R80132.2 R80133.2 R80134.2 R80159.2 R80160.2 R80167.2 R80168.2 R80201.1 R80202.1 R80244.2 R80245.2 R80248.1 R80253.2 RN5.1(A) RN5.2(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) U54.8 U54.9 U9626.5
SB3V_EN: C1700.1 PR5431.2 R1980.1 U54.3 U54.5
SB5_33_CT1: C1929.1 U54.12
SB5_33_CT2: C1928.1 U54.10
SB5V: C1926.1 C1927.1 C12365.1 CN3.1 PC4616.1 PC5004.1 PR4639.1 PR4652.1 PR5105.2 PR5118.2 PR5306.1 PU4601.18 PU5003.4 R117.1 R250.2 R389.1 R724.1 R735.1 R1759.1 R1767.1 R79726.1 RN3.5(B) RN3.6(B) RN3.7(B) RN3.8(B) U54.13 U54.14 U704.3 U706.3 U9628.1
SCALAR_ACK: CPU1.M1 R80173.1 SCA1.53
SCALAR_EN: R79809.2 R79927.2 U109.120
SCALAR_EN_G: PQ5007.2 R79809.1
SCALAR_MUTE: Q9627.2 R79188.2 SCA1.35
SCALAR_OUT_L: C12192.1 SCA1.45
SCALAR_OUT_L_C: C12192.2 U9615.2
SCALAR_OUT_R: C12193.1 SCA1.46
SCALAR_OUT_R_C: C12193.2 U9615.10
SCALAR_PC_SW1: Q9602.E R9601.2
SCALAR_PC_SW2: Q9602.B R9602.2 R9603.1
SCALAR_PC_SW3: C12171.1 Q9601.G Q9602.C R9604.1 R9605.1
SCALAR_PC_SW4: PQ5007.5 PQ5007.6 R9603.2
SCALAR_PC_SW5: PQ5007.3 R9605.2
SCALAR_SIO_PU: R277.1 R304.1 R305.2 R316.2 R317.2 R318.1 R1946.1 R79820.2 R79940.2 RN6.1(A) RN6.2(A)
SD_CD#: MEMCD1.11 U14.30
SD_CLK_C_1: C12376.1 MEMCD1.5 R79846.2
SD_CMD: MEMCD1.2 R79847.2
SD_DAT0: C12378.1 MEMCD1.7 R79845.2
SD_DAT1: C12379.1 MEMCD1.8 R79844.2
SD_DAT2: C12380.1 MEMCD1.9 R79849.2
SD_DAT3: C12381.1 MEMCD1.1 R79848.2
SD_LN0_M: TP9911.1 U14.25
SD_LN0_P: TP9910.1 U14.26
SD_LN1_M: TP9913.1 U14.23
SD_LN1_P: TP9912.1 U14.22
SD_RCOMP: CPU1.AB7 R1901.1
SD_VDD2: C311.1 C312.2 U14.13
SD_WAKE#_IC: R80189.2 U14.32
SD_WAKE_N: CPU1.B7 R80189.1 R80248.2
SD_WP: MEMCD1.10 R79851.2
SDIN: R9502.2 SCA1.116
SDIN_1: R9502.1 U9501.5
SDOUT: R9506.1 SCA1.117
SDREG2: C12156.2 U14.24
SENSE_A: R80174.2 U6.34
SENSE_A_C: Q9643.D R80174.1
SENSE_B: R266.2 R267.2 U6.33
SER_IRQ_R: R264.1 R80131.1 U109.36
SERIRQ_CPU: CPU1.AY11 R2032.2 R79704.2 R80131.2
SHDN_MUTE_AP_CTL: R9554.1 SCA1.36
SIDE_USB3_RX0+: L5.3 SSUSB1.6 U3.2 U3.9
SIDE_USB3_RX0-: L5.2 SSUSB1.5 U3.1 U3.10
SIDE_USB3_RX1+: L57.3 SSUSB2.6 U5.2 U5.9
SIDE_USB3_RX1-: L57.2 SSUSB2.5 U5.1 U5.10
SIDE_USB3_TX0+: L4.3 SSUSB1.9 U3.5 U3.6
SIDE_USB3_TX0-: L4.2 SSUSB1.8 U3.4 U3.7
SIDE_USB3_TX1+: L56.3 SSUSB2.9 U5.5 U5.6
SIDE_USB3_TX1-: L56.2 SSUSB2.8 U5.4 U5.7
SIO_AGND: C179.2 C181.2 C183.2 C184.2 C188.2 C12385.2 R252.2 R259.2 R399.1 R400.1 R651.1 R79939.2 R79945.1 R80250.2 U109.83 U109.84
SIO_AMD SVID_EN: R296.1 U109.26
SIO_ATXPG: R290.1 R80149.1 R80150.1 U109.16
SIO_AVCC3: C187.1 C12251.2 L9524.1 U109.96
SIO_CE_N: R308.1 U109.27 U9602.1
SIO_CLK_DB: RN7.2(A) U109.48
SIO_COPEN#: R303.1 U109.65
SIO_DAT_DB: RN7.1(A) U109.49
SIO_DEBUG_RX: R79947.1 TP104.1 U109.122
SIO_DEBUG_TX: R79946.1 TP103.1 U109.121
SIO_GREEN: Q9646.2 Q9646.5 R80202.2 U109.23
SIO_GREEN_PWM: R723.2 U109.15
SIO_GREEN_PWM_C_1: Q1212.G Q9646.1 R723.1 R729.1 R1752.2
SIO_HDD_LED: R1753.1 R1757.2 U109.11
SIO_HDD_LED_1: Q1214.B R1753.2
SIO_HOLD#: R311.1 U9602.7
SIO_INT#: R80210.1 R80211.1 U4101.39
SIO_INT_C: R80210.2 U109.100
SIO_LVDS_BL_ADJ: R131.2 R79932.1 U109.10
SIO_MAIN_VCC3: R286.1 U109.89
SIO_MEM_EVENT_L: R279.2 U109.53
SIO_PCIRSTIN#: R316.1 U109.128
SIO_PSON_D: Q8.D R323.1
SIO_PSON_N: Q8.G R318.2 U109.73
SIO_SCI#: CPU1.L6 R802.1 R79928.1
SIO_SCK: C197.1 R294.2 R312.1 U9602.6
SIO_SCK_R: R294.1 U109.22
SIO_SI: R313.1 U109.21 U9602.5
SIO_SMB2_CLK: R306.2 R80209.2 U109.63
SIO_SMB2_DATA: R307.2 R80208.2 U109.62
SIO_SMCLK0: R79633.2 RN5.3(B) U109.60
SIO_SMDAT0: R79634.2 RN5.4(B) U109.61
SIO_SO: R309.1 U109.45 U9602.2
SIO_UART1_RX: R317.1 R9553.2 U109.17
SIO_UART1_RX_R: R9553.1 SCA1.59
SIO_UART1_TX: R9555.2 R79820.1 U109.18
SIO_UART1_TX_R: R9555.1 SCA1.58
SIO_VCORE: C191.1 C12151.1 U109.33
SIO_VIN1: R80215.1 R80216.2 U109.94
SIO_VIN3: C179.1 R250.1 R252.1 U109.92
SIO_VIN4: C181.1 R255.1 R259.1 U109.91
SIO_VIN5: C183.1 R79937.1 R79939.1 U109.90
SIO_VREF: C188.1 R397.2 R404.2 R658.2 U109.88
SIO_WP#: R310.1 U9602.3
SIO_WRST#: C12152.1 R79944.2 U109.47
SIO_YELLOW: Q68.G R731.2 R1761.2 U109.31
SKEW1: CPU1.U1 R1687.2 R1688.1
SKEW2: CPU1.U2 R80180.2 R80181.1
SKEW3: CPU1.U3 R1684.2 R1685.1
SKTOCC#: CPU1.A65 TP402.1
SLEEVE: C160.1 Q24.1 Q28.D R272.2 U6.32 UHS1.4
SLEEVE_G: Q28.G Q31.C R319.2 R322.1
SLP_A_N: CPU1.AN16 TP9916.1
SLP_LAN_N: CPU1.AW15 TP1704.1
SLP_S0_N: CPU1.AT11 R80127.1
SLP_S3_N: CPU1.AP15 R718.1 R1878.2 R79712.1 R79789.1 R80112.2 R80118.1 R80126.1 R80140.1 U109.68
SLP_S3_N_EC: R79712.2 U4101.30
SLP_S3_N_R3: TP9917.1 U109.76
SLP_S4_N: CPU1.BA16 Q1217.5 R1951.1 R79713.1 R80111.2 R80117.1 R80247.1
SLP_S4_N_C: R297.1 U109.74
SLP_S4_N_EC: R79713.2 U4101.51
SLP_S4_N_SIO: R297.2 R1950.2 R1951.2
SLP_S5_N: CPU1.AY16 R1950.1
SLP_SUSB: CPU1.AN15 PR5217.1 PR5245.2 R1980.2 R80234.1 U109.3
SLP_SUSB_C: Q9650.6 R80235.1 R80236.2
SLP_SUSB_R: Q9650.2 R80232.1 R80233.1 R80234.2
SLP_WLAN_N: CPU1.BB17 TP9915.1
SM_DRAMRST#: CPU1.AT13 R80074.2 R80075.1
SM_DRAMRST#_R: C1217.1 C1301.1 DIMM1.30 DIMM2.30 R80075.2
SM_INTRUDER#: CPU1.AP16 R80038.2
SM_RCOMP_0: CPU1.AR18 R80076.1
SM_RCOMP_1: CPU1.AT18 R80078.1
SM_RCOMP_2: CPU1.AU18 R80077.1
SMB0_CVT_CLK: C3456.1 R79633.1 U120.6
SMB0_CVT_DATA: C43.1 R79634.1 U120.7
SMB_CLK_MAIN: DIMM1.202 DIMM2.202 Q4.S Q123.6 Q9501.1 R9912.2 R79991.2 U6701.4
SMB_CLK_RESUME: CPU1.R7 Q4.D R14.1 R1837.2
SMB_DATA_MAIN: DIMM1.200 DIMM2.200 Q123.3 Q9501.4 Q9628.S R124.2 R9911.2 U6701.6
SMB_DATA_RESUME: CPU1.R8 Q9628.D R1622.1 R1838.2
SMBUS_ISP: C182.1 Q9501.2 Q9501.5 Q9502.2 Q9502.5 R257.2 R9557.2 R9563.1 U109.115
SMBUS_MS: R80217.2 R80218.1 U109.123
SML0_CLK: CPU1.R9 RN1807.5(B)
SML0_DATA: CPU1.W2 RN1807.6(B)
SML1_CLK: CPU1.W3 RN1807.7(B)
SML1_DATA: CPU1.V3 RN1807.8(B)
SNB: C35.1 R79619.2
SO_1: R9506.2 U9501.2
SP1: R79844.1 U14.15
SP2: R79845.1 U14.16
SP3: R79846.1 U14.17
SP4: R79847.1 U14.19
SP5: R79848.1 U14.20
SP6: R79849.1 U14.21
SP7: R79851.1 U14.29
SPDIF_IC: SCA1.68 U6.16
SPEAKER1_L1: C241.1 R79812.2 U9615.3
SPEAKER1_R1: C12263.1 R79813.2 U9615.9
SPEED_100*_CON: RJ1.12 UR6.2
SPEED_100_N: U12.6 U16.26 UR6.1
SPEED_1000*_CON: RJ1.11 UR7.2
SPEED_1000_N: U12.1 U16.25 UR7.1
SPI_CLK: R352.1 R1806.1
SPI_CLK_1: R352.2 SRCON1.6 U9624.6
SPI_CLK_CPU: CPU1.AV2 R1806.2
SPI_CS0_N: R1812.2 SRCON1.1 U9624.1
SPI_CS_CPU_N0: CPU1.AU3 R1812.1
SPI_HOLD_CPU: CPU1.AU4 R1811.2 R1834.2
SPI_IO2: R351.2 R1809.1
SPI_IO3: R348.1 R1811.1
SPI_MISO: R1807.1 R79978.2
SPI_MISO_ROM_1: R79978.1 SRCON1.2 U9624.2
SPI_MOSI: R1808.1 R79977.1
SPI_MOSI_1: R79977.2 SRCON1.5 U9624.5
SPI_SI_CPU: CPU1.AV3 R1808.2 R1824.2 R1825.1 R1826.2
SPI_SI_XDP: R1826.1 R9909.2 R9910.2
SPI_SO_CPU: CPU1.AW3 R1807.2
SPI_WP_CPU: CPU1.AW2 R1809.2 R1827.2
SPI_WP_N_1: R343.2 R351.1 R79981.1 SRCON1.3 U9624.3
SPI_WP_XDP: R1827.1 R9928.1
SPKR_DET: R283.1 R80237.1 U109.59
SPKR_DET_C: R80237.2 SPK1.6
SPKR_IN_L: C241.2 C243.2 U9625.6
SPKR_IN_R: C12263.2 U9625.31
SPKR_L+_C: C253.1 L7.2 R79982.1 SPK1.1
SPKR_L+_SNB: C255.1 R79982.2
SPKR_L-_C: C254.1 L8.2 R79983.1 SPK1.2
SPKR_L-_SNB: C256.1 R79983.2
SPKR_OUT_L+: C244.2 C12262.1 L7.1 U9625.16
SPKR_OUT_L-: C242.2 C252.1 L8.1 U9625.18
SPKR_OUT_R+: C235.2 C257.1 L10.1 U9625.25
SPKR_OUT_R-: C239.2 C12264.1 L11.1 U9625.23
SPKR_R+_C: C259.1 L10.2 R79985.1 SPK1.4
SPKR_R+_SNB: C261.1 R79985.2
SPKR_R-_C: C12334.1 L11.2 R79986.1 SPK1.3
SPKR_R-_SNB: C12265.1 R79986.2
SPV10: C785.1 C787.1 C789.1 GPU1.H8 L51.2
SPV18: C788.1 C792.1 C793.1 GPU1.H7 L49.2
SST_HOLDJ_1: R348.2 R79980.2 SRCON1.7 U9624.7
SSTCMP: R45.1 U120.11
SSTCMP_1: C5.1 R45.2
STATUS: R61.1 U120.8
SUS_CLK: R1710.1 R80062.2
SUS_CLK_PCH: CPU1.BA17 R80062.1
SUS_LED_GREEN_C: PWRCN1.7 Q68.D R729.2 R730.2
SUS_LED_GREEN_C2: R730.1 R735.2
SUS_PWR_ACK: CPU1.AP11 R1949.2 R80191.2
SUS_PWR_ACK_SIO: R1949.1 R79836.1 U109.13
SUS_WARNB: CPU1.AR13 R1948.2 R80039.2 R80191.1
SUS_WARNB_SIO: R1948.1 U109.12
SUSCLK_NGFF: NGFF1.50 R1710.2
SW_ON_N_SIO: R277.2 R334.1 U109.69
SYS_3VSB: R79930.1 U109.67
SYS_FAN_TACH1_1: FANC3.3 R76.2 R80.2
SYS_FAN_TACH1_2: R73.2 R74.2 R76.1
SYS_PRES: BAT2.7B R79647.2
SYS_PWROK: CPU1.B6 R9908.1 R80033.1 R80192.1
SYSTEM_FAN_PWM1_1: D1.A FANC3.4 R68.2 R71.2
TCK: TP4130.1 U4101.27
TDI: TP4128.1 U4101.25
TDO: TP4127.1 U4101.24
TESTEN: GPU1.K7 R302.1 R1897.1
THERMAL_SHUT#_SIO: Q9642.C R1920.1 R80256.2
THERMTRIP#_CPU: CPU1.C63 R420.2
THERMTRIP#_EC: Q9642.E R419.2 R420.1 R80256.1
THERMTRIP#_EC_N: Q9642.B R80158.2
TMDS_3V3: C12185.1 C12186.1 C12187.1 L9502.2 R9531.1 SCA1.1 SCA1.20
TMS: TP4129.1 U4101.26
TP1_AY4: CPU1.AY4 TP610.1
TP2_BB3: CPU1.BB3 TP611.1
TP4_BB5: CPU1.BB5 TP609.1
TP5_AU5: CPU1.AU5 TP607.1
TP6_AT5: CPU1.AT5 TP608.1
TP3131_GVDD: C12266.2 R396.1 R398.2 U9625.2
TP_DDPC_CTRLDATA: CPU1.N8 TP9919.1
TP_DET: R1785.2 TOUCH1.1 U109.118
TP_GPU_CLKREQ#: GPU1.N7 TP158.1
TP_L_BKLTEN: CPU1.R12 TP9904.1
TP_L_VDDEN: CPU1.U13 TP9905.1
TP_NGFF_COEX1: NGFF1.48 TP39.1
TP_NGFF_COEX2: NGFF1.46 TP38.1
TP_NGFF_COEX3: NGFF1.44 TP196.1
TP_NGFF_LED1: NGFF1.6 TP63.1
TP_NGFF_LED2: NGFF1.16 TP64.1
TP_NGFF_MLDIR: NGFF1.17 TP62.1
TP_PMODE_XDP_RST_R_N: R9930.2 R9933.1 XDP1.46
TP_SIO_VIN2: C12385.1 R80250.1 R80251.1 TP107.1 U109.93
TPA3113_SD: Q12.G Q9622.6 R390.2 R79871.1
TPA3113_SD1#: C245.1 Q12.D Q9626.G R381.1 R79919.1 R79984.2 U9625.29
TPA3131_BSNL: C242.1 U9625.19
TPA3131_BSNR: C239.1 U9625.22
TPA3131_BSPL: C244.1 U9625.15
TPA3131_BSPR: C235.1 U9625.26
TPA3131_FAULT#: R381.2 U9625.30
TPA3131_GAIN: R396.2 R79988.1 U9625.3
TPA3131_LINN: C240.2 U9625.5
TPA3131_LINN_1: C240.1 R387.2
TPA3131_MUTE: Q9626.D R388.1 R79989.2 U9625.7
TPA3131_PLIMIT: C250.2 R398.1 R79987.2 U9625.1
TPA3131_RINN: C236.2 U9625.32
TPA3131_RINN_1: C236.1 R382.2
TPA3131_SYNC: TP109.1 U9625.11
TSVDD: C758.1 C759.1 GPU1.AD17 L47.2
USB2_C_N1: R80101.1 TR5205.4
USB2_C_P1: R80100.1 TR5205.1
USB2_IN_N1: TR4.1 U9628.11
USB2_IN_P1: TR4.4 U9628.10
USB2_N0: CPU1.AB9 TR3.4
USB2_N1: CPU1.AD6 R80101.2 R80116.2
USB2_N2: CPU1.AH3 TR7.1
USB2_N3: CPU1.AD9 TR5.4
USB2_N4: CPU1.AJ1 TR1.1
USB2_N5: CPU1.AF6 TR9.4
USB2_N6: CPU1.AH1 TR12.4
USB2_NGFF_N6: NGFF1.5 TR12.3
USB2_NGFF_P6: NGFF1.3 TR12.2
USB2_OUT_N1: R80116.1 U9628.2
USB2_OUT_P1: R80115.1 U9628.3
USB2_P0: CPU1.AB10 TR3.1
USB2_P1: CPU1.AD7 R80100.2 R80115.2
USB2_P2: CPU1.AJ3 TR7.4
USB2_P3: CPU1.AD10 TR5.1
USB2_P4: CPU1.AJ2 TR1.4
USB2_P5: CPU1.AF7 TR9.1
USB2_P6: CPU1.AH2 TR12.1
USB2N_EXT: D24.3 TR7.2 USB3.2
USB2P_EXT: D24.4 TR7.3 USB3.3
USB3_TX0_EMI_DN: C91.2 L4.1
USB3_TX0_EMI_DP: C1757.2 L4.4
USB3_TX1_EMI_DN: C113.2 L56.1
USB3_TX1_EMI_DP: C111.2 L56.4
USB3N_EXT: D24.1 TR5.3 USB4.2
USB3P_EXT: D24.6 TR5.2 USB4.3
USB30_RX_CPU_N0: CPU1.H8 L5.1
USB30_RX_CPU_N1: CPU1.J6 L57.1
USB30_RX_CPU_P0: CPU1.G8 L5.4
USB30_RX_CPU_P1: CPU1.H6 L57.4
USB30_TX_CPU_N0: C91.1 CPU1.C13
USB30_TX_CPU_N1: C113.1 CPU1.B13
USB30_TX_CPU_P0: C1757.1 CPU1.D13
USB30_TX_CPU_P1: C111.1 CPU1.A13
USB_EN: C249.1 C1764.2 Q43.4 R1783.2
USB_EN1: Q1217.2 Q1217.3 R1780.2 R1781.1
USB_EN2: Q1217.6 R1777.2 R1779.1 R1783.1
USB_OC#0_1: C1756.1 CPU1.A9 R1727.1 R1728.2 R80113.2
USB_OC#2_3: C12363.1 CPU1.C9 R80102.1 R80103.2
USB_PCH_DN4_NN: TR1.2 WEBCM1.2
USB_PCH_DP4_PP: TR1.3 WEBCM1.1
USB_TOUCH_N: C1774.1 TOUCH1.4 TR9.3
USB_TOUCH_P: C1773.1 TOUCH1.3 TR9.2
USBCOMP: CPU1.AB6 R1603.1
USBP0N_EXT: D4.1 SSUSB1.2 TR3.3
USBP0P_EXT: D4.6 SSUSB1.3 TR3.2
USBP1N_EXT: D4.3 SSUSB2.2 TR4.2 TR5205.3
USBP1P_EXT: D4.4 SSUSB2.3 TR4.3 TR5205.2
USBVCC01: C104.1 C105.1 C106.1 C1753.2 D4.5 F14.2 R1728.1 SSUSB1.1 SSUSB2.1 TC8.1 U9628.12
USBVCC23: C271.1 C12361.1 C12362.1 C12364.1 D24.5 F17.2 R80103.1 TC23.1 USB3.1 USB4.1
USBVCCTP: C592.1 F15.2 TOUCH1.5
V_0P675_S3: C1214.1 C1215.1 C1216.1 C1220.1 C1221.1 C1222.1 C1237.1 C1238.1 C1247.1 C1303.1 C1319.1 C1320.1 C1321.1 C1322.1 C1323.1 C1324.1 C1325.1 C1326.1 DIMM1.203 DIMM1.204 DIMM2.203 DIMM2.204 PR8506.1 PR8507.1
V_1P5_HDMI: C3366.1 C12202.1 C12203.1 C12204.1 C12205.1 C12206.1 C12207.1 R2081.1 U118.12 U118.19 U118.20 U118.31 U118.40 U119.2
V_1P05_LAN: C202.1 C204.1 C213.1 C570.1 C574.1 C580.1 C583.1 C584.1 C1801.1 U16.3 U16.8 U16.22 U16.24 U16.30
V_3_CARD: C329.2 C330.1 C12161.2 MEMCD1.4 U14.12
V_3P0_BAT_VREG: C2117.1 C2118.1 C2119.1 D2.3 R322.2 R2106.1 R80038.1 R80057.1 R80059.1
V_3P3_A: C185.1 C194.1 C195.1 C1699.1 C1830.1 C6725.2 C12249.1 D2.1 L9524.2 L9525.1 PC4501.1 PG4501.1 PL4502.1 PR4402.1 PR4404.1 PR4407.1 PR4422.2 PR4426.1 PR4427.1 PR4432.1 PR4434.1 PR4450.2 PR5431.1 PT4501.1 Q9649.S R305.1 R308.2 R309.2 R310.2 R311.2 R312.2 R313.2 R319.1 R390.1 R1760.1 R79936.1 R79944.1 R79984.1 R79989.1 R80041.1 R80054.2 R80151.1 R80211.2 R80217.1 R80223.2 R80224.1 R80225.1 R80226.1 R80228.2 R80230.1 R80254.2 RN7.3(B) RN7.4(B) U52.6 U52.7 U54.6 U54.7 U109.1 U109.32 U109.64 U9602.8
V_3P3_LAN: C84.1 C209.1 C572.1 C587.1 C1802.1 C1803.1 C1804.1 C1806.1 C1807.1 C3453.1 C3454.1 Q44.D R741.2 R1816.1 R1819.1 R79618.2 U10.5 U11.5 U12.5 U16.11 U16.23 U16.32
V_3P3_PCIVAUX: C1742.1 C1743.1 C1744.1 C1745.1 NGFF1.2 NGFF1.4 NGFF1.72 NGFF1.74 Q1211.D Q1229.G R1.1 R1707.1 R1708.2 R1932.1 TC1.1
V_5_CODEC: C146.1 C147.2 C450.1 L19.1 U6.39
V_5_LCD1: L1.1 U1.4
V_5_LCD2: F2.1 L1.2 R2.1 R8.2
V_5HDD: C109.1 C110.1 C112.1 R183.2 R185.2 SATAP1.1 SATAP1.3 TC5.1
V_5P0_A: C1698.1 C1829.1 D21.K L19.2 PC4511.1 PC5202.1 PC5224.1 PG4532.1 PL4501.2 PT4502.1 PU5201.7 PU5302.6 Q43.5 Q43.6 Q43.7 Q43.8 R80233.2 R80235.2 U52.1 U52.2 U52.4 U54.1 U54.2 U54.4
V_5P0_HDMI_CONN: C419.1 HDMI1.18 HDMI3.2 L25.1
V_5P0_HDMI_CONN_L: F7.2 L25.2
V_19_INV: C3459.1 C3460.1 F16.2 L61.1 R5.1 R79631.2
V_SM_VREF_CNT: C1257.1 CPU1.AY67 R1220.2
VGA_CORE: C805.1 C806.1 C807.1 C808.1 C809.1 C810.1 C811.1 C812.1 C813.1 C814.1 C815.1 C816.1 C817.1 C818.1 C819.1 C820.1 C821.1 C822.1 C823.1 C824.1 GPU1.AA12 GPU1.AA15 GPU1.M11 GPU1.M13 GPU1.M15 GPU1.M16 GPU1.M17 GPU1.M18 GPU1.M20 GPU1.M21 GPU1.N12 GPU1.N15 GPU1.N17 GPU1.N20 GPU1.R13 GPU1.R16 GPU1.R18 GPU1.T12 GPU1.T15 GPU1.T17 GPU1.T20 GPU1.U11 GPU1.U13 GPU1.U16 GPU1.U18 GPU1.V15 GPU1.V17 GPU1.V20 GPU1.V21 GPU1.Y13 GPU1.Y16 GPU1.Y18 GPU1.Y21 PC12179.1 PG3.2 PL1.2 PR28.1 PT1.1 PT3.1 PT4.1
VIDALERT#_CPU: CPU1.B63 R80030.1
VIDALERT#_CPU_R: PR4609.2 PR4660.1 R80029.2 R80030.2
VIDSCK_CPU: CPU1.A63 R80032.2
VIDSCK_CPU_R: PR4618.2 PR4662.1 R80028.2 R80032.1
VIDSOUT_CPU: CPU1.D64 R80031.2
VIDSOUT_CPU_R: PR4616.2 PR4668.1 R80027.2 R80031.1
VOUT_INV: C36.1 C37.1 C38.1 C39.1 C40.1 CONVT1.3 CONVT1.4 D32.K U120.18
VR_EN: PR4666.2 R80144.1
VR_EN_C_1: Q9636.G Q9637.6 R8511.2
VR_EN_C_2: Q9637.2 R80140.2
VR_RDY: PR4615.2 PR4665.2 R80146.1
VR_TT#: TP204.1 U9.4
VRAM1_VREFCA: C529.1 MEM3.M8 R885.1 R886.2
VRAM1_VREFDQ: C559.1 MEM3.H1 R924.2 R928.1
VRAM2_VREFCA: C163.1 MEM1.M8 R230.1 R1905.2
VRAM2_VREFDQ: C835.1 C1854.1 MEM1.H1 R202.2 R203.1
VRAM3_VREFCA: C1869.1 MEM4.M8 R1923.2 R1924.1
VRAM3_VREFDQ: C1867.1 C1868.1 MEM4.H1 R1921.2 R1922.1
VRAM4_VREFCA: C1861.1 MEM2.M8 R80087.1 R80088.2
VRAM4_VREFDQ: C1860.1 MEM2.H1 R945.1 R946.2
VRAM_ZQ1: MEM3.L8 R870.2
VRAM_ZQ2: MEM1.L8 R899.2
VRAM_ZQ3: MEM4.L8 R299.2
VRAM_ZQ4: MEM2.L8 R320.2
VREF: C4.2 U120.2
VREF_1: C140.1 U6.41
VREG_PCIAUX_PCH: Q3.D Q128.C R10.2 R13.1
VREG_PCIAUX_PCH_1: C1616.1 PC1.2 Q1211.G R13.2
VRP: C155.1 U6.38
VSUM_RC: PC14.2 PR34.2
VSUM_RR: PR42.2 PR51.1
VTT_EN: C1797.1 PU5104.7 R507.2 R1810.1 R80118.2 R80162.2 U501.4
WAKE_N: R1718.1 R1719.2 R80037.2 R80048.2 U16.21
WEA0#: GPU1.G25 MEM1.L3 MEM3.L3
WEA1#: GPU1.H10 MEM2.L3 MEM4.L3
WEBCAM_DET: PC126.2 R12.2 U109.114 WEBCM1.7
WP#_1: R9507.2 R9508.1 R9509.2 U9501.3
WP_PRO: RN9503.1(A) SCA1.40 U9502.7
XCLK_BIASREF: CPU1.E42 R80063.1
XDP_DBRESET#: CPU1.B5 R9925.1 R80046.2
XDP_DBRESET_XDP#: C9905.1 R9925.2 R9927.2 XDP1.48
XDP_PRDY#: CPU1.D56 TP9901.1 XDP1.5
XDP_PREQ#: CPU1.D61 R9934.2 XDP1.3
XDP_PRSENT_PIN60: R9928.2 R9929.2 R9931.1 XDP1.60
XDP_PRSNT_PIN1: R9902.2 XDP1.1
XDP_SMBCLK: R9912.1 XDP1.53
XDP_SMBDAT: R9911.1 XDP1.51
XDP_SYS_PWROK: C9903.1 R9908.2 R9910.1 XDP1.47
XDP_TCK_JTAGX: CPU1.A59 R9915.1 R9922.2 R80001.1
XDP_TCLK: CPU1.B61 R9915.2 R9921.1 R80003.1 XDP1.57
XDP_TCLK1: R9914.2 XDP1.55
XDP_TDI: CPU1.D60 R9916.2 R80002.1 XDP1.56
XDP_TDO: R9918.1 R9919.1 R9920.2 R9922.1 XDP1.52
XDP_TDO_CPU: CPU1.A61 R9919.2 R80000.1
XDP_TMS: CPU1.C60 R9917.2 R80005.1 XDP1.58
XDP_TRST#: CPU1.B59 CPU1.C61 R80004.1 XDP1.54
XRF_TDC2: C3452.1 XF1.9 XF1.10 XF2.9 XF2.10
XTALIN: C756.1 GPU1.AM28 R1879.1 X9505.1
XTALOUT: C757.1 GPU1.AK28 R1879.2 X9505.3
XTL_24M_X1_CPU: C12355.1 CPU1.E37 R80060.1 X9503.1
XTL_24M_X2_CPU: C12356.1 CPU1.E35 R80060.2 X9503.3
XTL_32K_X1_CPU: C12358.1 CPU1.AM18 R80061.1 X9504.1
XTL_32K_X2_CPU: C12357.1 CPU1.AM20 R80061.2 X9504.4
N35415300: Q9637.1 Q9637.3
N35418666: Q9639.1 Q9639.3
N37189306: Q9647.G Q9651.D R80239.2

Pads without a net: BAT2 1A 2A 3A 4A 5A 6A 7A 8A 9A 10A; CPU1 A3 A4 A6 A7 A11 A15 A25 A26 A27 A29 A31 A33 A36 A38 A40 A50 A52 A69 AB4 AB11 AB12 AB13 AC1 AC3 AD11 AD12 AF8 AF9 AF11 AF12 AF13 AG1 AG2 AG3 AG4 AH7 AH8 AH9 AH10 AH11 AH12 AK6 AK7 AK9 AK10 AK62 AL25 AL27 AL61 AM1 AM2 AM3 AM4 AN1 AN2 AN3 AN7 AN8 AN55 AP1 AP2 AP3 AP4 AP5 AP13 AP53 AP56 AR56 AT15 AU1 AU2 AU56 AW1 AW7 AW20 AW48 AW56 AW68 AW69 AW70 AW71 AY1 AY2 AY5 AY7 AY8 AY20 AY21 AY56 B2 B3 B11 B15 B25 B26 B27 B29 B31 B33 B36 B38 B40 B50 B69 B70 BA3 BA4 BA5 BA7 BA8 BB2 BB4 C2 C4 C7 C8 C11 C12 C15 C23 C24 C27 C28 C29 C31 C32 C33 C36 C37 C38 C50 C51 C52 C54 C70 C71 D1 D3 D4 D5 D7 D8 D12 D15 D23 D24 D27 D28 D29 D31 D32 D33 D36 D37 D38 D50 D51 D52 D54 D71 E1 E2 E3 E10 E25 E27 E28 E30 E38 E40 E48 E61 F6 F10 F25 F30 F46 F48 F50 F52 F60 F61 G1 G2 G3 G46 G50 H5 H10 H11 J5 J10 J68 J71 K45 K46 L7 M4 N1 N2 N3 N7 N11 N12 P1 P2 P3 P4 U4 U11 U12 W7 W8 W10 W11 W12; D5202 2; DIMM1 77 122 125 198; DIMM2 77 122 125 198; GPU1 AA1 AA3 AA5 AA6 AA29 AA31 AB2 AB4 AB7 AB8 AB9 AB11 AB12 AB13 AB23 AB25 AB26 AB27 AB30 AC1 AC3 AC5 AC6 AC7 AC8 AC10 AC11 AC13 AC14 AC20 AC23 AC25 AD2 AD4 AD7 AD9 AD10 AD11 AD13 AD16 AD20 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE8 AE9 AE10 AE11 AE13 AE16 AE19 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF19 AF20 AF22 AF23 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG14 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG23 AG24 AG25 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH14 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ13 AJ15 AJ17 AJ19 AJ21 AJ23 AJ25 AK1 AK3 AK5 AK6 AK8 AK14 AK16 AK18 AK20 AK22 AK24 AK26 AL7 AL9 AL13 AL15 AL17 AL19 AL21 AL23 AL25 AM3 AM5 AM6 AM8 AM12 AM14 AM16 AM18 AM20 AM22 AM24 AM26 J8 J22 J25 K13 K30 L9 L16 L17 L29 L31 M27 M28 M30 N3 N5 N6 N9 N26 N29 N31 P7 P23 P24 P26 P27 P28 P30 R29 R31 T7 T10 T23 T24 T26 T27 T28 T30 U1 U3 U5 U6 U10 U12 U23 U24 U26 U29 U31 V2 V4 V6 V12 V27 V28 V30 W1 W3 W5 W6 W7 W8 W9 W10 W23 W24 W29 W31 Y2 Y4 Y6 Y7 Y8 Y9 Y11 Y12 Y23 Y24 Y26 Y27 Y28 Y30; HDMI1 13 14; HDMI2 13 14; HDMI3 6 7; HDMI4 6 7; LPC1 10; MEM1 J1 J9 L1 L9 M7; MEM2 J1 J9 L1 L9 M7; MEM3 J1 J9 L1 L9 M7; MEM4 J1 J9 L1 L9 M7; NGFF1 64; PU8401 7; RN4301 1 8; RN9503 4 5; SCA1 21 22 24 25 26 27 28 29 30 42 43 47 48 65 66 67 69 70 71 72 96 97 98 99 100 101; TOUCH1 6 7; U6 15 17 37 45 46; U9 26 28 29 30; U12 3; U29 5 6; U109 20 50; U501 1; U4101 8 16 18 31 40 42 43 46 54 55 57; U6701 2 3; U9626 1; XDP1 61 62 63 64

## Via types
v1: diameter 0.762, hole 0.381, TOP to BOTTOM, 672 vias
v2: diameter 0.66, hole 0.33, TOP to BOTTOM, 1315 vias
v3: diameter 0.559, hole 0.305, TOP to BOTTOM, 2321 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 1631 vias
v5: diameter 0.711, hole 0.406, TOP to BOTTOM, 1025 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V_CPU_XDP_AB: length 26.5
  TOP w0.254: XDP1.43 30.33,216.23 31.3,217.2 32.45,217.2 32.86,217.61 32.86,218.25 31.86,219.25 19.73,219.25 18.96,220.03 v3(18.96,222.76)
  BOTTOM w0.254: R9905.2 22.41,223.55 v2(20.07,223.55) 19.74,223.55 v3(18.96,222.76)
1V_CPU_XDP_CD: length 8.8
  TOP w0.254: XDP1.44 30.33,222.52 v3(29.97,222.88)
  BOTTOM w0.254: R9924.2 24.32,223.37 27.24,223.37 v2(27.57,223.7) 27.9,223.37 29.49,223.37 v3(29.97,222.88)
1V_DCPDSW: length 4.1
  TOP w0.127: CPU1.AL1 87.79,144.9 88.49,144.21
  TOP w0.254: 88.49,144.21 89.11,143.59 v1(89.11,142.6) 89.11,141.77 C2103.1
1V_EDRAM: length 2.4
  TOP w0.305: v4(82.46,178.82) 82.46,179.07 82.86,179.48 CPU1.AB62 ; v4(79.28,178.94) 79.2,179.02 CPU1.P62 ; v4(81.06,178.94) 81.03,178.97 CPU1.V62
  vias: v2(80.07,178.79)
1V_EOPIO: length 4
  TOP w0.305: CPU1.AE62 CPU1.AG62 85.3,179.34 v4(85.3,178.77)
  BOTTOM w0.305: R80128.2 85.3,179.18 v4(85.3,178.77) 85.25,178.71 R80014.1
1V_S3:
  vias: v1(49.84,138.43)
1V_SIP_S5: length 27.8
  TOP w0.127: v4(82.57,156.39) 82.57,156.39 82.57,155.31 82.15,154.9 CPU1.Y18 82.8,154.11 CPU1.AB17
  TOP w0.254: R1136.2 77.31,135.56 v3(77.68,135.93)
  L4 w0.254: v3(77.68,135.93) 77.12,136.49 77.12,144.52 79.64,147.03 79.64,151.86 79.61,151.89 79.61,152.6 82.57,155.57 v4(82.57,156.39)
  BOTTOM w0.254: v2(77.33,135.1) 77.33,135.58 v3(77.68,135.93)
1V_VCC19P2: length 20.5
  TOP w0.254: CPU1.A14 71.97,152.53 71.01,152.53 70.83,152.35 68.78,152.35 68.28,151.85 68.28,150.12 66.96,148.8 66.96,145.27 66.07,144.38 66.07,144.01 65.14,143.08 64.77,143.08 63.27,141.58 v1(62.57,141.58) 61.53,141.58 60.49,142.63 60.49,142.68 R1131.2
1V_VCC24TBT: length 18.8
  TOP w0.254: CPU1.A10 71.56,150.01 71.11,149.56 71.11,149.51 69.7,148.11 68.57,148.11 C2116.1 67.34,146.88 67.34,145.11 66.47,144.23 66.47,143.86 65.3,142.7 64.93,142.7 62.64,140.41 60.28,140.41 v1(60.18,140.51) 60.04,140.65 R1122.2
1V_VCCAMPHYPLL: length 6
  TOP w0.254: CPU1.K15 77.32,152.61 77.76,152.61 CPU1.L15 77.96,152.44 v4(78.13,152.27)
  BOTTOM w0.254: R1102.2 77.74,154.58 C1181.1 77.63,154.13 78.32,153.44 v2(78.32,153.09) 78.32,152.46 v4(78.13,152.27)
1V_VCCAPLL: length 16.7
  TOP w0.102: v4(80.19,151.66) 80.19,151.92 80.38,152.11 80.38,152.11 81.08,152.81 CPU1.V15
  BOTTOM w0.152: 79.58,147.23 79.58,147.87 79.57,147.87 79.57,150.06 79.66,150.15 79.66,151.14 v4(80.19,151.66)
  BOTTOM w0.254: R1120.2 v2(77.5,140.51) 77.5,141.1 77,141.6 77,143.68 77.84,144.53 78.87,144.53 79.58,145.23 79.58,147.23
1V_VCCAPLLEBB: length 5.2
  TOP w0.191: CPU1.N18 78.8,154.86 79.19,155.25 79.19,156.33 v4(79.22,156.35)
  BOTTOM w0.254: R1101.2 v2(80.55,154.61) 80.22,154.94 79.54,155.63 C1173.1 79.47,156.1 v4(79.22,156.35)
1V_VCCDTS: length 38.2
  TOP w0.254: v3(60.87,145.92) 60.29,145.92 R1130.2 ; CPU1.T1 79.52,144.69 79.52,144.5 78.87,143.86 78.87,138.63 78.62,138.38 77.52,138.38 74.32,135.18 63.56,135.18 v1(63.28,134.9) 62.57,134.9 61.71,135.76 v3(61.37,135.76)
  L3 w0.254: v3(60.87,145.92) 59.95,145.01 59.95,137.19 v3(61.37,135.76)
1V_VCCF24NS: length 60.5
  TOP w0.254: v4(77.54,156.35) 77.54,155.83 CPU1.L19 ; v3(45.12,140.97) 45.12,140.54 C2115.1 R1125.2
  L3 w0.254: v4(77.54,156.35) 76.87,156.35 76.61,156.61 76.61,162.56 74.07,165.1 v4(74.07,167)
  L4 w0.191: 74.84,156.46 74.86,156.49 76.22,156.49 76.36,156.35 v4(77.54,156.35)
  L4 w0.203: 74.01,155.64 74.84,156.46
  L4 w0.254: 74.01,155.64 70.52,152.15 59.76,152.15 57.44,149.82 57.44,144.15 56.04,142.75 46.9,142.75 v3(45.12,140.97)
  BOTTOM w0.254: R80063.2 74.1,167.03 v4(74.07,167) ; v3(45.12,140.97) v2(45.12,141.81)
1V_VCCF100: length 51.7
  TOP w0.089: v4(77.53,157.78) 77.1,157.35 77.1,157.21 76.83,156.94 76.83,155.7 CPU1.K19
  TOP w0.254: R1114.2 C2113.1 43.01,140.59 43.03,140.59 v3(43.09,140.65)
  L4 w0.178: v4(77.53,157.78) 76.15,157.78 75.79,157.41 74.5,157.41 73.33,156.25 73.33,155.45
  L4 w0.254: v3(43.09,140.65) 43.78,140.65 46.26,143.13 55.41,143.13 56.68,144.4 56.68,149.73 59.47,152.53 70.41,152.53 73.33,155.45
  BOTTOM w0.254: v2(43.9,140.36) 43.61,140.65 v3(43.09,140.65)
1V_VCCF100OC: length 50.4
  TOP w0.254: R1132.2 C2114.1 47.15,140.54 v3(47.15,141.1) ; CPU1.N20 78.75,156.06 78.39,156.42 78.39,157.57 79.14,158.32 v4(79.28,158.32)
  L4 w0.203: v4(79.28,158.32) 79.24,158.32 78.65,157.72 78.65,156.43 76.88,154.66 74.55,154.66 74.2,154.32 74.2,154.31
  L4 w0.254: v3(47.15,141.1) 48.04,141.99 56.93,141.99 58.83,143.89 58.83,149.48 60.1,150.75 70.97,150.75 74.2,153.98 74.2,154.31
  BOTTOM w0.254: v3(47.15,141.1) v2(47.99,141.1)
1V_VCCF135: length 39.1
  TOP w0.254: CPU1.L21 78.01,156.76 78.01,157.73 79.21,158.93 79.23,158.93 v4(79.28,158.98) ; v3(60.87,146.69) 60.36,147.19 R1121.2
  L4 w0.203: v4(79.28,158.98) 79.95,158.31 79.95,155.87 76.92,152.83 74.43,152.83 74.38,152.79
  L4 w0.254: 74.38,152.79 70.69,149.1 68.56,149.1 62.16,142.7 62.16,142.02 61.85,141.71 60.89,141.71 60.33,142.27 60.33,146.15 v3(60.87,146.69)
  BOTTOM w0.254: v4(79.28,158.98) 79.81,158.98 v2(80.22,158.57)
1V_VCCFHV: length 79.7
  TOP w0.127: CPU1.AK20 87.06,156.06 v4(86.76,156.36)
  TOP w0.254: v3(60.87,144.27) 60.74,144.15 R1133.2
  L3 w0.254: v3(85.82,120.97) 84.82,120.97 79.67,126.11 74.17,126.11 60.87,139.41 v3(60.87,144.27)
  BOTTOM w0.254: v4(86.76,156.36) 86.7,156.36 85.04,154.71 85.04,152.98 85.02,152.96 85.02,151.18 86.16,150.04 86.16,149.37 86.14,149.35 86.14,148.38 87.31,147.22 87.31,146.28 v2(89.21,144.37) 89.31,144.27 89.31,139.25 88.07,138.01 88.07,134.71 88.91,133.87 88.91,130.33 89.77,129.47 89.77,124.92 v2(87.94,123.09) v3(85.82,120.97)
1V_VCCFUSEPRG: length 4.3
  TOP w0.254: CPU1.G20 75.38,155.9 v4(75.38,156.03)
  BOTTOM w0.254: v2(73.96,155.37) 74.26,155.68 75.03,155.68 v4(75.38,156.03) 75.11,156.31 74.46,156.31 73.79,156.97 R703.2
1V_VCCGT: length 50.6
  TOP w0.127: CPU1.A58 71.06,177.27 70.28,176.49 69.67,176.49 v4(69.25,176.91) ; CPU1.A62 72,179.76 70.51,179.76 v4(70.33,179.94) ; CPU1.A53 71.88,174.79 70.52,173.43 v4(70.52,173.35) ; CPU1.A66 71.93,182.3 71.93,182.3 71.82,182.41 v4(71.37,182.41)
  TOP w0.254: v4(71.16,172.84) 71.41,172.59 71.73,172.59 CPU1.A48 ; PL4801.2 PG4805.2 ; PG4822.2 PL4802.2
  TOP w0.508: 61.12,189.19 PT4801.1 ; PT4801.1 61.12,191.3 ; PT4801.1 60.07,190.25 ; PT4801.1 62.17,190.25 ; PT4802.1 68.4,195.83 ; PT4802.1 66.29,195.83 ; PT4802.1 67.34,196.89 ; PT4802.1 67.34,194.78
  L3 w0.508: 60.07,190.25 PT4801.1 ; PT4801.1 61.12,189.19 ; PT4801.1 61.12,191.3 ; PT4801.1 62.17,190.25 ; 66.29,195.83 PT4802.1 67.34,196.89
  L4 w0.508: v3(77.12,174.37) 75.47,172.72 71.28,172.72 v4(71.16,172.84) 70.65,173.35 v4(70.52,173.35) 69.25,174.62 v4(69.25,176.91)
  BOTTOM w0.508: 66.29,195.83 PT4802.1 67.34,194.78 ; PT4801.1 62.17,190.25 ; PT4801.1 61.12,191.3 ; PT4801.1 60.07,190.25 ; PT4801.1 61.12,189.19 ; v3(78.11,195.29) 78.14,195.33 78.14,197.99 C12383.1
  vias: v2(58.4,215.14) v2(62.21,185.47) v2(62.85,198.7) v2(78.32,173.43) v2(80.4,192.68) v2(82.96,186.06) v3(77.12,178.05) v3(77.12,177.16) v3(77.12,176.15) v3(77.12,175.26) v3(77.38,172.85) v3(77.38,172.09) v3(78.27,178.05) v3(78.27,177.16) v3(78.27,176.15) v3(78.27,175.26) v3(78.27,174.37) v3(79.28,172.72) v3(79.41,178.05) v3(79.41,177.16) v3(79.41,176.15) v3(79.41,175.26) v3(79.41,174.37) v4(78.29,184.99) v4(78.29,184.34) v4(78.29,183.69) v4(78.29,183.03) v4(78.29,182.38) v4(78.29,181.73) v4(78.29,181.08) v4(78.29,180.43) v4(80.12,184.99) v4(80.12,184.34) v4(80.12,183.69) v4(80.12,181.08) v4(80.12,180.43) v4(81.95,184.99) v4(81.95,184.34) v4(81.95,182.38) v4(81.95,180.43) v5(59.85,213.72) v5(60.1,205.36) v5(60.23,208.28) v5(60.23,207.14) v5(60.23,203.45) v5(60.23,202.31) v5(60.23,193.17) v5(60.23,192.02) v5(60.36,188.34) v5(60.36,187.2) v5(60.87,213.72) v5(61.12,205.36) v5(61.25,208.28) v5(61.25,207.14) v5(61.25,203.45) v5(61.25,202.31) v5(61.25,193.17) v5(61.25,192.02) v5(61.37,188.34) v5(61.37,187.2) v5(61.88,213.72) v5(62.14,205.36) v5(62.26,208.28) v5(62.26,207.14) v5(62.26,203.45) v5(62.26,202.31) v5(62.26,193.17) v5(62.26,192.02) v5(62.39,188.34) v5(62.39,187.2) v5(62.64,206.25) v5(62.64,204.47) v5(62.9,213.72) v5(63.15,205.36) v5(63.28,208.28) v5(63.28,207.14) v5(63.28,203.45) v5(63.28,202.31) v5(64.55,196.6) v5(64.55,195.33) v5(65.57,196.6) v5(65.57,195.33) v5(78.77,192.15) v5(78.97,185.94) v5(79.54,192.91) v5(79.92,189.74) v5(80.32,187.13) v5(80.3,186.27) v5(80.42,193.68) v5(80.68,190.5) v5(81.23,187.06) v5(81.24,186.2)
1V_VCCGTUS: length 29.6
  TOP w0.102: CPU1.BB57 95.75,177.24 97.47,178.97 v4(97.78,178.97)
  TOP w0.127: CPU1.BB66 94.77,182.22 v4(95.26,182.72)
  TOP w0.152: v3(86.27,187.26) 86.67,186.86 86.67,186.17 86.9,185.94 86.9,185.06 CPU1.AK70
  TOP w0.254: CPU1.AL53 86.68,174.32 v4(86.68,174.32) ; v4(86.68,168.83) 86.68,168.83 CPU1.AL43 ; v4(86.68,170.66) 86.68,170.66 CPU1.AL46 ; v4(86.68,176.14) 86.68,176.15 CPU1.AL56 ; CPU1.AL50 86.68,172.49 v4(86.68,172.49)
  TOP w0.305: CPU1.AU58 91.2,177.39 v4(90.87,177.06) ; CPU1.AU63 91.2,180.13 v4(90.87,179.81)
  BOTTOM w0.381: v3(86.27,187.26) 86.32,187.26 87.98,185.6 88.25,185.33 88.25,181.23 v2(87.97,180.95) 87.73,180.71 87.73,177.74 87.74,177.72 87.74,177.32
  BOTTOM w0.508: v4(95.26,182.72) 97.78,180.2 v4(97.78,178.97)
  vias: v2(87.36,170.26) v2(96.65,179.45)
1V_VCCIO: length 199.9
  TOP w0.254: CPU1.AM42 87.49,167.92 CPU1.AL42 87.45,167.94 86.57,167.94 v4(86.52,167.89) ; v3(12.48,185.42) 12.48,184.72 R80200.1
  TOP w0.305: R9906.1 43.21,225.17 v3(42.96,225.43)
  L4 w0.381: v4(86.52,167.89) 86.52,167.78 87.1,167.21 87.1,162.37 v4(86.39,161.67)
  L4 w0.508: v4(71.15,157.99) 73.06,159.89 77.39,159.89 77.42,159.93 79.73,159.93 80.48,159.18 82.15,159.18 82.2,159.23 84.13,159.23 85.12,158.25 86.93,158.25 87.28,158.59 87.28,160.32 86.56,161.04 v4(86.39,161.04)
  BOTTOM w0.254: v5(40.8,136.91) v2(40.8,135.76) 40.8,132.97 41.74,132.03 41.74,131.49 41.44,131.19 37.63,131.19 37.31,130.87 32.23,130.87 28.69,134.41 15.74,134.41 13.37,136.78 13.37,149.22 12.48,150.11 v2(12.48,178.18) v3(12.48,185.42) 11.84,185.42 8.16,189.1 8.16,203.72 4.18,207.71 4.18,214.84 12.86,223.52 v2(13.24,223.52) 13.47,223.29 14.36,223.29 15.65,222 33.45,222 35.41,223.95 40.24,223.95 v2(40.44,224.16) 41.69,224.16 v3(42.96,225.43)
  BOTTOM w0.305: v4(71.15,157.99) 71.34,157.8 R709.2
  BOTTOM w0.381: R801.1 85.82,168.91 86.52,168.21 v4(86.52,167.89) 86.71,168.08 C1153.1
  BOTTOM w0.508: v5(70.01,144.4) 70.87,144.4 v2(70.9,144.42) ; R80024.2 v5(40.8,136.91)
  vias: v5(38.74,136.91) v5(39.76,136.91) v5(70.01,143.51) v5(70.01,142.62)
1V_VCCMPHYAON: length 57.4
  TOP w0.127: C2104.1 77.04,141.5 77.04,144.24 77.19,144.55 77.19,144.69 CPU1.L1
  TOP w0.178: v4(76.03,155.12) 76.44,155.12 76.74,154.82 76.74,154.69 76.74,154.68 76.74,154.6 77.12,154.22 CPU1.K17
  TOP w0.254: v3(60.87,145.03) 60.74,145.16 R1134.2 ; C2104.1 76.89,141.31 76.89,138.66 74.17,135.94 v3(73.52,135.94) 73.49,135.97 65.1,135.97 64.82,136.25 v3(62.67,136.25)
  L3 w0.254: v3(60.87,145.03) 60.33,144.5 60.33,138.58 v3(62.67,136.25)
  BOTTOM w0.254: v4(76.03,155.12) 77.62,153.54 77.62,153.33 77.63,153.31 77.63,149.09 77.38,148.84 77.38,145.8 v2(74.73,143.15) 72.87,141.29 72.87,136.59 v3(73.52,135.94) ; v3(62.67,136.25) v2(62.67,137.06)
1V_VCCMPHYGTAON: length 31.7
  L4 w0.508: v4(79.11,152.32) 78.54,152.88 77.87,152.88 77.38,152.39 77.38,151.94 75.93,150.5 74.46,150.5 71.53,147.57 68.11,147.57 62.67,142.14 62.67,141.81 62.06,141.2 61.73,141.2 59.47,138.94 54.29,138.94 v3(53.98,138.63)
  vias: v2(80.53,153.19)
1V_VCCPRIM: length 53.3
  TOP w0.127: v4(79.26,157.68) 80.05,156.88 80.05,155.18 CPU1.P18 ; CPU1.AB19 CPU1.AB20 83.3,156.37 83.3,157.02 82.94,157.37
  TOP w0.254: v4(79.26,157.68) 79.36,157.68 80.71,159.04 81.36,159.04 81.65,158.75 81.65,158.67 82.94,157.37
  TOP w0.508: v3(51.95,140.21) 52.01,140.27 C2101.1 R1112.2
  L4 w0.178: v4(79.26,157.68) 79.67,157.26 79.67,156.18 77.24,153.75 74.54,153.75 74.06,153.27
  L4 w0.203: 74.06,153.27 74.06,153.17
  L4 w0.508: 74.06,153.17 71.13,150.24 60.31,150.24 59.34,149.27 59.34,142.72 56.83,140.21 v3(51.95,140.21)
  BOTTOM w0.508: v3(51.95,140.21) v2(51.95,141.02)
1V_VCCPRIM_CORE: length 65.2
  TOP w0.254: CPU1.V20 81.44,156.19 81.44,156.59 CPU1.V21 81.14,156.89 v4(81.14,157.86)
  TOP w0.305: v4(84.27,156.39) 84.24,156.36 84.24,155.81 84.63,155.41 CPU1.AF19 CPU1.AF18
  L3 w0.254: v4(81.14,157.86) 81.18,157.91 82.28,157.91 83.8,156.39 v4(84.27,156.39)
  L4 w0.254: v4(81.14,157.86) 79.54,159.46 79.08,159.46 78.88,159.26 74.53,159.26 73.06,157.79 73.06,156.44 69.52,152.91 59.06,152.91 55.91,149.76 55.91,144.53 54.9,143.51 46.1,143.51 44.07,141.48 v3(43.09,141.48)
  BOTTOM w0.254: v4(84.27,156.39) 83.86,156.39 C2102.1 82.77,157.16 v2(82.05,157.89) 81.16,157.89 v4(81.14,157.86)
  BOTTOM w0.508: R80024.1 R80023.2 R80025.2 42.71,141.48 v3(43.09,141.48)
1V_VCCSA: length 47
  TOP w0.254: PG5002.2 PL5001.2
  TOP w0.508: 49.94,163.66 PT5001.1 ; PT5001.1 51,164.72 ; PT5001.1 49.94,165.77 ; PT5001.1 48.89,164.72
  L4 w0.305: v5(52.1,166.88) 57.21,161.77 57.21,153.19 51.72,147.7 51.72,145.67 50.83,144.78 45.63,144.78 44.61,143.76 v3(42.07,143.76)
  BOTTOM w0.305: R80025.1 v3(42.07,143.76)
  BOTTOM w0.508: 48.89,164.72 PT5001.1 ; PT5001.1 49.94,163.66 ; PT5001.1 49.94,165.77 ; PT5001.1 51,164.72
  vias: v2(44.38,168.07) v2(56.52,166.34) v2(69.15,158.72) v2(78.39,159.38) v3(77.12,161.54) v3(77.12,160.53) v4(71.38,161.09) v4(72.07,161.09) v4(74.73,160.61) v4(85.38,160.27) v4(86.61,159.56) v4(86.56,158.89) v5(43.85,166.62) v5(44.99,166.62) v5(46.36,163.86) v5(47.4,163.83) v5(52.74,167.64)
1V_VCCSFR: length 52.6
  TOP w0.203: CPU1.K20 77.09,156.1 77.09,156.68 CPU1.K21
  TOP w0.254: R708.1 49.86,137.48 v3(49.82,137.52) ; CPU1.K21 77.14,156.71 77.51,157.08 v4(77.51,157.13)
  L4 w0.178: v4(77.51,157.13) 77.99,156.65 77.99,156.17 77.39,155.57 74.55,155.57 74.19,155.21
  L4 w0.254: v3(49.82,137.52) 49.82,138.36 47.97,140.21 47.28,140.21 46.62,140.88 46.62,141.32 47.67,142.37 56.68,142.37 58.2,143.89 58.2,149.89 59.44,151.13 70.87,151.13 72.15,152.41 72.15,153.16 74.19,155.21
  BOTTOM w0.254: C720.1 78.15,157.67 77.61,157.13 v4(77.51,157.13) ; v2(49,137.92) 49.06,137.92 49.46,137.52 v3(49.82,137.52)
1V_VCCSRAM: length 14.5
  TOP w0.102: CPU1.AF21 84.69,156.69 84.69,156.09 CPU1.AF20
  TOP w0.254: CPU1.T19 CPU1.T20 80.79,156.38 v4(80.89,156.38) ; v4(84.34,157.15) 84.34,157.04 CPU1.AF21
  L3 w0.254: v4(80.89,156.38) 80.89,156.89 81.57,157.57 82.08,157.57 83.74,155.91 85.28,155.91 85.58,156.21 85.58,156.61 85.27,156.92 84.57,156.92 v4(84.34,157.15)
  BOTTOM w0.508: C1179.1 81.06,156.55 v4(80.89,156.38) 80.89,156.38 81.4,155.87 C1175.1 v2(82.35,155.63) 82.43,155.63 82.79,155.27 R1106.2
1V_VCCST: length 205.5
  TOP w0.127: CPU1.A18 70.9,154.97 v4(70.75,154.81)
  TOP w0.254: v3(78.23,207.29) 78.23,207.3 76.26,209.27 R80158.1 ; R80029.1 v3(66.58,182.18) 66.45,182.05 R419.1 64.93,182.82 64.93,184.02 64.68,184.28 64.17,184.28 63.79,184.66 63.79,185.42 64.23,185.86 ; 64.23,185.86 R80028.1 66.39,185.86 v1(66.58,186.06) 67.42,185.22 R80027.1 ; 64.23,185.86 63.79,186.31 63.79,186.88 R603.2 64.68,188.47 64.37,188.77 v3(64.37,190.7) 64.37,191.85 65.31,192.79 69.18,192.79 R80043.1 ; PR4609.1 PR4618.1 PC4622.1 PR4616.1 ; PR4664.1 PR4616.1 ; PR4616.1 v3(22.54,191.96)
  L3 w0.254: v3(64.37,190.7) 64.37,191.85 65.31,192.79 65.9,192.79 75.6,202.49 75.6,204.6 78.23,207.23 v3(78.23,207.29)
  L4 w0.254: 60.25,175.62 63.35,178.71 64.06,178.71 65.06,179.71 65.06,180.66 v3(66.58,182.18) ; 60.25,175.62 52.91,175.62 47.66,170.37 25.75,170.37 18.6,177.52 18.6,179.7 17.74,180.57 17.74,190.17 19.53,191.96 v3(22.54,191.96) ; 60.25,175.62 63,172.87 63,170.92 68.69,165.23 71.58,165.23 71.85,165.5 73.6,165.5 74.63,164.46 74.63,162.86 70.07,158.3 70.07,155.49 v4(70.75,154.81)
  BOTTOM w0.381: 65.06,151.51 65.31,151.51 67.98,154.18 70.11,154.18 v4(70.75,154.81)
  BOTTOM w0.762: 65.06,151.51 59.47,151.51 58.45,150.5 54.39,150.5 52.99,149.1 52.99,137.64 v2(52.66,137.31) 52.66,137.3 v3(51.98,136.61)
1V_VCCSTG: length 134.1
  TOP w0.254: R9918.2 36.99,224.92 v3(36.48,225.43) ; R79997.2 65.63,178.18 v3(64.55,178.18) 64.02,177.65 64.02,177.2 64.43,176.78 65.36,176.78 65.88,176.26 R79999.2 66.49,176.38 66.87,176.38 R80001.2 ; R79997.2 66.01,178.56 R80005.2 ; R79997.2 65.16,178.78 65.16,179.62 R80000.2 ; v3(64.55,175.26) 64.68,175.13 R79998.2 65.82,174.43 R80002.2 ; CPU1.A22 71.95,157.51 70.98,157.51 v4(70.82,157.35) ; R401.1 67.33,187.07 v3(66.58,187.07)
  L4 w0.254: v3(66.58,187.07) 67.62,186.03 67.62,182.47 66.76,181.61 66.72,181.61 65.82,180.71 65.82,179.45 v3(64.55,178.18) 64.02,177.65 64.02,175.79 v3(64.55,175.26) 64.55,170.19 68.8,165.94 73.64,165.94 74.97,164.61 74.97,162.57 70.62,158.22 70.62,157.56 v4(70.82,157.35) ; v3(36.48,225.43) 38.03,226.97 50.83,226.97 51.81,226 63.5,226 68.62,220.88 v3(68.74,220.88)
  BOTTOM w0.254: v2(36.48,224.61) v3(36.48,225.43) ; v3(66.58,187.07) 67.27,187.76 67.27,190.75 70.52,194 70.52,218.57 69.25,219.84 v2(69.25,220.01) 69.25,220.37 v3(68.74,220.88) ; v3(64.55,175.26) 65.18,175.26 v2(65.36,175.08)
  BOTTOM w0.381: v4(70.82,157.35) 70.82,157.34 71.25,156.91 R709.1 72.8,156.91 R703.1 C717.1
1V_XDP_S5: length 13.4
  TOP w0.254: R9934.1 v3(15.53,225.93)
  BOTTOM w0.254: R9932.1 C9904.1 25.37,223.96 24.04,225.3 R9924.1 R9905.1 22.39,225.3 21.56,224.47 C9902.1 19.77,224.47 19.38,224.87 R9901.2 16.39,224.87 v2(16.01,225.25) 15.53,225.73 v3(15.53,225.93)
3V3AUX: length 2.6
  BOTTOM w0.203: U14.27 174.19,148.81 174.15,148.84
  BOTTOM w0.508: R79842.2 v2(174.53,154.56)
3V_VA: length 6.9
  TOP w0.203: U6.23 164.39,72.67 164.63,72.44 ; U6.25 165.62,74.06
  TOP w0.508: L21.2 v3(161.96,66.8)
  L3 w0.508: v3(161.96,66.8) 163.48,66.8 165.51,68.83 v3(165.51,69.22)
  vias: v1(166.48,69.06)
+19V_AMP_AVCC: length 4.6
  TOP w0.305: 155.61,49.28 155.74,49.15 U9625.12
  TOP w0.508: 155.61,49.28 155.53,49.35 v1(155.51,49.35) 155.51,49.38 154.72,50.16 C246.1 R380.2
+19V_AMP_PVCC: length 14.4
  L3 w0.762: v5(155.61,48.13) 155.61,46.1 157.39,44.32 163.1,44.32 v5(166.02,47.24)
  vias: v1(163.86,48.49)
+VCCPRTC_3P3: length 27.7
  TOP w0.127: CPU1.AK19 87.8,156.03 v4(88.27,156.03) ; v4(96.55,151.51) 96.27,151.51 95,152.77 94.1,152.77 CPU1.BB14
  TOP w0.254: R2106.2 102.46,150.94 C2121.2 C2120.1 100.43,151.38 96.68,151.38 v4(96.55,151.51)
  BOTTOM w0.203: 92.16,156.44 92.13,156.41 91.59,156.41 91.51,156.49 88.73,156.49 v4(88.27,156.03)
  BOTTOM w0.254: 92.16,156.44 92.43,156.71 94.28,156.71 95.14,155.84 98.07,155.84 98.78,155.13 98.78,153.05 v2(98.38,152.65) 97.24,151.51 v4(96.55,151.51)
AGND: length 67.5
  TOP w0.203: v3(167.17,74.93) 166.64,75.45 U6.28 ; v3(164.04,72.1) 164.04,72.22 163.99,72.26 U6.22 ; 162.38,81.22 162.85,80.75 162.85,80.26 162.79,80.21 U6.42
  TOP w0.305: v3(160.41,52.83) 160.05,52.47 U9625.4 ; U9615.6 160.6,61.3 v3(160.94,60.96)
  TOP w0.381: C11359.2 C11358.2 154.72,63.83 v3(154.21,63.32)
  TOP w0.508: R79988.2 159.66,54.14 160.35,53.45 160.35,53.27 160.41,53.21 v3(160.41,52.83) ; R1193.2 167.45,86.11 Q28.S 168.66,86.26 v3(168.82,86.11) ; v3(155.99,56.52) 155.93,56.45 R79825.2 ; R386.2 162.34,60.02 161.98,60.02 161.04,60.96 v3(160.94,60.96) 160.46,60.96 160.18,60.68 C12375.1 R8516.2 ; R79987.1 163.49,55.05 162.82,55.73 v3(162.82,55.93) ; C268.2 82.52,37.91 v3(82.46,37.85) ; v3(153.45,52.32) 153.13,52.01 R79824.2 ; v3(85.5,37.85) 85.44,37.91 C267.2 ; v3(168.31,78.11) 168.05,78.11 167.61,78.55 R268.2 ; C160.2 171.8,77.91 v3(171.86,77.85) ; C12333.2 165.58,52.13 v3(166.15,52.7) ; v3(152.69,58.67) 152.69,58.99 152.5,59.18 R379.1 ; C246.2 154.34,52.6 v3(154.11,52.83) ; R216.2 178.85,82.75 v3(179.1,83.01) ; R301.2 159.55,80.26 v3(159.42,80.14) ; v3(171.86,74.93) 171.8,74.87 C157.2 ; R387.1 159.55,57.28 C12266.1 C250.1 v3(162.82,57.28) 162.97,57.28 163.05,57.35 R382.1 ; v3(164.04,72.1) 164.05,72.08 C495.1 164.05,70.55 C493.2 v3(163.74,69.22) ; R221.2 v3(173.64,81.03) ; R215.2 v3(159.16,86.11) ; R385.2 v3(156.12,60.83) ; C1491.2 v3(162.21,69.22) ; Q9643.S 162.5,64.55 162.47,64.52 v3(161.7,64.52) 161.45,64.77 R300.2 ; C147.1 v3(166.56,81.03) ; v3(168.18,82.68) 167.24,82.68 C146.2 ; 162.38,81.22 161.7,81.89 C140.2 161.42,82.58 161.42,83.31 ; v3(82.33,32.38) 82.9,32.38 C12386.2 ; C144.2 161.37,84.53 v3(161.37,83.36) 161.42,83.31 ; 161.42,83.31 C145.1 ; C154.2 171.71,79.4 v3(171.74,79.38) ; v3(168.18,83.82) 167.75,83.82 167.11,84.45 C450.2 ; UHS1.5 173.27,72.96 C159.2 R281.2 ; C134.2 v3(172.63,81.03) ; v3(167.67,69.22) 168.05,69.6 C485.2 168.05,70.93 C483.2 ; C155.2 v3(171.74,81.41)
  BOTTOM w0.508: v2(163.84,55.37) 163.56,55.37 163,55.93 v3(162.82,55.93) ; v2(178.95,83.82) 179.05,83.72 179.05,83.06 v3(179.1,83.01) ; v3(161.37,83.36) v2(162.19,83.36)
